#define RUBY_REVISION 67958
