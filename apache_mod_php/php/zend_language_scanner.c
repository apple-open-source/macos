#define yy_create_buffer zend_create_buffer
#define yy_delete_buffer zend_delete_buffer
#define yy_scan_buffer zend_scan_buffer
#define yy_scan_string zend_scan_string
#define yy_scan_bytes zend_scan_bytes
#define yy_flex_debug zend_flex_debug
#define yy_init_buffer zend_init_buffer
#define yy_flush_buffer zend_flush_buffer
#define yy_load_buffer_state zend_load_buffer_state
#define yy_switch_to_buffer zend_switch_to_buffer
#define yyin zendin
#define yyleng zendleng
#define yylex zendlex
#define yyout zendout
#define yyrestart zendrestart
#define yytext zendtext

/* A Lexical scanner generated by flex */

/* Scanner skeleton version:
 * $Header: /cvs/root/apache_mod_php/php/zend_language_scanner.c,v 1.1 2003/03/14 10:54:19 zarzycki Exp $
 */

#define FLEX_SCANNER
#define YY_FLEX_MAJOR_VERSION 2
#define YY_FLEX_MINOR_VERSION 5

#include <stdio.h>


/* cfront 1.2 defines "c_plusplus" instead of "__cplusplus" */
#ifdef c_plusplus
#ifndef __cplusplus
#define __cplusplus
#endif
#endif


#ifdef __cplusplus

#include <stdlib.h>
#if HAVE_UNISTD_H
#include <unistd.h>
#endif

/* Use prototypes in function declarations. */
#define YY_USE_PROTOS

/* The "const" storage-class-modifier is valid. */
#define YY_USE_CONST

#else	/* ! __cplusplus */

#if __STDC__

#define YY_USE_PROTOS
#define YY_USE_CONST

#endif	/* __STDC__ */
#endif	/* ! __cplusplus */

#ifdef __TURBOC__
 #pragma warn -rch
 #pragma warn -use
#include <io.h>
#include <stdlib.h>
#define YY_USE_CONST
#define YY_USE_PROTOS
#endif

#ifdef YY_USE_CONST
#define yyconst const
#else
#define yyconst
#endif

#undef YY_USE_PROTOS
#define YY_USE_PROTOS

#ifdef YY_USE_PROTOS
#define YY_PROTO(proto) proto
#else
#define YY_PROTO(proto) ()
#endif

/* Returned upon end-of-file. */
#define YY_NULL 0

/* Promotes a possibly negative, possibly signed char to an unsigned
 * integer for use as an array index.  If the signed char is negative,
 * we want to instead treat it as an 8-bit unsigned char, hence the
 * double cast.
 */
#define YY_SC_TO_UI(c) ((unsigned int) (unsigned char) c)

/* Enter a start condition.  This macro really ought to take a parameter,
 * but we do it the disgusting crufty way forced on us by the ()-less
 * definition of BEGIN.
 */
#define BEGIN yy_start = 1 + 2 *

/* Translate the current start state into a value that can be later handed
 * to BEGIN to return to the state.  The YYSTATE alias is for lex
 * compatibility.
 */
#define YY_START ((yy_start - 1) / 2)
#define YYSTATE YY_START

/* Action number for EOF rule of a given start state. */
#define YY_STATE_EOF(state) (YY_END_OF_BUFFER + state + 1)

/* Special action meaning "start processing a new file". */
#define YY_NEW_FILE yyrestart( SCNG(yy_in) TSRMLS_CC )

#define YY_END_OF_BUFFER_CHAR 0

/* Size of default input buffer. */
#define YY_BUF_SIZE 16384

typedef struct yy_buffer_state *YY_BUFFER_STATE;

extern int yyleng;


#define EOB_ACT_CONTINUE_SCAN 0
#define EOB_ACT_END_OF_FILE 1
#define EOB_ACT_LAST_MATCH 2

/* The funky do-while in the following #define is used to turn the definition
 * int a single C statement (which needs a semi-colon terminator).  This
 * avoids problems with code like:
 *
 * 	if ( condition_holds )
 *		yyless( 5 );
 *	else
 *		do_something_else();
 *
 * Prior to using the do-while the compiler would get upset at the
 * "else" because it interpreted the "if" statement as being all
 * done when it reached the ';' after the yyless() call.
 */

/* Return all but the first 'n' matched characters back to the input stream. */

#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
		*yy_cp = yy_hold_char; \
		yy_c_buf_p = yy_cp = yy_bp + n - YY_MORE_ADJ; \
		YY_DO_BEFORE_ACTION; /* set up yytext again */ \
		} \
	while ( 0 )

#define unput(c) yyunput( c, yytext_ptr TSRMLS_CC )

/* The following is because we cannot portably get our hands on size_t
 * (without autoconf's help, which isn't available because we want
 * flex-generated scanners to compile on their own).
 */
typedef unsigned int yy_size_t;


struct yy_buffer_state
	{
	FILE *yy_input_file;

	char *yy_ch_buf;		/* input buffer */
	char *yy_buf_pos;		/* current position in input buffer */

	/* Size of input buffer in bytes, not including room for EOB
	 * characters.
	 */
	yy_size_t yy_buf_size;

	/* Number of characters read into yy_ch_buf, not including EOB
	 * characters.
	 */
	int yy_n_chars;

	/* Whether we "own" the buffer - i.e., we know we created it,
	 * and can realloc() it to grow it, and should free() it to
	 * delete it.
	 */
	int yy_is_our_buffer;

	/* Whether this is an "interactive" input source; if so, and
	 * if we're using stdio for input, then we want to use getc()
	 * instead of fread(), to make sure we stop fetching input after
	 * each newline.
	 */
	int yy_is_interactive;

	/* Whether we're considered to be at the beginning of a line.
	 * If so, '^' rules will be active on the next match, otherwise
	 * not.
	 */
	int yy_at_bol;

	/* Whether to try to fill the input buffer when we reach the
	 * end of it.
	 */
	int yy_fill_buffer;

	int yy_buffer_status;
#define YY_BUFFER_NEW 0
#define YY_BUFFER_NORMAL 1
	/* When an EOF's been seen but there's still some text to process
	 * then we mark the buffer as YY_EOF_PENDING, to indicate that we
	 * shouldn't try reading from the input source any more.  We might
	 * still have a bunch of tokens to match, though, because of
	 * possible backing-up.
	 *
	 * When we actually see the EOF, we change the status to "new"
	 * (via yyrestart()), so that the user can continue scanning by
	 * just pointing yyin at a new input file.
	 */
#define YY_BUFFER_EOF_PENDING 2
	};

#define yy_current_buffer SCNG(current_buffer)
#define yy_hold_char SCNG(_yy_hold_char)

/* We provide macros for accessing buffer states in case in the
 * future we want to put the buffer states in a more general
 * "scanner state".
 */
#define YY_CURRENT_BUFFER yy_current_buffer


/* yy_hold_char holds the character lost when yytext is formed. */

#if 0
static char yy_hold_char;

static int yy_n_chars;		/* number of characters read into yy_ch_buf */
#endif

/* Points to current character in buffer. */
#define yy_c_buf_p SCNG(c_buf_p)
#define yy_init SCNG(init)
#define yy_start SCNG(start)

#ifdef ZTS
#define TSRMLS_D	void ***tsrm_ls
#define TSRMLS_DC	, TSRMLS_D
#define TSRMLS_C	tsrm_ls
#define TSRMLS_CC	, TSRMLS_C
#else
#define TSRMLS_D
#define TSRMLS_DC
#define TSRMLS_C
#define TSRMLS_CC
#endif

/* Flag which is used to allow yywrap()'s to do buffer switches
 * instead of setting up a fresh yyin.  A bit of a hack ...
 */
/* static int yy_did_buffer_switch_on_eof; */
#define yy_did_buffer_switch_on_eof SCNG(_yy_did_buffer_switch_on_eof)

void yyrestart YY_PROTO(( FILE *input_file TSRMLS_DC ));

void yy_switch_to_buffer YY_PROTO(( YY_BUFFER_STATE new_buffer TSRMLS_DC ));
void yy_load_buffer_state YY_PROTO(( TSRMLS_D ));
YY_BUFFER_STATE yy_create_buffer YY_PROTO(( FILE *file, int size TSRMLS_DC ));
void yy_delete_buffer YY_PROTO(( YY_BUFFER_STATE b TSRMLS_DC ));
void yy_init_buffer YY_PROTO(( YY_BUFFER_STATE b, FILE *file TSRMLS_DC ));
void yy_flush_buffer YY_PROTO(( YY_BUFFER_STATE b TSRMLS_DC ));
#define YY_FLUSH_BUFFER yy_flush_buffer( yy_current_buffer TSRMLS_CC )

YY_BUFFER_STATE yy_scan_buffer YY_PROTO(( char *base, yy_size_t size TSRMLS_DC ));
YY_BUFFER_STATE yy_scan_string YY_PROTO(( yyconst char *yy_str TSRMLS_DC ));
YY_BUFFER_STATE yy_scan_bytes YY_PROTO(( yyconst char *bytes, int len TSRMLS_DC ));


static void *yy_flex_alloc YY_PROTO(( yy_size_t ));
static void *yy_flex_realloc YY_PROTO(( void *, yy_size_t ));
static void yy_flex_free YY_PROTO(( void * ));

#define yy_new_buffer yy_create_buffer

#define yy_set_interactive(is_interactive) \
	{ \
	if ( ! yy_current_buffer ) \
		yy_current_buffer = yy_create_buffer( SCNG(yy_in), YY_BUF_SIZE TSRMLS_CC ); \
	yy_current_buffer->yy_is_interactive = is_interactive; \
	}

#define yy_set_bol(at_bol) \
	{ \
	if ( ! yy_current_buffer ) \
		yy_current_buffer = yy_create_buffer( SCNG(yy_in), YY_BUF_SIZE TSRMLS_CC ); \
	yy_current_buffer->yy_at_bol = at_bol; \
	}

#define YY_AT_BOL() (yy_current_buffer->yy_at_bol)


#define yywrap() 1
#define YY_SKIP_YYWRAP
typedef unsigned char YY_CHAR;
FILE *yyin = (FILE *) 0, *yyout = (FILE *) 0;
typedef int yy_state_type;
extern char *yytext;
#define yytext_ptr yytext
#undef yyleng
#define yyleng SCNG(yy_leng)
#undef yytext
#define yytext SCNG(yy_text)
#undef yytext_ptr
#define yytext_ptr SCNG(yy_text)
#undef yyin
#define yyin SCNG(yy_in)
#undef yyout
#define yyout SCNG(yy_out)
#undef yy_last_accepting_state
#define yy_last_accepting_state SCNG(_yy_last_accepting_state)
#undef yy_last_accepting_cpos
#define yy_last_accepting_cpos SCNG(_yy_last_accepting_cpos)
#undef yy_more_flag
#define yy_more_flag SCNG(_yy_more_flag)
#undef yy_more_len
#define yy_more_len SCNG(_yy_more_len)


static yy_state_type yy_get_previous_state YY_PROTO(( TSRMLS_D ));
static yy_state_type yy_try_NUL_trans YY_PROTO(( yy_state_type current_state TSRMLS_DC ));
static int yy_get_next_buffer YY_PROTO(( TSRMLS_D ));
static void yy_fatal_error YY_PROTO(( yyconst char msg[] ));

#undef TSRMLS_D
#undef TSRMLS_DC
#undef TSRMLS_C
#undef TSRMLS_CC

/* Done after the current pattern has been matched and before the
 * corresponding action - sets up yytext.
 */
#define YY_DO_BEFORE_ACTION \
	yytext_ptr = yy_bp; \
	yytext_ptr -= yy_more_len; \
	yyleng = (int) (yy_cp - yytext_ptr); \
	yy_hold_char = *yy_cp; \
	*yy_cp = '\0'; \
	yy_c_buf_p = yy_cp;

#undef yyleng
#undef yytext
#undef yytext_ptr
#undef yyin
#undef yyout
#undef yy_last_accepting_state
#undef yy_last_accepting_cpos
#undef yy_more_flag
#undef yy_more_len


#define YY_NUM_RULES 146
#define YY_END_OF_BUFFER 147
static yyconst short int yy_accept[1367] =
    {   0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
      147,   98,   98,  145,  108,   84,  122,  109,   84,   84,
       84,  125,   84,   84,   84,   84,   84,   84,   84,   90,
       90,   84,   84,   84,   84,   84,   84,  106,  124,  106,
      106,  106,  106,  106,  106,  106,  106,  106,  106,  106,
      106,  106,  106,  106,  106,  106,  106,  106,   85,   84,
       87,  105,  142,  132,  127,   92,   92,  132,  145,  105,
      129,  132,  128,  144,  145,  130,  145,  143,  107,  127,
      141,  107,  127,   92,   92,  145,  107,  107,   33,   32,

       89,   88,  115,  117,  111,  112,  112,  110,  110,  110,
       98,    0,   98,  101,   99,   98,  108,   63,    0,  120,
        0,  104,   71,  119,   78,   74,    0,  121,    0,    0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,   68,
       58,   66,   59,   67,   31,   93,   70,  114,  109,   69,
       93,   90,    0,    0,   34,    0,   82,   64,   63,   62,
       55,   65,   83,  118,   76,  106,  106,  106,  106,   20,
      106,  106,  106,  106,  106,  106,  106,   13,  106,  106,
      106,  106,  106,  106,  106,  106,  106,    7,  106,  106,
      106,  106,  106,   79,  106,  106,  106,  106,  106,  106,

      106,  106,  106,   75,   77,  105,  127,  105,  131,   86,
      127,   31,    0,   92,  105,  140,  136,  138,  140,  129,
      133,  128,    0,  134,  135,  130,  137,  107,  127,  107,
      141,  107,    0,   92,  107,  126,  126,  107,  107,   32,
       88,  115,  116,  111,  112,  113,   98,    0,  100,    0,
        0,   61,  104,  119,  119,    0,    0,    0,    0,    0,
        0,    0,    0,    0,   93,    0,   93,   91,    0,    0,
       72,   60,   73,  118,  118,  106,  106,  106,   80,  106,
      106,  106,  106,  106,  106,  106,  106,    2,  106,  106,
      106,  106,  106,  106,  106,   14,  106,  106,  106,  106,

      106,   35,  106,  106,  106,  106,  106,  106,  106,   49,
       36,  106,   81,   92,  138,  139,   92,   98,    0,    0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
        0,    0,    0,  106,  106,  106,  106,  106,  106,   23,
      106,  106,  106,  106,  106,  106,   27,   10,  106,  106,
      106,  106,  106,  106,   44,    1,  106,  106,  106,  106,
      106,  106,   56,  106,  106,  106,  106,  106,  106,  106,
      106,  138,  139,   98,    0,    0,    0,    0,    0,    0,
        0,    0,   37,    0,    0,    0,    0,    0,    0,  123,
      123,    0,  106,  106,  106,  106,   57,   25,  106,   29,

        5,  106,  106,  106,  106,   52,  106,  106,    9,  106,
      106,  106,  106,  106,  106,  106,   51,  106,   28,  106,
      106,  106,  106,   54,   11,   98,    0,  102,  102,    0,
        0,    0,    0,   42,    0,    0,    0,    0,    0,   38,
        0,    0,    0,  106,  106,  106,  106,  106,  106,  106,
      106,    8,  106,   15,  106,  106,  106,  106,  106,   50,
      106,  106,  106,    6,   53,   21,   98,    0,    0,    0,
        0,   40,    0,    0,    0,    0,    0,   43,    0,  106,
      106,  106,  106,  106,  106,   18,   24,  106,  106,  106,
      106,   30,   16,  106,   45,  106,   47,   98,    0,    0,

        0,    0,    0,    0,   41,    0,   39,    0,  106,   97,
      106,   96,  106,   26,  106,  106,  106,   12,    4,  106,
      106,  106,   98,    0,    0,    0,    0,   94,  106,  106,
      106,   22,  106,  106,  106,   98,    0,    0,    0,  106,
       19,   17,  106,  106,  106,   98,    0,    0,    0,  106,
      106,  106,  106,   98,    0,    0,    0,   95,   46,    3,
       48,   98,    0,    0,    0,   98,    0,    0,    0,   98,
        0,    0,    0,   98,    0,    0,    0,   98,    0,    0,
        0,    0,   98,    0,  103,    0,    0,    0,    0,   98,
        0,  103,  103,    0,    0,    0,   98,    0,    0,    0,

        0,   98,    0,    0,    0,    0,   99,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,    0
    } ;

static yyconst int yy_ec[256] =
    {   0,
        1,    1,    1,    1,    1,    1,    1,    1,    2,    3,
        1,    1,    4,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    2,    5,    6,    7,    8,    9,   10,   11,   12,
       13,   14,   15,   16,   17,   18,   19,   20,   21,   21,
       21,   21,   21,   21,   21,   22,   22,   23,   24,   25,
       26,   27,   28,   16,   34,   35,   36,   37,   38,   39,
       40,   41,   42,   43,   44,   45,   46,   47,   48,   49,
       50,   51,   52,   53,   54,   55,   56,   57,   58,   59,
       29,   30,   29,   31,   32,   33,   34,   35,   36,   37,

       38,   39,   40,   41,   42,   43,   44,   45,   46,   47,
       48,   49,   50,   51,   52,   53,   54,   55,   56,   57,
       58,   59,   60,   61,   62,   16,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,

       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59
    } ;

static yyconst int yy_meta[63] =
    {   0,
        1,    2,    3,    3,    4,    1,    4,    5,    6,    4,
        7,    4,    4,    8,    4,    4,    4,    4,    4,    9,
        9,    9,    4,    4,   10,    4,    6,    6,    1,    1,
        4,   11,    1,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,    1,
        4,    1
    } ;

static yyconst short int yy_base[1787] =
    {   0,
     7774, 7773,    0,    0,   62,    0,  114,  115,  121,  122,
      155,  186,  245,    0,  307,    0, 7783, 7782,  367,  369,
     7795, 7769,  365, 7800,  127, 7767,  369, 7800,    0,  106,
      124,  368,  416, 7800, 7766,  120,  121,  360,  123,  367,
      382, 7768,  365,  113,  380, 7763, 7763, 7756, 7800,  361,
     7736,  377,  381,  385,  329, 7741,    0,  362, 7743, 7746,
      382, 7732, 7744,  381,   89, 7747, 7739, 7731, 7800,  384,
     7800,  469, 7800,  530,  126,  576,  426, 7800,  588, 7761,
     7744, 7768, 7745, 7800,  424, 7768,  442, 7800,  644,    0,
      433,  589,  409,  582,  439,  585, 7756,  704, 7800,    0,

     7800,    0,    0, 7753,    0, 7800, 7768, 7743, 7800, 7742,
     7743,  592, 7742, 7740,  389, 7729,  608, 7738,  422, 7800,
      610,    0, 7800,  611, 7800, 7800,  596, 7800, 7760,    0,
     7711, 7713, 7712, 7714, 7711, 7722, 7718, 7702, 7707, 7800,
     7800, 7800, 7800, 7800, 7800,  603, 7800, 7800, 7800, 7800,
      614,  746,  754,  757, 7800, 7701,  602, 7800, 7800, 7726,
     7800, 7800, 7725,  626, 7800,    0,  744, 7713, 7698,    0,
     7710, 7695, 7692, 7711, 7697,  580, 7705,    0, 7701, 7689,
     7691, 7702, 7704,  579, 7686, 7689, 7687,    0, 7698, 7681,
     7680, 7675, 7693,    0, 7687,  587, 7694, 7685, 7674, 7687,

     7673, 7681, 7671, 7800, 7800,    0,  755, 7704, 7800, 7800,
        0,    0,  770,  781,  787, 7800, 7800,  653,  793, 7687,
     7800, 7689, 7688, 7800, 7800, 7711, 7800,    0,  773, 7699,
      800,  806,  793,  820,  826, 7800, 7712,    0,  782,    0,
        0,    0, 7800,    0, 7800, 7800, 7689,  825, 7800, 7672,
     7661, 7800,    0, 7800, 7708, 7659, 7661, 7654, 7659, 7653,
     7662, 7670, 7652, 7650,  834,  837,  846,  849, 7665, 7698,
     7800, 7800, 7800, 7800, 7696, 7653,  415, 7655,    0, 7662,
     7661, 7656, 7646, 7640,  681, 7646, 7656,    0, 7641, 7650,
     7634,  837, 7641, 7632, 7646, 7645, 7646, 7646, 7635, 7641,

     7625,    0, 7645, 7629, 7621, 7620, 7620, 7619, 7633,    0,
        0, 7625,    0,  877,  798,  870,  900, 7644,  901, 7619,
     7625, 7632, 7620, 7629, 7629,  917, 7624, 7616, 7618, 7621,
     7607, 7655,  832, 7622, 7610, 7607, 7606, 7594, 7607,    0,
     7614, 7597, 7595, 7605, 7612, 7591,    0, 7602, 7585, 7604,
     7593, 7601, 7583, 7597,    0,    0, 7590, 7602, 7582, 7600,
     7579, 7579,    0, 7592, 7577, 7587, 7577, 7585, 3244, 3225,
     3239, 7800, 7800, 3251,  915,  899, 3226, 3216,  931, 3215,
     3206,  768, 7800, 3218, 3221,  803, 3209, 3202, 3212, 7800,
     3250,  841, 3187, 3183, 3182, 3174,    0,    0, 3150,    0,

        0, 3153, 3141, 3145, 3148,    0, 3147, 3124,    0, 3109,
     3104, 3090, 3085, 3013, 3009, 3016,    0, 2998,    0, 2999,
     3002, 3012, 3006,    0,    0, 3019,  923, 7800, 3040, 2989,
     2988,  836,  939, 7800, 3006, 2999, 2998, 2982,  943, 7800,
     2993,  944, 2982, 2978, 2994, 2972, 2991, 2978, 2963, 2971,
     2947,    0, 2952, 2952, 2934, 2941, 2931, 2939, 2929,    0,
     2930, 2918, 2906,    0,    0,    0, 2918,  933, 2891,  878,
      947, 7800, 2893, 2888,  952,  957,  960, 7800, 2885, 2905,
     2896, 2875, 2874, 2854, 2861,    0,    0, 2863, 2861, 2856,
     2850,    0,    0, 2830, 2834, 2827, 2830, 2835,  938, 2825,

      974,  966,  969,  970, 7800,  978, 7800,  984, 2817,    0,
     2800,    0, 2790,    0, 2779, 2791, 2785,    0,    0, 2775,
     2767, 2769, 2780,  972, 2764, 2763,  990,    0, 2736, 2744,
     2739,    0, 2732, 2736, 2730, 2743,  980, 2713, 2695, 2707,
        0,    0, 2702, 2689, 2699, 2707,  987, 2696, 2685, 2670,
     2661, 2645, 2652, 2664,  993, 2633, 2633,    0,    0,    0,
        0, 2660,  995, 2636, 2633, 2625,  997, 2596, 2606, 2620,
     1001, 2592, 2603, 2615, 1005, 2602, 1032, 2594, 1018, 2583,
     1038, 1048, 2583, 1035,  848, 1063, 2558, 2555, 2560, 2572,
     1047, 7800, 2587, 2538, 2537, 2526, 2543, 1052, 2516, 2515,

     1079, 2536, 1064, 2544, 2528, 1082, 7800, 2507, 1070, 2505,
     1082, 2504, 1092, 2503, 1093, 2502, 1099, 2500, 1104, 2482,
     1105, 2477, 1110, 2474, 1114, 2465, 1122, 2462, 1127, 2460,
     1139, 2459, 1140, 2456, 1144, 2455, 1145, 2445, 1150, 2434,
     1152, 2425, 1162, 2422, 1173, 2419, 1175, 2416, 1180, 2415,
     1184, 2412, 1185, 2405, 1190, 2402, 1198, 2393, 1210, 2390,
     1215, 2379, 1219, 2376, 1220, 2369, 1221, 2367, 1230, 2365,
     1232, 2364, 1250, 2362, 1252, 2353, 1260, 2347, 1261, 2344,
     1265, 2342, 1267, 2327, 1272, 2324, 1278, 2322, 1282, 2317,
     1290, 2313, 1300, 2302, 1307, 2299, 1311, 2296, 1312, 2287,

     1313, 2285, 1318, 2284, 1320, 2274, 1322, 2273, 1348, 2262,
     1352, 2259, 1353, 2256, 1357, 2255, 1358, 2252, 1359, 2245,
     1366, 2242, 1370, 2230, 1387, 2225, 1388, 2222, 1392, 2219,
     1398, 2216, 1399, 2207, 1405, 2205, 1410, 2204, 1420, 2202,
     1427, 2193, 1428, 2187, 1433, 2184, 1438, 2182, 1440, 2167,
     1445, 2164, 1450, 2163, 1458, 2162, 1468, 2157, 1473, 2153,
     1475, 2150, 1479, 2147, 1480, 2136, 1486, 2127, 1490, 2125,
     1508, 2124, 1512, 2114, 1519, 2113, 1520, 2110, 1521, 2107,
     1525, 2096, 1526, 2095, 1530, 2092, 1534, 2085, 1556, 2082,
     1560, 2070, 1565, 2067, 1566, 2065, 1567, 2056, 1571, 2047,

     1578, 2045, 1588, 2044, 1596, 2042, 1600, 2033, 1601, 2024,
     1606, 2022, 1611, 2019, 1613, 2016, 1618, 2007, 1626, 2004,
     1636, 2002, 1641, 1997, 1646, 1993, 1647, 1990, 1648, 1987,
     1658, 1976, 1659, 1967, 1676, 1964, 1680, 1957, 1681, 1954,
     1687, 1953, 1688, 1950, 1693, 1947, 1694, 1944, 1698, 1935,
     1716, 1932, 1726, 1911, 1727, 1910, 1728, 1909, 1733, 1907,
     1734, 1906, 1738, 1905, 1739, 1904, 1748, 1895, 1756, 1884,
     1768, 1873, 1773, 1869, 1774, 1866, 1778, 1864, 1779, 1862,
     1785, 1859, 1786, 1855, 1796, 1844, 1807, 1833, 1808, 1830,
     1814, 1829, 1818, 1827, 1819, 1826, 1825, 1816, 1836, 1815,

     1840, 1804, 1847, 1797, 1848, 1794, 1853, 1793, 1854, 1790,
     1858, 1787, 1865, 1784, 1876, 1772, 1886, 1767, 1887, 1764,
     1888, 1750, 1893, 1749, 1894, 1747, 1898, 1746, 1899, 1745,
     1916, 1744, 1924, 1735, 1928, 1724, 1933, 1713, 1934, 1709,
     1938, 1706, 1939, 1705, 1945, 1704, 1946, 1702, 1956, 1699,
     1968, 1695, 1974, 1692, 1978, 1689, 1979, 1670, 1985, 1669,
     1986,  194, 1991,  416, 1996,  424, 2000,  440, 2008,  452,
     2014,  473, 2025,  477, 2026,  504, 2031,  606, 2036,  613,
     2037,  618, 2046,  625, 2048,  652, 2054,  679, 2059,  685,
     2066,  687, 2071,  712, 2076,  748, 2077,  763, 2084,  848,

     2088,  850, 2094,  853, 2099,  870, 2105,  871, 2106,  875,
     2116,  893, 2117,  898, 2128,  900, 2134,  902, 2138,  903,
     2139,  925, 2145,  939, 2146,  949, 2151,  959, 2156,  970,
     2168,  973, 2174,  974, 2176,  976, 2185,  978, 2186,  982,
     2191,  984, 2196,  988, 2197,  991, 2206, 1003, 2208, 1006,
     2214, 1012, 2226, 1013, 2231, 1023, 2236, 1030, 2237, 1037,
     2243, 1043, 2244, 1046, 2248, 1051, 2254, 1053, 2265, 1063,
     2266, 1065, 2276, 1068, 2277, 1069, 2283, 1071, 2288, 1075,
     2294, 1078, 2298, 1080, 2305, 1086, 2306, 1090, 2311, 1100,
     2316, 1101, 2323, 1103, 2328, 1112, 2334, 1115, 2336, 1116,

     2345, 1118, 2346, 1121, 2351, 1133, 2356, 1135, 2357, 1138,
     2368, 1151, 2374, 1156, 2382, 1158, 2386, 1160, 2391, 1161,
     2396, 1163, 2397, 1170, 2403, 1181, 2404, 1186, 2408, 1191,
     2414, 1192, 2426, 1195, 2436, 1196, 2437, 1197, 2443, 1206,
     2444, 1208, 2448, 1209, 2449, 1226, 2454, 1227, 2458, 1228,
     2466, 1229, 2483, 1231, 2484, 1238, 2488, 1239, 2489, 1240,
     2494, 1241, 2495, 1243, 2496, 1254, 2506, 1258, 2517, 1269,
     2524, 1271, 2528, 1273, 2529, 1276, 2534, 1280, 2535, 1283,
     2542, 1286, 2546, 1289, 2557, 1298, 2563, 1301, 2564, 1308,
     2568, 1319, 2574, 1324, 2575, 1326, 2586, 1328, 2596, 1329,

     2597, 1330, 2603, 1331, 2604, 1333, 2608, 1335, 2609, 1344,
     2614, 1346, 2626, 1363, 2634, 1364, 2643, 1365, 2644, 1367,
     2648, 1368, 2649, 1374, 2654, 1377, 2655, 1378, 2656, 1381,
     2666, 1396, 2684, 1400, 2688, 1403, 2689, 1406, 2694, 1407,
     2695, 1409, 2696, 1416, 2701, 1418, 2702, 1421, 2706, 1435,
     2724, 1439, 2734, 1444, 2735, 1446, 2736, 1449, 2741, 1451,
     2742, 1456, 2746, 1462, 2747, 1466, 2756, 1469, 2764, 1481,
     2776, 1484, 2781, 1487, 2782, 1488, 2786, 1491, 2787, 1494,
     2793, 1497, 2794, 1498, 2804, 1499, 2815, 1501, 2816, 1516,
     2822, 1527, 2826, 1531, 2827, 1532, 2833, 1536, 2844, 1538,

     2848, 1541, 2855, 1542, 2856, 1543, 2861, 1545, 2862, 1554,
     2866, 1558, 2873, 1564, 2884, 1573, 2894, 1575, 2895, 1576,
     2896, 1577, 2901, 1579, 2902, 1582, 2906, 1586, 2907, 1589,
     2924, 1607, 2932, 1608, 2936, 1612, 2941, 1617, 2942, 1619,
     2946, 1622, 2947, 1624, 2953, 1634, 2954, 1635, 2964, 1637,
     2976, 1652, 2982, 1654, 2986, 1655, 2987, 1656, 2993, 1657,
     2994, 1666, 2999, 7800, 3004, 7800, 3056, 3067, 3078, 3089,
     3100, 3111, 3122, 1681, 3133, 3136, 3146, 3157, 3168, 3178,
     3187, 3190, 3193, 3204, 3215, 3226, 3229, 3240, 3250, 3261,
     3270, 3281, 3292, 3303, 3314, 3325, 3336, 3347, 3358, 3369,

     3380, 3391, 3402, 3413, 3424, 3435, 3446, 3457, 3468, 3479,
     3490, 3501, 3512, 3523, 3534, 3545, 3556, 3567, 3578, 3589,
     3600, 3611, 3622, 3633, 3644, 3655, 3666, 3677, 3688, 3699,
     3710, 3721, 3732, 3743, 3754, 3765, 3776, 3787, 3798, 3809,
     3820, 3831, 3842, 3853, 3864, 3875, 3886, 3897, 3908, 3919,
     3930, 3941, 3952, 3963, 3974, 3985, 3996, 4007, 4018, 4029,
     4040, 4051, 4062, 4073, 4084, 4095, 4106, 4117, 4128, 4139,
     4150, 4161, 4172, 4183, 4194, 4205, 4216, 4227, 4238, 4249,
     4260, 4271, 4282, 4293, 4304, 4315, 4326, 4337, 4348, 4359,
     4370, 4381, 4392, 4403, 4414, 4425, 4436, 4447, 4458, 4469,

     4480, 4491, 4502, 4513, 4524, 4535, 4546, 4557, 4568, 4579,
     4590, 4601, 4612, 4623, 4634, 4645, 4656, 4667, 4678, 4689,
     4700, 4711, 4722, 4733, 4744, 4755, 4766, 4777, 4788, 4799,
     4810, 4821, 4832, 4843, 4854, 4865, 4876, 4887, 4898, 4909,
     4920, 4931, 4942, 4953, 4964, 4975, 4986, 4997, 5008, 5019,
     5030, 5041, 5052, 5063, 5074, 5085, 5096, 5107, 5118, 5129,
     5140, 5151, 5162, 5173, 5184, 5195, 5206, 5217, 5228, 5239,
     5250, 5261, 5272, 5283, 5294, 5305, 5316, 5327, 5338, 5349,
     5360, 5371, 5382, 5393, 5404, 5415, 5426, 5437, 5448, 5459,
     5470, 5481, 5492, 5503, 5514, 5525, 5536, 5547, 5558, 5569,

     5580, 5591, 5602, 5613, 5624, 5635, 5646, 5657, 5668, 5679,
     5690, 5701, 5712, 5723, 5734, 5745, 5756, 5767, 5778, 5789,
     5800, 5811, 5822, 5833, 5844, 5855, 5866, 5877, 5888, 5899,
     5910, 5921, 5932, 5943, 5954, 5965, 5976, 5987, 5998, 6009,
     6020, 6031, 6042, 6053, 6064, 6075, 6086, 6097, 6108, 6119,
     6130, 6141, 6152, 6163, 6174, 6185, 6196, 6207, 6218, 6229,
     6240, 6251, 6262, 6273, 6284, 6295, 6306, 6317, 6328, 6339,
     6350, 6361, 6372, 6383, 6394, 6405, 6416, 6427, 6438, 6449,
     6460, 6471, 6482, 6493, 6504, 6515, 6526, 6537, 6548, 6559,
     6570, 6581, 6592, 6603, 6614, 6625, 6636, 6647, 6658, 6669,

     6680, 6691, 6702, 6713, 6724, 6735, 6746, 6757, 6768, 6779,
     6790, 6801, 6812, 6823, 6834, 6845, 6856, 6867, 6878, 6889,
     6900, 6911, 6922, 6933, 6944, 6955, 6966, 6977, 6988, 6999,
     7010, 7021, 7032, 7043, 7054, 7065, 7076, 7087, 7098, 7109,
     7120, 7131, 7142, 7153, 7164, 7175, 7186, 7197, 7208, 7219,
     7230, 7241, 7252, 7263, 7274, 7285, 7296, 7307, 7318, 7329,
     7340, 7351, 7362, 7373, 7384, 7395, 7406, 7417, 7428, 7439,
     7450, 7461, 7472, 7483, 7494, 7505, 7516, 7527, 7538, 7549,
     7560, 7571, 7582, 7593, 7604, 7615
    } ;

static yyconst short int yy_def[1787] =
    {   0,
     1367, 1367, 1366,    3, 1366,    5, 1368, 1368,    5,    5,
     1366,   11, 1366,   13, 1366,   15, 1369, 1369, 1370, 1370,
     1366, 1371, 1372, 1366, 1366, 1366, 1373, 1366, 1374, 1366,
     1366, 1375, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1376, 1366, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1366, 1366,
     1366, 1366, 1366, 1366,   72, 1377, 1377, 1366, 1378, 1377,
     1366, 1366, 1379, 1366, 1379, 1366, 1378, 1366, 1366, 1380,
     1366,   89,   89, 1381, 1381, 1378, 1381, 1366, 1366, 1382,

     1366, 1383, 1384, 1366, 1385, 1366, 1366, 1366, 1366, 1366,
     1386, 1371, 1371, 1366, 1366, 1366, 1366, 1366, 1373, 1366,
     1373, 1387, 1366, 1366, 1366, 1366, 1375, 1366, 1375,   33,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,

     1376, 1376, 1376, 1366, 1366,   72,   72, 1377, 1366, 1366,
     1380, 1380, 1377, 1377, 1377, 1366, 1366, 1366, 1366, 1366,
     1366, 1379, 1379, 1366, 1366, 1366, 1366,   89,   89, 1381,
     1366,   89, 1381, 1381, 1381, 1366, 1366,   98, 1381, 1382,
     1383, 1384, 1366, 1385, 1366, 1366, 1388, 1386, 1366, 1366,
     1366, 1366, 1387, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1389,
     1366, 1366, 1366, 1366, 1366, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,

     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1377, 1366, 1366, 1381, 1390, 1388, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1389, 1391, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1366, 1366, 1392, 1390, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1391, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,

     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1393, 1392, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1394, 1393, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1395, 1394, 1366,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376,
     1376, 1376, 1396, 1395, 1366, 1366, 1366, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1397, 1396, 1366, 1366, 1376,
     1376, 1376, 1376, 1376, 1376, 1398, 1397, 1366, 1366, 1376,
     1376, 1376, 1376, 1399, 1398, 1366, 1366, 1376, 1376, 1376,
     1376, 1400, 1399, 1366, 1366, 1401, 1400, 1366, 1366, 1402,
     1401, 1366, 1366, 1403, 1402, 1366, 1366, 1404, 1403, 1366,
     1366, 1366, 1405, 1404, 1366, 1366, 1366, 1366, 1366, 1406,
     1405, 1366, 1366, 1366, 1366, 1366, 1407, 1406, 1366, 1366,

     1366, 1408, 1407, 1366, 1366, 1366, 1366, 1409, 1408, 1410,
     1409, 1411, 1410, 1412, 1411, 1413, 1412, 1414, 1413, 1415,
     1414, 1416, 1415, 1417, 1416, 1418, 1417, 1419, 1418, 1420,
     1419, 1421, 1420, 1422, 1421, 1423, 1422, 1424, 1423, 1425,
     1424, 1426, 1425, 1427, 1426, 1428, 1427, 1429, 1428, 1430,
     1429, 1431, 1430, 1432, 1431, 1433, 1432, 1434, 1433, 1435,
     1434, 1436, 1435, 1437, 1436, 1438, 1437, 1439, 1438, 1440,
     1439, 1441, 1440, 1442, 1441, 1443, 1442, 1444, 1443, 1445,
     1444, 1446, 1445, 1447, 1446, 1448, 1447, 1449, 1448, 1450,
     1449, 1451, 1450, 1452, 1451, 1453, 1452, 1454, 1453, 1455,

     1454, 1456, 1455, 1457, 1456, 1458, 1457, 1459, 1458, 1460,
     1459, 1461, 1460, 1462, 1461, 1463, 1462, 1464, 1463, 1465,
     1464, 1466, 1465, 1467, 1466, 1468, 1467, 1469, 1468, 1470,
     1469, 1471, 1470, 1472, 1471, 1473, 1472, 1474, 1473, 1475,
     1474, 1476, 1475, 1477, 1476, 1478, 1477, 1479, 1478, 1480,
     1479, 1481, 1480, 1482, 1481, 1483, 1482, 1484, 1483, 1485,
     1484, 1486, 1485, 1487, 1486, 1488, 1487, 1489, 1488, 1490,
     1489, 1491, 1490, 1492, 1491, 1493, 1492, 1494, 1493, 1495,
     1494, 1496, 1495, 1497, 1496, 1498, 1497, 1499, 1498, 1500,
     1499, 1501, 1500, 1502, 1501, 1503, 1502, 1504, 1503, 1505,

     1504, 1506, 1505, 1507, 1506, 1508, 1507, 1509, 1508, 1510,
     1509, 1511, 1510, 1512, 1511, 1513, 1512, 1514, 1513, 1515,
     1514, 1516, 1515, 1517, 1516, 1518, 1517, 1519, 1518, 1520,
     1519, 1521, 1520, 1522, 1521, 1523, 1522, 1524, 1523, 1525,
     1524, 1526, 1525, 1527, 1526, 1528, 1527, 1529, 1528, 1530,
     1529, 1531, 1530, 1532, 1531, 1533, 1532, 1534, 1533, 1535,
     1534, 1536, 1535, 1537, 1536, 1538, 1537, 1539, 1538, 1540,
     1539, 1541, 1540, 1542, 1541, 1543, 1542, 1544, 1543, 1545,
     1544, 1546, 1545, 1547, 1546, 1548, 1547, 1549, 1548, 1550,
     1549, 1551, 1550, 1552, 1551, 1553, 1552, 1554, 1553, 1555,

     1554, 1556, 1555, 1557, 1556, 1558, 1557, 1559, 1558, 1560,
     1559, 1561, 1560, 1562, 1561, 1563, 1562, 1564, 1563, 1565,
     1564, 1566, 1565, 1567, 1566, 1568, 1567, 1569, 1568, 1570,
     1569, 1571, 1570, 1572, 1571, 1573, 1572, 1574, 1573, 1575,
     1574, 1576, 1575, 1577, 1576, 1578, 1577, 1579, 1578, 1580,
     1579, 1581, 1580, 1582, 1581, 1583, 1582, 1584, 1583, 1585,
     1584, 1586, 1585, 1587, 1586, 1588, 1587, 1589, 1588, 1590,
     1589, 1591, 1590, 1592, 1591, 1593, 1592, 1594, 1593, 1595,
     1594, 1596, 1595, 1597, 1596, 1598, 1597, 1599, 1598, 1600,
     1599, 1601, 1600, 1602, 1601, 1603, 1602, 1604, 1603, 1605,

     1604, 1606, 1605, 1607, 1606, 1608, 1607, 1609, 1608, 1610,
     1609, 1611, 1610, 1612, 1611, 1613, 1612, 1614, 1613, 1615,
     1614, 1616, 1615, 1617, 1616, 1618, 1617, 1619, 1618, 1620,
     1619, 1621, 1620, 1622, 1621, 1623, 1622, 1624, 1623, 1625,
     1624, 1626, 1625, 1627, 1626, 1628, 1627, 1629, 1628, 1630,
     1629, 1631, 1630, 1632, 1631, 1633, 1632, 1634, 1633, 1635,
     1634, 1636, 1635, 1637, 1636, 1638, 1637, 1639, 1638, 1640,
     1639, 1641, 1640, 1642, 1641, 1643, 1642, 1644, 1643, 1645,
     1644, 1646, 1645, 1647, 1646, 1648, 1647, 1649, 1648, 1650,
     1649, 1651, 1650, 1652, 1651, 1653, 1652, 1654, 1653, 1655,

     1654, 1656, 1655, 1657, 1656, 1658, 1657, 1659, 1658, 1660,
     1659, 1661, 1660, 1662, 1661, 1663, 1662, 1664, 1663, 1665,
     1664, 1666, 1665, 1667, 1666, 1668, 1667, 1669, 1668, 1670,
     1669, 1671, 1670, 1672, 1671, 1673, 1672, 1674, 1673, 1675,
     1674, 1676, 1675, 1677, 1676, 1678, 1677, 1679, 1678, 1680,
     1679, 1681, 1680, 1682, 1681, 1683, 1682, 1684, 1683, 1685,
     1684, 1686, 1685, 1687, 1686, 1688, 1687, 1689, 1688, 1690,
     1689, 1691, 1690, 1692, 1691, 1693, 1692, 1694, 1693, 1695,
     1694, 1696, 1695, 1697, 1696, 1698, 1697, 1699, 1698, 1700,
     1699, 1701, 1700, 1702, 1701, 1703, 1702, 1704, 1703, 1705,

     1704, 1706, 1705, 1707, 1706, 1708, 1707, 1709, 1708, 1710,
     1709, 1711, 1710, 1712, 1711, 1713, 1712, 1714, 1713, 1715,
     1714, 1716, 1715, 1717, 1716, 1718, 1717, 1719, 1718, 1720,
     1719, 1721, 1720, 1722, 1721, 1723, 1722, 1724, 1723, 1725,
     1724, 1726, 1725, 1727, 1726, 1728, 1727, 1729, 1728, 1730,
     1729, 1731, 1730, 1732, 1731, 1733, 1732, 1734, 1733, 1735,
     1734, 1736, 1735, 1737, 1736, 1738, 1737, 1739, 1738, 1740,
     1739, 1741, 1740, 1742, 1741, 1743, 1742, 1744, 1743, 1745,
     1744, 1746, 1745, 1747, 1746, 1748, 1747, 1749, 1748, 1750,
     1749, 1751, 1750, 1752, 1751, 1753, 1752, 1754, 1753, 1755,

     1754, 1756, 1755, 1757, 1756, 1758, 1757, 1759, 1758, 1760,
     1759, 1761, 1760, 1762, 1761, 1763, 1762, 1764, 1763, 1765,
     1764, 1766, 1765, 1767, 1766, 1768, 1767, 1769, 1768, 1770,
     1769, 1771, 1770, 1772, 1771, 1773, 1772, 1774, 1773, 1775,
     1774, 1776, 1775, 1777, 1776, 1778, 1777, 1779, 1778, 1780,
     1779, 1781, 1780, 1782, 1781, 1783, 1782, 1784, 1783, 1785,
     1784, 1786, 1785, 1366, 1786,    0, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366
    } ;

static yyconst short int yy_nxt[7863] =
    {   0,
       24,   25,   25,   25,   26,   27,   28,   29,   30,   31,
       32,   33,   34,   35,   36,   34,   37,   38,   39,   40,
       41,   41,   42,   34,   43,   44,   45,   46,   34,   24,
       47,   48,   49,   50,   51,   52,   53,   54,   55,   56,
       57,   58,   57,   57,   59,   57,   60,   61,   62,   57,
       63,   64,   57,   65,   66,   67,   68,   57,   57,   69,
       70,   71,   24,   72,   72,   72,   72,   73,   72,   74,
       72,   72,   72,   72,   72,   72,   72,   72,   75,   72,
       72,   76,   77,   77,   72,   72,   72,   72,   72,   72,
       78,   79,   72,   80,   81,   80,   80,   80,   80,   80,

       80,   80,   80,   80,   80,   80,   80,   80,   80,   80,
       80,   80,   80,   80,   80,   80,   80,   80,   80,   80,
       80,   82,   72,   78,   84,   84,   86,   86,  117,  117,
      117,  123,  124,  125,  141,  199,  148,  143,  160,  161,
      200,  149,  211,   85,   85,  142,  144,  145,  150,  126,
       87,   87,  212,   88,   88,   24,   89,   90,   90,   89,
       91,   89,   74,   89,   89,   92,   89,   89,   89,   89,
       89,   93,   89,   89,   94,   95,   95,   89,   89,   89,
       89,   89,   89,   78,   96,   89,   97,   91,   97,   97,
       97,   97,   97,   97,   97,   97,   97,   97,   97,   97,

       97,   97,   97,   97,   97,   97,   97,   97,   97,   97,
       97,   97,   97,   97,   82,   89,   78,   98,  965,   98,
       98,   98,   98,   98,   98,   98,   98,   98,   98,   98,
       98,   98,   98,   98,   98,   98,   98,   98,   98,   98,
       98,   98,   98,   98,   98,   99,   99,   99,   99,   99,
       99,   99,   99,   99,   99,   99,   99,   99,   99,   99,
       99,   99,   99,   99,   99,   99,   99,   99,   99,   99,
       99,   99,   99,   99,   99,   99,  100,   99,  100,  100,
      100,  100,  100,  100,  100,  100,  100,  100,  100,  100,
      100,  100,  100,  100,  100,  100,  100,  100,  100,  100,

      100,  100,  100,  100,   99,   99,   99,  101,  101,  101,
      101,  101,  101,  101,  101,  101,  101,  101,  101,  101,
      101,  101,  101,  101,  101,  101,  101,  101,  101,  101,
      101,  101,  101,  101,  101,  101,  101,  101,  102,  101,
      102,  102,  102,  102,  102,  102,  102,  102,  102,  102,
      102,  102,  102,  102,  102,  102,  102,  102,  102,  102,
      102,  102,  102,  102,  102,  102,  101,  101,  101,  106,
      107,  106,  107,  114,  120,  108,  185,  108,  128,  146,
      146,  146,  186,  156,  151,  147,  152,  152,  152,  157,
      158,  159,  115,  109,  110,  109,  110,  129,  121,  151,

      188,  152,  152,  152,  153,  162,  163,  168,  189,  204,
      172,  169,  170,  190,  249,  173,  116,  130,  176,  153,
      179,  174,  177,  154,  175,  211,  193,  120,  178,  180,
      181,  182,  194,  197,  224,  212,  198,  250,  231,  183,
      967,  184,  213,  231,  205,  214,  214,  214,  969,  131,
      132,  121,  133,  225,  134,  233,  335,  135,  234,  234,
      234,  218,  218,  136,  971,  231,  137,  138,  336,  139,
      206,  206,  206,  206,  227,  206,  973,  206,  206,  206,
      206,  206,  206,  206,  206,  207,  206,  206,  208,  208,
      208,  206,  206,  206,  206,  206,  206,  975,  219,  206,

      208,  977,  208,  208,  208,  208,  208,  208,  208,  208,
      208,  208,  208,  208,  208,  208,  208,  208,  208,  208,
      208,  208,  208,  208,  208,  208,  208,  208,  979,  206,
      209,  209,  209,  209,  209,  209,  209,  209,  209,  209,
      209,  209,  209,  209,  209,  209,  209,  209,  209,  209,
      209,  209,  209,  209,  209,  209,  209,  209,  209,  209,
      209,  122,  209,  122,  122,  122,  122,  122,  122,  122,
      122,  122,  122,  122,  122,  122,  122,  122,  122,  122,
      122,  122,  122,  122,  122,  122,  122,  122,  122,  210,
      209,  209,  213,  217,  231,  214,  214,  214,  233,  232,

     1366,  234,  234,  234,  218,  218,  128,  218,  218,  117,
      117,  117, 1366,  254,  255,  286, 1366,  119,  287, 1366,
      294,  231,  146,  146,  146,  129,  270,  271,  274,  275,
      981,  295,  215,  265,  265,  265,  305,  983,  235,  306,
      153,  219,  985, 1366,  219,  228,  211,  211,  228,  987,
      228,  153,  228,  228,  228,  228,  228,  228,  228,  228,
      229,  228,  228,  230,  230,  230,  228,  228,  228,  228,
      228,  228,  315,  315,  228,  230,  989,  230,  230,  230,
      230,  230,  230,  230,  230,  230,  230,  230,  230,  230,
      230,  230,  230,  230,  230,  230,  230,  230,  230,  230,

      230,  230,  230,  991,  228,  230,  236,  237,  230,  993,
      230,  995,  230,  230,  230,  230,  230,  230,  230,  230,
      233,  230,  230,  238,  238,  238,  230,  239,  230,  230,
      230,  230,  343,  344,  230,  238,  997,  238,  238,  238,
      238,  238,  238,  238,  238,  238,  238,  238,  238,  238,
      238,  238,  238,  238,  238,  238,  238,  238,  238,  238,
      238,  238,  238,  151,  230,  152,  152,  152,  266,  382,
      266,  211,  999,  267,  267,  267,  268,  268,  268,  276,
      383,  211,  277,  153,  236,  237, 1366, 1001,  278,  211,
      268,  268,  268,  268,  268,  268, 1366,  213,  233,  211,

      214,  214,  214,  213,  439,  231,  314,  314,  314, 1366,
      231,  231,  316,  316,  316,  440,  232,  372,  372, 1366,
      314,  314,  314,  314,  314,  314,  316,  316,  316,  316,
      316,  316,  231, 1366,  390,  391,  233,  471,  231,  234,
      234,  234,  233,  390,  391,  317,  317,  317,  472, 1366,
      592,  593, 1366,  265,  265,  265,  267,  267,  267,  317,
      317,  317,  317,  317,  317,  267,  267,  267,  268,  268,
      268,  153, 1003,  350, 1005,  351, 1366, 1007,  352,  501,
      501,  501,  268,  268,  268,  268,  268,  268,  353,  373,
      373,  373,  354,  213, 1009, 1011,  314,  314,  314, 1013,

      428,  428,  429,  373,  373,  373,  373,  373,  373, 1366,
      314,  314,  314,  314,  314,  314,  233, 1015,  382,  317,
      317,  317, 1017, 1366, 1019, 1366, 1021, 1023, 1366,  383,
      430, 1366,  433,  317,  317,  317,  317,  317,  317, 1366,
      433, 1366, 1366,  434,  439,  477, 1366, 1366,  471, 1025,
     1366,  434, 1366,  504,  384,  440,  478, 1366,  506,  472,
     1366,  477, 1366, 1027,  505, 1366, 1366,  433,  435,  507,
      382,  504,  478, 1029, 1366,  501,  501,  501,  434,  506,
     1366,  383,  505, 1031, 1366,  527,  527,  527, 1366, 1366,
      507,  527,  527,  527, 1033, 1366, 1366, 1035, 1037, 1366,

     1039, 1366, 1041, 1366, 1366, 1366, 1043, 1366, 1045, 1366,
      164, 1366, 1047, 1366, 1366, 1049,  164, 1366,  526, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1051, 1366, 1366,
     1053, 1366, 1366,  581,  581,  581, 1055, 1057, 1366,  581,
      581,  581, 1366, 1366, 1366, 1366, 1366, 1059, 1366,  586,
      586,  586, 1366,  587, 1061, 1366, 1366,  582,  588, 1366,
     1366, 1063, 1366,  582,  586,  586,  586, 1065,  587, 1366,
     1067, 1366, 1366,  588, 1366, 1069, 1366, 1071, 1366, 1366,
      606,  606,  606,  606,  606,  606, 1366, 1073, 1366, 1075,
     1366, 1366, 1077, 1079, 1366, 1081,  589, 1366, 1366, 1083,

     1366, 1366, 1085, 1366, 1087,  607, 1366, 1366,  607, 1366,
     1089,  589, 1366, 1366, 1091, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1093, 1095, 1366, 1097, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1099, 1366, 1366, 1101,
     1103, 1366, 1105, 1366, 1366, 1107, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1109, 1366, 1111,
     1366, 1366, 1113, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1115, 1366, 1366, 1366, 1366,
     1117, 1366, 1119, 1366, 1121, 1123, 1366, 1125, 1366, 1366,
     1366, 1366, 1366, 1366, 1127, 1366, 1366, 1366, 1366, 1366,

     1366, 1366, 1366, 1366, 1366, 1129, 1366, 1366, 1366, 1366,
     1131, 1366, 1366, 1366, 1366, 1133, 1135, 1366, 1366, 1137,
     1139, 1141, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1143, 1366, 1145, 1147, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1149, 1151, 1153, 1155, 1366, 1157, 1366, 1366, 1366, 1366,
     1366, 1366, 1159, 1161, 1163, 1165, 1366, 1167, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1169, 1366,
     1366, 1366, 1171, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1173, 1366, 1175, 1366, 1177, 1366, 1366,

     1179, 1366, 1366, 1366, 1181, 1366, 1366, 1183, 1366, 1366,
     1185, 1366, 1366, 1187, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1189, 1366, 1366, 1191, 1366, 1366, 1366, 1366,
     1366, 1366, 1193, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1195, 1366, 1366, 1366, 1366, 1197, 1366,
     1199, 1366, 1201, 1203, 1205, 1207, 1366, 1209, 1366, 1211,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1213, 1366,
     1215, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1217, 1219, 1221,
     1366, 1223, 1225, 1366, 1366, 1366, 1366, 1366, 1227, 1366,

     1366, 1229, 1231, 1366, 1366, 1233, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1235, 1366, 1366, 1366, 1237, 1366, 1366, 1239, 1366, 1366,
     1241, 1243, 1366, 1245, 1366, 1366, 1366, 1366, 1366, 1366,
     1247, 1366, 1249, 1366, 1366, 1251, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1253,
     1366, 1366, 1366, 1255, 1366, 1366, 1366, 1366, 1257, 1366,
     1259, 1366, 1366, 1261, 1366, 1263, 1366, 1366, 1366, 1366,
     1265, 1366, 1366, 1366, 1366, 1366, 1267, 1366, 1366, 1366,
     1269, 1366, 1366, 1271, 1366, 1366, 1366, 1366, 1366, 1366,

     1366, 1366, 1366, 1366, 1366, 1273, 1366, 1366, 1275, 1366,
     1366, 1277, 1279, 1366, 1366, 1281, 1366, 1366, 1283, 1366,
     1366, 1285, 1287, 1289, 1366, 1291, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1293, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1295, 1366, 1366, 1366, 1297, 1299, 1366, 1366, 1366,
     1301, 1366, 1303, 1366, 1366, 1305, 1307, 1309, 1366, 1311,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1313, 1366,
     1366, 1366, 1315, 1366, 1366, 1366, 1366, 1366, 1317, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1319, 1366, 1321,

     1323, 1325, 1366, 1327, 1366, 1366, 1329, 1366, 1366, 1366,
     1331, 1366, 1366, 1333, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1335, 1337, 1366, 1366, 1366, 1339, 1366, 1366, 1366,
     1366, 1341, 1366, 1343, 1366, 1366, 1345, 1366, 1347, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1349, 1351,
     1366, 1353, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1355, 1366, 1357, 1359,
     1361, 1363, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1365,  122, 1366,  963,  961, 1366, 1366, 1366, 1366, 1366,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366,  959, 1366, 1366,  957, 1366, 1366,  955,
     1366, 1366, 1366,  953, 1366, 1366,  951, 1366,  949,  947,
      945, 1366, 1366,  943, 1366, 1366, 1366,  941, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  939, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  937,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  935,  933,
      931,  929, 1366,  927,  925, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  923, 1366,
     1366,  921, 1366, 1366, 1366, 1366,  919, 1366, 1366, 1366,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  917, 1366,
     1366,  915, 1366, 1366,  913, 1366, 1366,  911,  909, 1366,
     1366,  907, 1366, 1366, 1366, 1366, 1366, 1366,  905, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  903,
      901, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
      899,  897, 1366,  895,  893, 1366, 1366,  891, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  889, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  887,
     1366, 1366, 1366,  885, 1366, 1366,  883, 1366,  881, 1366,
      879, 1366, 1366,  877, 1366, 1366, 1366,  875, 1366, 1366,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  873, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  871,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  869,  867,
      865,  863, 1366,  861,  859,  857, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  855, 1366, 1366,  853,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  851, 1366,
     1366,  849, 1366, 1366,  847, 1366, 1366,  845,  843, 1366,
     1366,  841, 1366, 1366, 1366, 1366, 1366, 1366,  839, 1366,
     1366,  837, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,

      835, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366,  833, 1366, 1366,  831, 1366, 1366,  829, 1366, 1366,
     1366,  827, 1366, 1366, 1366, 1366,  825, 1366,  823, 1366,
     1366,  821, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
      819, 1366, 1366,  817, 1366, 1366,  815, 1366,  813, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366,  811, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  809, 1366,  807,  805,
     1366,  803, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
      801, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  799,
     1366,  797, 1366, 1366,  795, 1366, 1366, 1366, 1366, 1366,

     1366, 1366, 1366, 1366, 1366, 1366,  793, 1366, 1366,  791,
     1366, 1366, 1366, 1366, 1366, 1366,  789, 1366, 1366,  787,
      785, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366,  783, 1366, 1366,  781, 1366, 1366,  779,  777, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  775,  773,
     1366,  771, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
      769, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366,  767, 1366, 1366,  765, 1366, 1366,  763, 1366, 1366,
     1366,  761, 1366, 1366, 1366, 1366,  759,  757,  755, 1366,
     1366,  753, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,

     1366, 1366, 1366, 1366, 1366, 1366,  751, 1366,  749, 1366,
     1366,  747, 1366, 1366, 1366, 1366, 1366,  745, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  743, 1366,  741,  739,
     1366,  737, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
      735, 1366, 1366,  733, 1366, 1366,  731, 1366, 1366,  729,
     1366, 1366, 1366, 1366,  727, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  725, 1366, 1366,  723,
     1366, 1366, 1366, 1366, 1366, 1366,  721, 1366, 1366,  719,
      717, 1366, 1366,  715, 1366, 1366,  713, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366,  711,  709, 1366,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  707,  705,
     1366,  703, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
      701, 1366, 1366,  699, 1366, 1366,  697, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366,  695, 1366, 1366,
     1366,  693, 1366, 1366, 1366, 1366,  691, 1366,  689, 1366,
     1366,  687, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  685, 1366,  683, 1366,
     1366,  681, 1366, 1366, 1366, 1366, 1366,  679, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  677, 1366,  675,  673,
     1366,  671, 1366,  669, 1366, 1366, 1366, 1366, 1366, 1366,

      667, 1366, 1366,  665, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366,  663, 1366, 1366,  661, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  659, 1366, 1366,  657,
     1366, 1366, 1366, 1366, 1366, 1366,  655, 1366, 1366,  653,
      651, 1366, 1366,  649, 1366, 1366,  647, 1366, 1366,  645,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  643, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  641,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  639,
      637, 1366, 1366,  635,  633, 1366,  631, 1366, 1366,  629,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  627, 1366,

     1366,  625, 1366, 1366, 1366, 1366,  623, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366,  621, 1366,  619,  617,  615,  613,
     1366,  611, 1366, 1366, 1366, 1366, 1366, 1366,  601, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  601,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
      609, 1366, 1366,  605,  604, 1366, 1366,  603, 1366, 1366,
     1366, 1366, 1366, 1366,  601, 1366, 1366,  600,  599, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  592,
     1366, 1366, 1366, 1366, 1366, 1366,  598, 1366, 1366, 1366,

      596, 1366, 1366,  595, 1366, 1366,  594,  591, 1366,  585,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  584, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  580,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  579,
      577, 1366, 1366,  576,  575,  573,  572, 1366, 1366,  571,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  569, 1366, 1366,  568,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366,  567, 1366,  565,  564,  563,  561,
     1366,  560, 1366, 1366, 1366, 1366, 1366, 1366,  559, 1366,

     1366,  558, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366,  557, 1366, 1366,  556, 1366, 1366,
     1366,  555, 1366, 1366,  553, 1366,  552,  551,  550, 1366,
     1366,  549, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  548, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366,  547, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  545,  544,  543,  542,
     1366,  541,  540, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  539, 1366, 1366,  538,

     1366, 1366, 1366, 1366,  537, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  535, 1366, 1366,  534,
     1366, 1366,  533, 1366, 1366,  532,  531, 1366, 1366,  530,
     1366, 1366, 1366, 1366, 1366, 1366,  519, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366,  529,  528, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  525,  524,
     1366,  522,  521, 1366, 1366,  520, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  519, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366,  518, 1366, 1366,
     1366,  517, 1366, 1366,  516, 1366,  515, 1366,  514, 1366,

     1366,  513, 1366, 1366, 1366,  512, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  511, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366,  510, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  509,  508,  503,  502,
     1366,  500,  499,  497, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366,  496, 1366, 1366,  495, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  494, 1366, 1366,  493,
     1366, 1366,  492, 1366, 1366,  491,  490, 1366, 1366,  489,
     1366, 1366, 1366, 1366, 1366, 1366,  488, 1366, 1366,  487,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,  486, 1366,
     1366, 1366, 1366, 1366, 1366, 1366,  485, 1366, 1366,  484,
     1366, 1366,  483, 1366,  482,  481, 1366, 1366, 1366,  480,
      479, 1366,  476, 1366,  475,  474,  386, 1366, 1366,  473,
      470,  469,  428,  468, 1366, 1366,  466,  465,  464,  463,
     1366,  462,  461,  460,  459, 1366,   22,   22,   22,   22,
       22,   22,   22,   22,   22,   22,   22,   83,   83,   83,
       83,   83,   83,   83,   83,   83,   83,   83,  103,  103,
      103,  103,  103,  103,  103,  103,  103,  103,  103,  105,
      105,  105,  105,  105,  105,  105,  105,  105,  105,  105,

      111,  111,  111,  111,  111,  111,  111,  111,  111,  111,
      111,  113,  113,  113,  113,  113,  113,  113,  113,  113,
      458,  113,  119,  119,  119,  119,  457,  119,  119,  119,
      119,  119,  119,  127,  127,  127,  127,  127,  127,  127,
      127,  127,  127,  127,  166,  456,  166,  208,  208,  208,
      455,  208,  208,  208,  208,  208,  208,  216,  216,  216,
      216,  216,  216,  216,  216,  216,  216,  216,  222,  222,
      222,  222,  222,  222,  454,  222,  222,  222,  222,  211,
      211,  211,  453,  211,  211,  211,  452,  211,  230,  451,
      230,  450,  230,  230,  230,  230,  230,  230,  240,  449,

      240,  241,  448,  241,  242,  242,  242,  242,  242,  242,
      242,  447,  242,  242,  242,  244,  244,  446,  244,  244,
      445,  244,  244,  244,  244,  244,  247,  247,  247,  247,
      247,  247,  247,  247,  247,  247,  247,  253,  444,  253,
      318,  318,  318,  318,  318,  318,  318,  318,  318,  318,
      318,  333,  390,  443,  442,  441,  438,  437,  386,  436,
      333,  374,  374,  374,  374,  374,  374,  374,  374,  374,
      374,  374,  392,  432,  431,  427,  425,  424,  392,  423,
      392,  426,  426,  426,  426,  426,  426,  426,  426,  426,
      426,  426,  467,  467,  467,  467,  467,  467,  467,  467,

      467,  467,  467,  498,  498,  498,  498,  498,  498,  498,
      498,  498,  498,  498,  523,  523,  523,  523,  523,  523,
      523,  523,  523,  523,  523,  536,  536,  536,  536,  536,
      536,  536,  536,  536,  536,  536,  546,  546,  546,  546,
      546,  546,  546,  546,  546,  546,  546,  554,  554,  554,
      554,  554,  554,  554,  554,  554,  554,  554,  562,  562,
      562,  562,  562,  562,  562,  562,  562,  562,  562,  566,
      566,  566,  566,  566,  566,  566,  566,  566,  566,  566,
      570,  570,  570,  570,  570,  570,  570,  570,  570,  570,
      570,  574,  574,  574,  574,  574,  574,  574,  574,  574,

      574,  574,  578,  578,  578,  578,  578,  578,  578,  578,
      578,  578,  578,  583,  583,  583,  583,  583,  583,  583,
      583,  583,  583,  583,  590,  590,  590,  590,  590,  590,
      590,  590,  590,  590,  590,  597,  597,  597,  597,  597,
      597,  597,  597,  597,  597,  597,  602,  602,  602,  602,
      602,  602,  602,  602,  602,  602,  602,  608,  608,  608,
      608,  608,  608,  608,  608,  608,  608,  608,  610,  610,
      610,  610,  610,  610,  610,  610,  610,  610,  610,  612,
      612,  612,  612,  612,  612,  612,  612,  612,  612,  612,
      614,  614,  614,  614,  614,  614,  614,  614,  614,  614,

      614,  616,  616,  616,  616,  616,  616,  616,  616,  616,
      616,  616,  618,  618,  618,  618,  618,  618,  618,  618,
      618,  618,  618,  620,  620,  620,  620,  620,  620,  620,
      620,  620,  620,  620,  622,  622,  622,  622,  622,  622,
      622,  622,  622,  622,  622,  624,  624,  624,  624,  624,
      624,  624,  624,  624,  624,  624,  626,  626,  626,  626,
      626,  626,  626,  626,  626,  626,  626,  628,  628,  628,
      628,  628,  628,  628,  628,  628,  628,  628,  630,  630,
      630,  630,  630,  630,  630,  630,  630,  630,  630,  632,
      632,  632,  632,  632,  632,  632,  632,  632,  632,  632,

      634,  634,  634,  634,  634,  634,  634,  634,  634,  634,
      634,  636,  636,  636,  636,  636,  636,  636,  636,  636,
      636,  636,  638,  638,  638,  638,  638,  638,  638,  638,
      638,  638,  638,  640,  640,  640,  640,  640,  640,  640,
      640,  640,  640,  640,  642,  642,  642,  642,  642,  642,
      642,  642,  642,  642,  642,  644,  644,  644,  644,  644,
      644,  644,  644,  644,  644,  644,  646,  646,  646,  646,
      646,  646,  646,  646,  646,  646,  646,  648,  648,  648,
      648,  648,  648,  648,  648,  648,  648,  648,  650,  650,
      650,  650,  650,  650,  650,  650,  650,  650,  650,  652,

      652,  652,  652,  652,  652,  652,  652,  652,  652,  652,
      654,  654,  654,  654,  654,  654,  654,  654,  654,  654,
      654,  656,  656,  656,  656,  656,  656,  656,  656,  656,
      656,  656,  658,  658,  658,  658,  658,  658,  658,  658,
      658,  658,  658,  660,  660,  660,  660,  660,  660,  660,
      660,  660,  660,  660,  662,  662,  662,  662,  662,  662,
      662,  662,  662,  662,  662,  664,  664,  664,  664,  664,
      664,  664,  664,  664,  664,  664,  666,  666,  666,  666,
      666,  666,  666,  666,  666,  666,  666,  668,  668,  668,
      668,  668,  668,  668,  668,  668,  668,  668,  670,  670,

      670,  670,  670,  670,  670,  670,  670,  670,  670,  672,
      672,  672,  672,  672,  672,  672,  672,  672,  672,  672,
      674,  674,  674,  674,  674,  674,  674,  674,  674,  674,
      674,  676,  676,  676,  676,  676,  676,  676,  676,  676,
      676,  676,  678,  678,  678,  678,  678,  678,  678,  678,
      678,  678,  678,  680,  680,  680,  680,  680,  680,  680,
      680,  680,  680,  680,  682,  682,  682,  682,  682,  682,
      682,  682,  682,  682,  682,  684,  684,  684,  684,  684,
      684,  684,  684,  684,  684,  684,  686,  686,  686,  686,
      686,  686,  686,  686,  686,  686,  686,  688,  688,  688,

      688,  688,  688,  688,  688,  688,  688,  688,  690,  690,
      690,  690,  690,  690,  690,  690,  690,  690,  690,  692,
      692,  692,  692,  692,  692,  692,  692,  692,  692,  692,
      694,  694,  694,  694,  694,  694,  694,  694,  694,  694,
      694,  696,  696,  696,  696,  696,  696,  696,  696,  696,
      696,  696,  698,  698,  698,  698,  698,  698,  698,  698,
      698,  698,  698,  700,  700,  700,  700,  700,  700,  700,
      700,  700,  700,  700,  702,  702,  702,  702,  702,  702,
      702,  702,  702,  702,  702,  704,  704,  704,  704,  704,
      704,  704,  704,  704,  704,  704,  706,  706,  706,  706,

      706,  706,  706,  706,  706,  706,  706,  708,  708,  708,
      708,  708,  708,  708,  708,  708,  708,  708,  710,  710,
      710,  710,  710,  710,  710,  710,  710,  710,  710,  712,
      712,  712,  712,  712,  712,  712,  712,  712,  712,  712,
      714,  714,  714,  714,  714,  714,  714,  714,  714,  714,
      714,  716,  716,  716,  716,  716,  716,  716,  716,  716,
      716,  716,  718,  718,  718,  718,  718,  718,  718,  718,
      718,  718,  718,  720,  720,  720,  720,  720,  720,  720,
      720,  720,  720,  720,  722,  722,  722,  722,  722,  722,
      722,  722,  722,  722,  722,  724,  724,  724,  724,  724,

      724,  724,  724,  724,  724,  724,  726,  726,  726,  726,
      726,  726,  726,  726,  726,  726,  726,  728,  728,  728,
      728,  728,  728,  728,  728,  728,  728,  728,  730,  730,
      730,  730,  730,  730,  730,  730,  730,  730,  730,  732,
      732,  732,  732,  732,  732,  732,  732,  732,  732,  732,
      734,  734,  734,  734,  734,  734,  734,  734,  734,  734,
      734,  736,  736,  736,  736,  736,  736,  736,  736,  736,
      736,  736,  738,  738,  738,  738,  738,  738,  738,  738,
      738,  738,  738,  740,  740,  740,  740,  740,  740,  740,
      740,  740,  740,  740,  742,  742,  742,  742,  742,  742,

      742,  742,  742,  742,  742,  744,  744,  744,  744,  744,
      744,  744,  744,  744,  744,  744,  746,  746,  746,  746,
      746,  746,  746,  746,  746,  746,  746,  748,  748,  748,
      748,  748,  748,  748,  748,  748,  748,  748,  750,  750,
      750,  750,  750,  750,  750,  750,  750,  750,  750,  752,
      752,  752,  752,  752,  752,  752,  752,  752,  752,  752,
      754,  754,  754,  754,  754,  754,  754,  754,  754,  754,
      754,  756,  756,  756,  756,  756,  756,  756,  756,  756,
      756,  756,  758,  758,  758,  758,  758,  758,  758,  758,
      758,  758,  758,  760,  760,  760,  760,  760,  760,  760,

      760,  760,  760,  760,  762,  762,  762,  762,  762,  762,
      762,  762,  762,  762,  762,  764,  764,  764,  764,  764,
      764,  764,  764,  764,  764,  764,  766,  766,  766,  766,
      766,  766,  766,  766,  766,  766,  766,  768,  768,  768,
      768,  768,  768,  768,  768,  768,  768,  768,  770,  770,
      770,  770,  770,  770,  770,  770,  770,  770,  770,  772,
      772,  772,  772,  772,  772,  772,  772,  772,  772,  772,
      774,  774,  774,  774,  774,  774,  774,  774,  774,  774,
      774,  776,  776,  776,  776,  776,  776,  776,  776,  776,
      776,  776,  778,  778,  778,  778,  778,  778,  778,  778,

      778,  778,  778,  780,  780,  780,  780,  780,  780,  780,
      780,  780,  780,  780,  782,  782,  782,  782,  782,  782,
      782,  782,  782,  782,  782,  784,  784,  784,  784,  784,
      784,  784,  784,  784,  784,  784,  786,  786,  786,  786,
      786,  786,  786,  786,  786,  786,  786,  788,  788,  788,
      788,  788,  788,  788,  788,  788,  788,  788,  790,  790,
      790,  790,  790,  790,  790,  790,  790,  790,  790,  792,
      792,  792,  792,  792,  792,  792,  792,  792,  792,  792,
      794,  794,  794,  794,  794,  794,  794,  794,  794,  794,
      794,  796,  796,  796,  796,  796,  796,  796,  796,  796,

      796,  796,  798,  798,  798,  798,  798,  798,  798,  798,
      798,  798,  798,  800,  800,  800,  800,  800,  800,  800,
      800,  800,  800,  800,  802,  802,  802,  802,  802,  802,
      802,  802,  802,  802,  802,  804,  804,  804,  804,  804,
      804,  804,  804,  804,  804,  804,  806,  806,  806,  806,
      806,  806,  806,  806,  806,  806,  806,  808,  808,  808,
      808,  808,  808,  808,  808,  808,  808,  808,  810,  810,
      810,  810,  810,  810,  810,  810,  810,  810,  810,  812,
      812,  812,  812,  812,  812,  812,  812,  812,  812,  812,
      814,  814,  814,  814,  814,  814,  814,  814,  814,  814,

      814,  816,  816,  816,  816,  816,  816,  816,  816,  816,
      816,  816,  818,  818,  818,  818,  818,  818,  818,  818,
      818,  818,  818,  820,  820,  820,  820,  820,  820,  820,
      820,  820,  820,  820,  822,  822,  822,  822,  822,  822,
      822,  822,  822,  822,  822,  824,  824,  824,  824,  824,
      824,  824,  824,  824,  824,  824,  826,  826,  826,  826,
      826,  826,  826,  826,  826,  826,  826,  828,  828,  828,
      828,  828,  828,  828,  828,  828,  828,  828,  830,  830,
      830,  830,  830,  830,  830,  830,  830,  830,  830,  832,
      832,  832,  832,  832,  832,  832,  832,  832,  832,  832,

      834,  834,  834,  834,  834,  834,  834,  834,  834,  834,
      834,  836,  836,  836,  836,  836,  836,  836,  836,  836,
      836,  836,  838,  838,  838,  838,  838,  838,  838,  838,
      838,  838,  838,  840,  840,  840,  840,  840,  840,  840,
      840,  840,  840,  840,  842,  842,  842,  842,  842,  842,
      842,  842,  842,  842,  842,  844,  844,  844,  844,  844,
      844,  844,  844,  844,  844,  844,  846,  846,  846,  846,
      846,  846,  846,  846,  846,  846,  846,  848,  848,  848,
      848,  848,  848,  848,  848,  848,  848,  848,  850,  850,
      850,  850,  850,  850,  850,  850,  850,  850,  850,  852,

      852,  852,  852,  852,  852,  852,  852,  852,  852,  852,
      854,  854,  854,  854,  854,  854,  854,  854,  854,  854,
      854,  856,  856,  856,  856,  856,  856,  856,  856,  856,
      856,  856,  858,  858,  858,  858,  858,  858,  858,  858,
      858,  858,  858,  860,  860,  860,  860,  860,  860,  860,
      860,  860,  860,  860,  862,  862,  862,  862,  862,  862,
      862,  862,  862,  862,  862,  864,  864,  864,  864,  864,
      864,  864,  864,  864,  864,  864,  866,  866,  866,  866,
      866,  866,  866,  866,  866,  866,  866,  868,  868,  868,
      868,  868,  868,  868,  868,  868,  868,  868,  870,  870,

      870,  870,  870,  870,  870,  870,  870,  870,  870,  872,
      872,  872,  872,  872,  872,  872,  872,  872,  872,  872,
      874,  874,  874,  874,  874,  874,  874,  874,  874,  874,
      874,  876,  876,  876,  876,  876,  876,  876,  876,  876,
      876,  876,  878,  878,  878,  878,  878,  878,  878,  878,
      878,  878,  878,  880,  880,  880,  880,  880,  880,  880,
      880,  880,  880,  880,  882,  882,  882,  882,  882,  882,
      882,  882,  882,  882,  882,  884,  884,  884,  884,  884,
      884,  884,  884,  884,  884,  884,  886,  886,  886,  886,
      886,  886,  886,  886,  886,  886,  886,  888,  888,  888,

      888,  888,  888,  888,  888,  888,  888,  888,  890,  890,
      890,  890,  890,  890,  890,  890,  890,  890,  890,  892,
      892,  892,  892,  892,  892,  892,  892,  892,  892,  892,
      894,  894,  894,  894,  894,  894,  894,  894,  894,  894,
      894,  896,  896,  896,  896,  896,  896,  896,  896,  896,
      896,  896,  898,  898,  898,  898,  898,  898,  898,  898,
      898,  898,  898,  900,  900,  900,  900,  900,  900,  900,
      900,  900,  900,  900,  902,  902,  902,  902,  902,  902,
      902,  902,  902,  902,  902,  904,  904,  904,  904,  904,
      904,  904,  904,  904,  904,  904,  906,  906,  906,  906,

      906,  906,  906,  906,  906,  906,  906,  908,  908,  908,
      908,  908,  908,  908,  908,  908,  908,  908,  910,  910,
      910,  910,  910,  910,  910,  910,  910,  910,  910,  912,
      912,  912,  912,  912,  912,  912,  912,  912,  912,  912,
      914,  914,  914,  914,  914,  914,  914,  914,  914,  914,
      914,  916,  916,  916,  916,  916,  916,  916,  916,  916,
      916,  916,  918,  918,  918,  918,  918,  918,  918,  918,
      918,  918,  918,  920,  920,  920,  920,  920,  920,  920,
      920,  920,  920,  920,  922,  922,  922,  922,  922,  922,
      922,  922,  922,  922,  922,  924,  924,  924,  924,  924,

      924,  924,  924,  924,  924,  924,  926,  926,  926,  926,
      926,  926,  926,  926,  926,  926,  926,  928,  928,  928,
      928,  928,  928,  928,  928,  928,  928,  928,  930,  930,
      930,  930,  930,  930,  930,  930,  930,  930,  930,  932,
      932,  932,  932,  932,  932,  932,  932,  932,  932,  932,
      934,  934,  934,  934,  934,  934,  934,  934,  934,  934,
      934,  936,  936,  936,  936,  936,  936,  936,  936,  936,
      936,  936,  938,  938,  938,  938,  938,  938,  938,  938,
      938,  938,  938,  940,  940,  940,  940,  940,  940,  940,
      940,  940,  940,  940,  942,  942,  942,  942,  942,  942,

      942,  942,  942,  942,  942,  944,  944,  944,  944,  944,
      944,  944,  944,  944,  944,  944,  946,  946,  946,  946,
      946,  946,  946,  946,  946,  946,  946,  948,  948,  948,
      948,  948,  948,  948,  948,  948,  948,  948,  950,  950,
      950,  950,  950,  950,  950,  950,  950,  950,  950,  952,
      952,  952,  952,  952,  952,  952,  952,  952,  952,  952,
      954,  954,  954,  954,  954,  954,  954,  954,  954,  954,
      954,  956,  956,  956,  956,  956,  956,  956,  956,  956,
      956,  956,  958,  958,  958,  958,  958,  958,  958,  958,
      958,  958,  958,  960,  960,  960,  960,  960,  960,  960,

      960,  960,  960,  960,  962,  962,  962,  962,  962,  962,
      962,  962,  962,  962,  962,  964,  964,  964,  964,  964,
      964,  964,  964,  964,  964,  964,  966,  966,  966,  966,
      966,  966,  966,  966,  966,  966,  966,  968,  968,  968,
      968,  968,  968,  968,  968,  968,  968,  968,  970,  970,
      970,  970,  970,  970,  970,  970,  970,  970,  970,  972,
      972,  972,  972,  972,  972,  972,  972,  972,  972,  972,
      974,  974,  974,  974,  974,  974,  974,  974,  974,  974,
      974,  976,  976,  976,  976,  976,  976,  976,  976,  976,
      976,  976,  978,  978,  978,  978,  978,  978,  978,  978,

      978,  978,  978,  980,  980,  980,  980,  980,  980,  980,
      980,  980,  980,  980,  982,  982,  982,  982,  982,  982,
      982,  982,  982,  982,  982,  984,  984,  984,  984,  984,
      984,  984,  984,  984,  984,  984,  986,  986,  986,  986,
      986,  986,  986,  986,  986,  986,  986,  988,  988,  988,
      988,  988,  988,  988,  988,  988,  988,  988,  990,  990,
      990,  990,  990,  990,  990,  990,  990,  990,  990,  992,
      992,  992,  992,  992,  992,  992,  992,  992,  992,  992,
      994,  994,  994,  994,  994,  994,  994,  994,  994,  994,
      994,  996,  996,  996,  996,  996,  996,  996,  996,  996,

      996,  996,  998,  998,  998,  998,  998,  998,  998,  998,
      998,  998,  998, 1000, 1000, 1000, 1000, 1000, 1000, 1000,
     1000, 1000, 1000, 1000, 1002, 1002, 1002, 1002, 1002, 1002,
     1002, 1002, 1002, 1002, 1002, 1004, 1004, 1004, 1004, 1004,
     1004, 1004, 1004, 1004, 1004, 1004, 1006, 1006, 1006, 1006,
     1006, 1006, 1006, 1006, 1006, 1006, 1006, 1008, 1008, 1008,
     1008, 1008, 1008, 1008, 1008, 1008, 1008, 1008, 1010, 1010,
     1010, 1010, 1010, 1010, 1010, 1010, 1010, 1010, 1010, 1012,
     1012, 1012, 1012, 1012, 1012, 1012, 1012, 1012, 1012, 1012,
     1014, 1014, 1014, 1014, 1014, 1014, 1014, 1014, 1014, 1014,

     1014, 1016, 1016, 1016, 1016, 1016, 1016, 1016, 1016, 1016,
     1016, 1016, 1018, 1018, 1018, 1018, 1018, 1018, 1018, 1018,
     1018, 1018, 1018, 1020, 1020, 1020, 1020, 1020, 1020, 1020,
     1020, 1020, 1020, 1020, 1022, 1022, 1022, 1022, 1022, 1022,
     1022, 1022, 1022, 1022, 1022, 1024, 1024, 1024, 1024, 1024,
     1024, 1024, 1024, 1024, 1024, 1024, 1026, 1026, 1026, 1026,
     1026, 1026, 1026, 1026, 1026, 1026, 1026, 1028, 1028, 1028,
     1028, 1028, 1028, 1028, 1028, 1028, 1028, 1028, 1030, 1030,
     1030, 1030, 1030, 1030, 1030, 1030, 1030, 1030, 1030, 1032,
     1032, 1032, 1032, 1032, 1032, 1032, 1032, 1032, 1032, 1032,

     1034, 1034, 1034, 1034, 1034, 1034, 1034, 1034, 1034, 1034,
     1034, 1036, 1036, 1036, 1036, 1036, 1036, 1036, 1036, 1036,
     1036, 1036, 1038, 1038, 1038, 1038, 1038, 1038, 1038, 1038,
     1038, 1038, 1038, 1040, 1040, 1040, 1040, 1040, 1040, 1040,
     1040, 1040, 1040, 1040, 1042, 1042, 1042, 1042, 1042, 1042,
     1042, 1042, 1042, 1042, 1042, 1044, 1044, 1044, 1044, 1044,
     1044, 1044, 1044, 1044, 1044, 1044, 1046, 1046, 1046, 1046,
     1046, 1046, 1046, 1046, 1046, 1046, 1046, 1048, 1048, 1048,
     1048, 1048, 1048, 1048, 1048, 1048, 1048, 1048, 1050, 1050,
     1050, 1050, 1050, 1050, 1050, 1050, 1050, 1050, 1050, 1052,

     1052, 1052, 1052, 1052, 1052, 1052, 1052, 1052, 1052, 1052,
     1054, 1054, 1054, 1054, 1054, 1054, 1054, 1054, 1054, 1054,
     1054, 1056, 1056, 1056, 1056, 1056, 1056, 1056, 1056, 1056,
     1056, 1056, 1058, 1058, 1058, 1058, 1058, 1058, 1058, 1058,
     1058, 1058, 1058, 1060, 1060, 1060, 1060, 1060, 1060, 1060,
     1060, 1060, 1060, 1060, 1062, 1062, 1062, 1062, 1062, 1062,
     1062, 1062, 1062, 1062, 1062, 1064, 1064, 1064, 1064, 1064,
     1064, 1064, 1064, 1064, 1064, 1064, 1066, 1066, 1066, 1066,
     1066, 1066, 1066, 1066, 1066, 1066, 1066, 1068, 1068, 1068,
     1068, 1068, 1068, 1068, 1068, 1068, 1068, 1068, 1070, 1070,

     1070, 1070, 1070, 1070, 1070, 1070, 1070, 1070, 1070, 1072,
     1072, 1072, 1072, 1072, 1072, 1072, 1072, 1072, 1072, 1072,
     1074, 1074, 1074, 1074, 1074, 1074, 1074, 1074, 1074, 1074,
     1074, 1076, 1076, 1076, 1076, 1076, 1076, 1076, 1076, 1076,
     1076, 1076, 1078, 1078, 1078, 1078, 1078, 1078, 1078, 1078,
     1078, 1078, 1078, 1080, 1080, 1080, 1080, 1080, 1080, 1080,
     1080, 1080, 1080, 1080, 1082, 1082, 1082, 1082, 1082, 1082,
     1082, 1082, 1082, 1082, 1082, 1084, 1084, 1084, 1084, 1084,
     1084, 1084, 1084, 1084, 1084, 1084, 1086, 1086, 1086, 1086,
     1086, 1086, 1086, 1086, 1086, 1086, 1086, 1088, 1088, 1088,

     1088, 1088, 1088, 1088, 1088, 1088, 1088, 1088, 1090, 1090,
     1090, 1090, 1090, 1090, 1090, 1090, 1090, 1090, 1090, 1092,
     1092, 1092, 1092, 1092, 1092, 1092, 1092, 1092, 1092, 1092,
     1094, 1094, 1094, 1094, 1094, 1094, 1094, 1094, 1094, 1094,
     1094, 1096, 1096, 1096, 1096, 1096, 1096, 1096, 1096, 1096,
     1096, 1096, 1098, 1098, 1098, 1098, 1098, 1098, 1098, 1098,
     1098, 1098, 1098, 1100, 1100, 1100, 1100, 1100, 1100, 1100,
     1100, 1100, 1100, 1100, 1102, 1102, 1102, 1102, 1102, 1102,
     1102, 1102, 1102, 1102, 1102, 1104, 1104, 1104, 1104, 1104,
     1104, 1104, 1104, 1104, 1104, 1104, 1106, 1106, 1106, 1106,

     1106, 1106, 1106, 1106, 1106, 1106, 1106, 1108, 1108, 1108,
     1108, 1108, 1108, 1108, 1108, 1108, 1108, 1108, 1110, 1110,
     1110, 1110, 1110, 1110, 1110, 1110, 1110, 1110, 1110, 1112,
     1112, 1112, 1112, 1112, 1112, 1112, 1112, 1112, 1112, 1112,
     1114, 1114, 1114, 1114, 1114, 1114, 1114, 1114, 1114, 1114,
     1114, 1116, 1116, 1116, 1116, 1116, 1116, 1116, 1116, 1116,
     1116, 1116, 1118, 1118, 1118, 1118, 1118, 1118, 1118, 1118,
     1118, 1118, 1118, 1120, 1120, 1120, 1120, 1120, 1120, 1120,
     1120, 1120, 1120, 1120, 1122, 1122, 1122, 1122, 1122, 1122,
     1122, 1122, 1122, 1122, 1122, 1124, 1124, 1124, 1124, 1124,

     1124, 1124, 1124, 1124, 1124, 1124, 1126, 1126, 1126, 1126,
     1126, 1126, 1126, 1126, 1126, 1126, 1126, 1128, 1128, 1128,
     1128, 1128, 1128, 1128, 1128, 1128, 1128, 1128, 1130, 1130,
     1130, 1130, 1130, 1130, 1130, 1130, 1130, 1130, 1130, 1132,
     1132, 1132, 1132, 1132, 1132, 1132, 1132, 1132, 1132, 1132,
     1134, 1134, 1134, 1134, 1134, 1134, 1134, 1134, 1134, 1134,
     1134, 1136, 1136, 1136, 1136, 1136, 1136, 1136, 1136, 1136,
     1136, 1136, 1138, 1138, 1138, 1138, 1138, 1138, 1138, 1138,
     1138, 1138, 1138, 1140, 1140, 1140, 1140, 1140, 1140, 1140,
     1140, 1140, 1140, 1140, 1142, 1142, 1142, 1142, 1142, 1142,

     1142, 1142, 1142, 1142, 1142, 1144, 1144, 1144, 1144, 1144,
     1144, 1144, 1144, 1144, 1144, 1144, 1146, 1146, 1146, 1146,
     1146, 1146, 1146, 1146, 1146, 1146, 1146, 1148, 1148, 1148,
     1148, 1148, 1148, 1148, 1148, 1148, 1148, 1148, 1150, 1150,
     1150, 1150, 1150, 1150, 1150, 1150, 1150, 1150, 1150, 1152,
     1152, 1152, 1152, 1152, 1152, 1152, 1152, 1152, 1152, 1152,
     1154, 1154, 1154, 1154, 1154, 1154, 1154, 1154, 1154, 1154,
     1154, 1156, 1156, 1156, 1156, 1156, 1156, 1156, 1156, 1156,
     1156, 1156, 1158, 1158, 1158, 1158, 1158, 1158, 1158, 1158,
     1158, 1158, 1158, 1160, 1160, 1160, 1160, 1160, 1160, 1160,

     1160, 1160, 1160, 1160, 1162, 1162, 1162, 1162, 1162, 1162,
     1162, 1162, 1162, 1162, 1162, 1164, 1164, 1164, 1164, 1164,
     1164, 1164, 1164, 1164, 1164, 1164, 1166, 1166, 1166, 1166,
     1166, 1166, 1166, 1166, 1166, 1166, 1166, 1168, 1168, 1168,
     1168, 1168, 1168, 1168, 1168, 1168, 1168, 1168, 1170, 1170,
     1170, 1170, 1170, 1170, 1170, 1170, 1170, 1170, 1170, 1172,
     1172, 1172, 1172, 1172, 1172, 1172, 1172, 1172, 1172, 1172,
     1174, 1174, 1174, 1174, 1174, 1174, 1174, 1174, 1174, 1174,
     1174, 1176, 1176, 1176, 1176, 1176, 1176, 1176, 1176, 1176,
     1176, 1176, 1178, 1178, 1178, 1178, 1178, 1178, 1178, 1178,

     1178, 1178, 1178, 1180, 1180, 1180, 1180, 1180, 1180, 1180,
     1180, 1180, 1180, 1180, 1182, 1182, 1182, 1182, 1182, 1182,
     1182, 1182, 1182, 1182, 1182, 1184, 1184, 1184, 1184, 1184,
     1184, 1184, 1184, 1184, 1184, 1184, 1186, 1186, 1186, 1186,
     1186, 1186, 1186, 1186, 1186, 1186, 1186, 1188, 1188, 1188,
     1188, 1188, 1188, 1188, 1188, 1188, 1188, 1188, 1190, 1190,
     1190, 1190, 1190, 1190, 1190, 1190, 1190, 1190, 1190, 1192,
     1192, 1192, 1192, 1192, 1192, 1192, 1192, 1192, 1192, 1192,
     1194, 1194, 1194, 1194, 1194, 1194, 1194, 1194, 1194, 1194,
     1194, 1196, 1196, 1196, 1196, 1196, 1196, 1196, 1196, 1196,

     1196, 1196, 1198, 1198, 1198, 1198, 1198, 1198, 1198, 1198,
     1198, 1198, 1198, 1200, 1200, 1200, 1200, 1200, 1200, 1200,
     1200, 1200, 1200, 1200, 1202, 1202, 1202, 1202, 1202, 1202,
     1202, 1202, 1202, 1202, 1202, 1204, 1204, 1204, 1204, 1204,
     1204, 1204, 1204, 1204, 1204, 1204, 1206, 1206, 1206, 1206,
     1206, 1206, 1206, 1206, 1206, 1206, 1206, 1208, 1208, 1208,
     1208, 1208, 1208, 1208, 1208, 1208, 1208, 1208, 1210, 1210,
     1210, 1210, 1210, 1210, 1210, 1210, 1210, 1210, 1210, 1212,
     1212, 1212, 1212, 1212, 1212, 1212, 1212, 1212, 1212, 1212,
     1214, 1214, 1214, 1214, 1214, 1214, 1214, 1214, 1214, 1214,

     1214, 1216, 1216, 1216, 1216, 1216, 1216, 1216, 1216, 1216,
     1216, 1216, 1218, 1218, 1218, 1218, 1218, 1218, 1218, 1218,
     1218, 1218, 1218, 1220, 1220, 1220, 1220, 1220, 1220, 1220,
     1220, 1220, 1220, 1220, 1222, 1222, 1222, 1222, 1222, 1222,
     1222, 1222, 1222, 1222, 1222, 1224, 1224, 1224, 1224, 1224,
     1224, 1224, 1224, 1224, 1224, 1224, 1226, 1226, 1226, 1226,
     1226, 1226, 1226, 1226, 1226, 1226, 1226, 1228, 1228, 1228,
     1228, 1228, 1228, 1228, 1228, 1228, 1228, 1228, 1230, 1230,
     1230, 1230, 1230, 1230, 1230, 1230, 1230, 1230, 1230, 1232,
     1232, 1232, 1232, 1232, 1232, 1232, 1232, 1232, 1232, 1232,

     1234, 1234, 1234, 1234, 1234, 1234, 1234, 1234, 1234, 1234,
     1234, 1236, 1236, 1236, 1236, 1236, 1236, 1236, 1236, 1236,
     1236, 1236, 1238, 1238, 1238, 1238, 1238, 1238, 1238, 1238,
     1238, 1238, 1238, 1240, 1240, 1240, 1240, 1240, 1240, 1240,
     1240, 1240, 1240, 1240, 1242, 1242, 1242, 1242, 1242, 1242,
     1242, 1242, 1242, 1242, 1242, 1244, 1244, 1244, 1244, 1244,
     1244, 1244, 1244, 1244, 1244, 1244, 1246, 1246, 1246, 1246,
     1246, 1246, 1246, 1246, 1246, 1246, 1246, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1248, 1250, 1250,
     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1252,

     1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252,
     1254, 1254, 1254, 1254, 1254, 1254, 1254, 1254, 1254, 1254,
     1254, 1256, 1256, 1256, 1256, 1256, 1256, 1256, 1256, 1256,
     1256, 1256, 1258, 1258, 1258, 1258, 1258, 1258, 1258, 1258,
     1258, 1258, 1258, 1260, 1260, 1260, 1260, 1260, 1260, 1260,
     1260, 1260, 1260, 1260, 1262, 1262, 1262, 1262, 1262, 1262,
     1262, 1262, 1262, 1262, 1262, 1264, 1264, 1264, 1264, 1264,
     1264, 1264, 1264, 1264, 1264, 1264, 1266, 1266, 1266, 1266,
     1266, 1266, 1266, 1266, 1266, 1266, 1266, 1268, 1268, 1268,
     1268, 1268, 1268, 1268, 1268, 1268, 1268, 1268, 1270, 1270,

     1270, 1270, 1270, 1270, 1270, 1270, 1270, 1270, 1270, 1272,
     1272, 1272, 1272, 1272, 1272, 1272, 1272, 1272, 1272, 1272,
     1274, 1274, 1274, 1274, 1274, 1274, 1274, 1274, 1274, 1274,
     1274, 1276, 1276, 1276, 1276, 1276, 1276, 1276, 1276, 1276,
     1276, 1276, 1278, 1278, 1278, 1278, 1278, 1278, 1278, 1278,
     1278, 1278, 1278, 1280, 1280, 1280, 1280, 1280, 1280, 1280,
     1280, 1280, 1280, 1280, 1282, 1282, 1282, 1282, 1282, 1282,
     1282, 1282, 1282, 1282, 1282, 1284, 1284, 1284, 1284, 1284,
     1284, 1284, 1284, 1284, 1284, 1284, 1286, 1286, 1286, 1286,
     1286, 1286, 1286, 1286, 1286, 1286, 1286, 1288, 1288, 1288,

     1288, 1288, 1288, 1288, 1288, 1288, 1288, 1288, 1290, 1290,
     1290, 1290, 1290, 1290, 1290, 1290, 1290, 1290, 1290, 1292,
     1292, 1292, 1292, 1292, 1292, 1292, 1292, 1292, 1292, 1292,
     1294, 1294, 1294, 1294, 1294, 1294, 1294, 1294, 1294, 1294,
     1294, 1296, 1296, 1296, 1296, 1296, 1296, 1296, 1296, 1296,
     1296, 1296, 1298, 1298, 1298, 1298, 1298, 1298, 1298, 1298,
     1298, 1298, 1298, 1300, 1300, 1300, 1300, 1300, 1300, 1300,
     1300, 1300, 1300, 1300, 1302, 1302, 1302, 1302, 1302, 1302,
     1302, 1302, 1302, 1302, 1302, 1304, 1304, 1304, 1304, 1304,
     1304, 1304, 1304, 1304, 1304, 1304, 1306, 1306, 1306, 1306,

     1306, 1306, 1306, 1306, 1306, 1306, 1306, 1308, 1308, 1308,
     1308, 1308, 1308, 1308, 1308, 1308, 1308, 1308, 1310, 1310,
     1310, 1310, 1310, 1310, 1310, 1310, 1310, 1310, 1310, 1312,
     1312, 1312, 1312, 1312, 1312, 1312, 1312, 1312, 1312, 1312,
     1314, 1314, 1314, 1314, 1314, 1314, 1314, 1314, 1314, 1314,
     1314, 1316, 1316, 1316, 1316, 1316, 1316, 1316, 1316, 1316,
     1316, 1316, 1318, 1318, 1318, 1318, 1318, 1318, 1318, 1318,
     1318, 1318, 1318, 1320, 1320, 1320, 1320, 1320, 1320, 1320,
     1320, 1320, 1320, 1320, 1322, 1322, 1322, 1322, 1322, 1322,
     1322, 1322, 1322, 1322, 1322, 1324, 1324, 1324, 1324, 1324,

     1324, 1324, 1324, 1324, 1324, 1324, 1326, 1326, 1326, 1326,
     1326, 1326, 1326, 1326, 1326, 1326, 1326, 1328, 1328, 1328,
     1328, 1328, 1328, 1328, 1328, 1328, 1328, 1328, 1330, 1330,
     1330, 1330, 1330, 1330, 1330, 1330, 1330, 1330, 1330, 1332,
     1332, 1332, 1332, 1332, 1332, 1332, 1332, 1332, 1332, 1332,
     1334, 1334, 1334, 1334, 1334, 1334, 1334, 1334, 1334, 1334,
     1334, 1336, 1336, 1336, 1336, 1336, 1336, 1336, 1336, 1336,
     1336, 1336, 1338, 1338, 1338, 1338, 1338, 1338, 1338, 1338,
     1338, 1338, 1338, 1340, 1340, 1340, 1340, 1340, 1340, 1340,
     1340, 1340, 1340, 1340, 1342, 1342, 1342, 1342, 1342, 1342,

     1342, 1342, 1342, 1342, 1342, 1344, 1344, 1344, 1344, 1344,
     1344, 1344, 1344, 1344, 1344, 1344, 1346, 1346, 1346, 1346,
     1346, 1346, 1346, 1346, 1346, 1346, 1346, 1348, 1348, 1348,
     1348, 1348, 1348, 1348, 1348, 1348, 1348, 1348, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1352,
     1352, 1352, 1352, 1352, 1352, 1352, 1352, 1352, 1352, 1352,
     1354, 1354, 1354, 1354, 1354, 1354, 1354, 1354, 1354, 1354,
     1354, 1356, 1356, 1356, 1356, 1356, 1356, 1356, 1356, 1356,
     1356, 1356, 1358, 1358, 1358, 1358, 1358, 1358, 1358, 1358,
     1358, 1358, 1358, 1360, 1360, 1360, 1360, 1360, 1360, 1360,

     1360, 1360, 1360, 1360, 1362, 1362, 1362, 1362, 1362, 1362,
     1362, 1362, 1362, 1362, 1362, 1364, 1364, 1364, 1364, 1364,
     1364, 1364, 1364, 1364, 1364, 1364,  422,  421,  420,  419,
      418,  417,  416,  415,  414,  413,  412,  411,  410,  409,
      408,  407,  406,  405,  404,  403,  402,  401,  400,  399,
      398,  397,  396,  395,  394,  393,  332,  389,  388,  387,
      386,  385,  381,  380,  379,  378,  377,  376,  375,  371,
      370,  369,  368,  367,  366,  365,  364,  363,  362,  361,
      360,  359,  358,  357,  356,  355,  349,  348,  347,  346,
      345,  342,  341,  340,  339,  338,  337,  334,  274,  332,

      331,  330,  329,  328,  327,  326,  325,  324,  323,  322,
      254,  321,  320,  319,  236,  233,  226, 1366,  223,  220,
      213,  313,  312,  311,  310,  309,  308,  307,  304,  303,
      302,  301,  300,  299,  298,  297,  296,  293,  292,  291,
      290,  289,  288,  285,  284,  283,  282,  281,  280,  279,
      273,  272,  269,  264,  263,  262,  261,  260,  259,  258,
      257,  256, 1366,  252,  251,  249,  112,  248,  246,  246,
      245,  243,  233,  226,  223,  221,  220,  213,  203,  202,
      201,  196,  195,  192,  191,  187,  171,  167,  165,  164,
      155,  140,  118,  112, 1366,  104,  104,   23,   23,   21,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366
    } ;

static yyconst short int yy_chk[7863] =
    {   0,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,

        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    7,    8,    9,   10,   25,   25,
       25,   30,   30,   31,   36,   65,   39,   37,   44,   44,
       65,   39,   75,    7,    8,   36,   37,   37,   39,   31,
        9,   10,   75,    9,   10,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,

       11,   11,   11,   11,   11,   11,   11,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   12,  962,   12,
       12,   12,   12,   12,   12,   12,   12,   12,   12,   12,
       12,   12,   12,   12,   12,   12,   12,   12,   12,   12,
       12,   12,   12,   12,   12,   13,   13,   13,   13,   13,
       13,   13,   13,   13,   13,   13,   13,   13,   13,   13,
       13,   13,   13,   13,   13,   13,   13,   13,   13,   13,
       13,   13,   13,   13,   13,   13,   13,   13,   13,   13,
       13,   13,   13,   13,   13,   13,   13,   13,   13,   13,
       13,   13,   13,   13,   13,   13,   13,   13,   13,   13,

       13,   13,   13,   13,   13,   13,   13,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   19,
       19,   20,   20,   23,   27,   19,   55,   20,   32,   38,
       38,   38,   55,   43,   40,   38,   40,   40,   40,   43,
       43,   43,   23,   19,   19,   20,   20,   32,   27,   41,

       58,   41,   41,   41,   40,   45,   45,   50,   58,   70,
       52,   50,   50,   58,  115,   52,   23,   33,   53,   41,
       54,   52,   53,   40,   52,   93,   61,  119,   53,   54,
       54,   54,   61,   64,   85,   93,   64,  115,   91,   54,
      964,   54,   77,   91,   70,   77,   77,   77,  966,   33,
       33,  119,   33,   85,   33,   95,  277,   33,   95,   95,
       95,   87,   87,   33,  968,   91,   33,   33,  277,   33,
       72,   72,   72,   72,   87,   72,  970,   72,   72,   72,
       72,   72,   72,   72,   72,   72,   72,   72,   72,   72,
       72,   72,   72,   72,   72,   72,   72,  972,   87,   72,

       72,  974,   72,   72,   72,   72,   72,   72,   72,   72,
       72,   72,   72,   72,   72,   72,   72,   72,   72,   72,
       72,   72,   72,   72,   72,   72,   72,   72,  976,   72,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   76,   79,   92,   76,   76,   76,   94,   92,

      112,   94,   94,   94,   96,   96,  127,   79,   79,  117,
      117,  117,  121,  124,  124,  176,  112,  121,  176,  112,
      184,   92,  146,  146,  146,  127,  157,  157,  164,  164,
      978,  184,   76,  151,  151,  151,  196,  980,   94,  196,
      146,   96,  982,  112,   79,   89,   89,   89,   89,  984,
       89,  151,   89,   89,   89,   89,   89,   89,   89,   89,
       89,   89,   89,   89,   89,   89,   89,   89,   89,   89,
       89,   89,  218,  218,   89,   89,  986,   89,   89,   89,
       89,   89,   89,   89,   89,   89,   89,   89,   89,   89,
       89,   89,   89,   89,   89,   89,   89,   89,   89,   89,

       89,   89,   89,  988,   89,   98,   98,   98,   98,  990,
       98,  992,   98,   98,   98,   98,   98,   98,   98,   98,
       98,   98,   98,   98,   98,   98,   98,   98,   98,   98,
       98,   98,  285,  285,   98,   98,  994,   98,   98,   98,
       98,   98,   98,   98,   98,   98,   98,   98,   98,   98,
       98,   98,   98,   98,   98,   98,   98,   98,   98,   98,
       98,   98,   98,  152,   98,  152,  152,  152,  153,  382,
      153,  207,  996,  153,  153,  153,  154,  154,  154,  167,
      382,  207,  167,  152,  239,  239,  213,  998,  167,  229,
      154,  154,  154,  154,  154,  154,  213,  214,  239,  229,

      214,  214,  214,  215,  386,  231,  215,  215,  215,  233,
      231,  232,  219,  219,  219,  386,  232,  315,  315,  233,
      215,  215,  215,  215,  215,  215,  219,  219,  219,  219,
      219,  219,  231,  248,  333,  333,  234,  432,  232,  234,
      234,  234,  235,  392,  392,  235,  235,  235,  432,  248,
      585,  585,  248,  265,  265,  265,  266,  266,  266,  235,
      235,  235,  235,  235,  235,  267,  267,  267,  268,  268,
      268,  265, 1000,  292, 1002,  292,  248, 1004,  292,  470,
      470,  470,  268,  268,  268,  268,  268,  268,  292,  316,
      316,  316,  292,  314, 1006, 1008,  314,  314,  314, 1010,

      376,  376,  376,  316,  316,  316,  316,  316,  316,  319,
      314,  314,  314,  314,  314,  314,  317, 1012,  326,  317,
      317,  317, 1014,  375, 1016,  319, 1018, 1020,  319,  326,
      376,  427,  379,  317,  317,  317,  317,  317,  317,  375,
      433,  468,  375,  379,  439,  442,  499,  427,  471, 1022,
      427,  433,  319,  475,  326,  439,  442,  468,  476,  471,
      468,  477,  499, 1024,  475,  499,  375,  502,  379,  476,
      503,  504,  477, 1026,  427,  501,  501,  501,  502,  506,
      524,  503,  504, 1028,  468,  508,  508,  508,  537,  499,
      506,  527,  527,  527, 1030,  547,  524, 1032, 1034,  524,

     1036,  555, 1038,  563,  537,  567, 1040,  537, 1042,  571,
      508,  547, 1044,  575,  547, 1046,  527,  555,  501,  563,
      555,  567,  563,  524,  567,  571,  579, 1048,  571,  575,
     1050,  537,  575,  577,  577,  577, 1052, 1054,  547,  581,
      581,  581,  579,  584,  555,  579,  563, 1056,  567,  582,
      582,  582,  571,  582, 1058,  591,  575,  577,  582,  584,
      598, 1060,  584,  581,  586,  586,  586, 1062,  586,  579,
     1064,  591,  603,  586,  591, 1066,  598, 1068,  609,  598,
      601,  601,  601,  606,  606,  606,  584, 1070,  603, 1072,
      611,  603, 1074, 1076,  609, 1078,  582,  609,  591, 1080,

      613,  615, 1082,  598, 1084,  601,  611,  617,  606,  611,
     1086,  586,  619,  621, 1088,  603,  613,  615,  623,  613,
      615,  609,  625,  617, 1090, 1092,  617, 1094,  619,  621,
      627,  619,  621,  611,  623,  629, 1096,  623,  625, 1098,
     1100,  625, 1102,  613,  615, 1104,  627,  631,  633,  627,
      617,  629,  635,  637,  629,  619,  621, 1106,  639, 1108,
      641,  623, 1110,  631,  633,  625,  631,  633,  635,  637,
      643,  635,  637,  627,  639, 1112,  641,  639,  629,  641,
     1114,  645, 1116,  647, 1118, 1120,  643, 1122,  649,  643,
      631,  633,  651,  653, 1124,  635,  637,  645,  655,  647,

      645,  639,  647,  641,  649, 1126,  657,  649,  651,  653,
     1128,  651,  653,  643,  655, 1130, 1132,  655,  659, 1134,
     1136, 1138,  657,  661,  645,  657,  647,  663,  665,  667,
     1140,  649, 1142, 1144,  659,  651,  653,  659,  669,  661,
      671,  655,  661,  663,  665,  667,  663,  665,  667,  657,
     1146, 1148, 1150, 1152,  669, 1154,  671,  669,  673,  671,
      675,  659, 1156, 1158, 1160, 1162,  661, 1164,  677,  679,
      663,  665,  667,  681,  673,  683,  675,  673, 1166,  675,
      685,  669, 1168,  671,  677,  679,  687,  677,  679,  681,
      689,  683,  681, 1170,  683, 1172,  685, 1174,  691,  685,

     1176,  673,  687,  675, 1178,  687,  689, 1180,  693,  689,
     1182,  677,  679, 1184,  691,  695,  681,  691,  683,  697,
      699,  701, 1186,  685,  693, 1188,  703,  693,  705,  687,
      707,  695, 1190,  689,  695,  697,  699,  701,  697,  699,
      701,  691,  703, 1192,  705,  703,  707,  705, 1194,  707,
     1196,  693, 1198, 1200, 1202, 1204,  709, 1206,  695, 1208,
      711,  713,  697,  699,  701,  715,  717,  719, 1210,  703,
     1212,  705,  709,  707,  721,  709,  711,  713,  723,  711,
      713,  715,  717,  719,  715,  717,  719, 1214, 1216, 1218,
      721, 1220, 1222,  721,  723,  725,  727,  723, 1224,  709,

      729, 1226, 1228,  711,  713, 1230,  731,  733,  715,  717,
      719,  725,  727,  735,  725,  727,  729,  721,  737,  729,
     1232,  723,  731,  733, 1234,  731,  733, 1236,  739,  735,
     1238, 1240,  735, 1242,  737,  741,  743,  737,  725,  727,
     1244,  745, 1246,  729,  739, 1248,  747,  739,  749,  731,
      733,  741,  743,  751,  741,  743,  735,  745,  753, 1250,
      745,  737,  747, 1252,  749,  747,  755,  749, 1254,  751,
     1256,  739,  751, 1258,  753, 1260,  757,  753,  741,  743,
     1262,  759,  755,  761,  745,  755, 1264,  763,  765,  747,
     1266,  749,  757, 1268,  767,  757,  751,  759,  769,  761,

      759,  753,  761,  763,  765, 1270,  763,  765, 1272,  755,
      767, 1274, 1276,  767,  769, 1278,  771,  769, 1280,  757,
      773, 1282, 1284, 1286,  759, 1288,  761,  775,  777,  779,
      763,  765,  771,  781,  783,  771,  773,  767,  785,  773,
     1290,  769,  787,  775,  777,  779,  775,  777,  779,  781,
      783, 1292,  781,  783,  785, 1294, 1296,  785,  787,  771,
     1298,  787, 1300,  773,  789, 1302, 1304, 1306,  791, 1308,
      775,  777,  779,  793,  795,  797,  781,  783, 1310,  799,
      789,  785, 1312,  789,  791,  787,  801,  791, 1314,  793,
      795,  797,  793,  795,  797,  799,  803, 1316,  799, 1318,

     1320, 1322,  801, 1324,  805,  801, 1326,  789,  807,  809,
     1328,  791,  803, 1330,  811,  803,  793,  795,  797,  813,
      805,  815,  799,  805,  807,  809,  817,  807,  809,  801,
      811, 1332, 1334,  811,  819,  813, 1336,  815,  813,  803,
      815, 1338,  817, 1340,  821,  817, 1342,  805, 1344,  823,
      819,  807,  809,  819,  825,  827,  829,  811, 1346, 1348,
      821, 1350,  813,  821,  815,  823,  831,  833,  823,  817,
      825,  827,  829,  825,  827,  829, 1352,  819, 1354, 1356,
     1358, 1360,  831,  833,  835,  831,  833,  821,  837,  839,
     1362, 1374,  823,  960,  958,  841,  843,  825,  827,  829,

      835,  845,  847,  835,  837,  839,  849,  837,  839,  831,
      833,  841,  843,  956,  841,  843,  954,  845,  847,  952,
      845,  847,  849,  950,  851,  849,  948,  835,  946,  944,
      942,  837,  839,  940,  853,  855,  857,  938,  841,  843,
      851,  859,  861,  851,  845,  847,  863,  865,  936,  849,
      853,  855,  857,  853,  855,  857,  867,  859,  861,  934,
      859,  861,  863,  865,  869,  863,  865,  851,  932,  930,
      928,  926,  867,  924,  922,  867,  871,  853,  855,  857,
      869,  873,  875,  869,  859,  861,  877,  879,  920,  863,
      865,  918,  871,  881,  883,  871,  916,  873,  875,  867,

      873,  875,  877,  879,  885,  877,  879,  869,  914,  881,
      883,  912,  881,  883,  910,  887,  889,  908,  906,  871,
      885,  904,  891,  885,  873,  875,  893,  895,  902,  877,
      879,  887,  889,  897,  887,  889,  881,  883,  891,  900,
      898,  891,  893,  895,  899,  893,  895,  885,  901,  897,
      896,  894,  897,  892,  890,  903,  905,  888,  887,  889,
      899,  907,  909,  899,  901,  891,  911,  901,  886,  893,
      895,  903,  905,  913,  903,  905,  897,  907,  909,  884,
      907,  909,  911,  882,  915,  911,  880,  899,  878,  913,
      876,  901,  913,  874,  917,  919,  921,  872,  903,  905,

      915,  923,  925,  915,  907,  909,  927,  929,  870,  911,
      917,  919,  921,  917,  919,  921,  913,  923,  925,  868,
      923,  925,  927,  929,  931,  927,  929,  915,  866,  864,
      862,  860,  933,  858,  856,  854,  935,  917,  919,  921,
      931,  937,  939,  931,  923,  925,  941,  943,  933,  927,
      929,  933,  935,  945,  947,  935,  852,  937,  939,  850,
      937,  939,  941,  943,  949,  941,  943,  931,  848,  945,
      947,  846,  945,  947,  844,  933,  951,  842,  840,  935,
      949,  838,  953,  949,  937,  939,  955,  957,  836,  941,
      943,  834,  951,  959,  961,  951,  945,  947,  953,  963,

      832,  953,  955,  957,  965,  955,  957,  949,  967,  959,
      961,  830,  959,  961,  828,  963,  969,  826,  963,  951,
      965,  824,  971,  965,  967,  953,  822,  967,  820,  955,
      957,  818,  969,  973,  975,  969,  959,  961,  971,  977,
      816,  971,  963,  814,  979,  981,  812,  965,  810,  973,
      975,  967,  973,  975,  983,  977,  985,  808,  977,  969,
      979,  981,  987,  979,  981,  971,  806,  989,  804,  802,
      983,  800,  985,  983,  991,  985,  973,  975,  987,  993,
      798,  987,  977,  989,  995,  997,  989,  979,  981,  796,
      991,  794,  999,  991,  792,  993, 1001,  983,  993,  985,

      995,  997, 1003,  995,  997,  987,  790, 1005,  999,  788,
      989,  999, 1001, 1007, 1009, 1001,  786,  991, 1003,  784,
      782, 1003,  993, 1005, 1011, 1013, 1005,  995,  997, 1007,
     1009,  780, 1007, 1009,  778,  999, 1015,  776,  774, 1001,
     1011, 1013, 1017, 1011, 1013, 1003, 1019, 1021,  772,  770,
     1005,  768, 1015, 1023, 1025, 1015, 1007, 1009, 1017, 1027,
      766, 1017, 1019, 1021, 1029, 1019, 1021, 1011, 1013, 1023,
     1025,  764, 1023, 1025,  762, 1027, 1031,  760, 1027, 1015,
     1029,  758, 1033, 1029, 1035, 1017,  756,  754,  752, 1019,
     1021,  750, 1031, 1037, 1039, 1031, 1023, 1025, 1033, 1041,

     1035, 1033, 1027, 1035, 1043, 1045,  748, 1029,  746, 1037,
     1039,  744, 1037, 1039, 1047, 1041, 1049,  742, 1041, 1031,
     1043, 1045, 1051, 1043, 1045, 1033,  740, 1035,  738,  736,
     1047,  734, 1049, 1047, 1053, 1049, 1037, 1039, 1051, 1055,
      732, 1051, 1041,  730, 1057, 1059,  728, 1043, 1045,  726,
     1053, 1061, 1063, 1053,  724, 1055, 1065, 1047, 1055, 1049,
     1057, 1059, 1067, 1057, 1059, 1051,  722, 1061, 1063,  720,
     1061, 1063, 1065, 1069, 1071, 1065,  718, 1053, 1067,  716,
      714, 1067, 1055,  712, 1073, 1075,  710, 1057, 1059, 1069,
     1071, 1077, 1069, 1071, 1061, 1063, 1079,  708,  706, 1065,

     1073, 1075, 1081, 1073, 1075, 1067, 1083, 1077,  704,  702,
     1077,  700, 1079, 1085, 1087, 1079, 1069, 1071, 1081, 1089,
      698, 1081, 1083,  696, 1091, 1083,  694, 1073, 1075, 1085,
     1087, 1093, 1085, 1087, 1077, 1089, 1095,  692, 1089, 1079,
     1091,  690, 1097, 1091, 1099, 1081,  688, 1093,  686, 1083,
     1093,  684, 1095, 1101, 1103, 1095, 1085, 1087, 1097, 1105,
     1099, 1097, 1089, 1099, 1107, 1109,  682, 1091,  680, 1101,
     1103,  678, 1101, 1103, 1093, 1105, 1111,  676, 1105, 1095,
     1107, 1109, 1113, 1107, 1109, 1097,  674, 1099,  672,  670,
     1115,  668, 1111,  666, 1117, 1111, 1101, 1103, 1113, 1119,

      664, 1113, 1105,  662, 1121, 1123, 1115, 1107, 1109, 1115,
     1117, 1125, 1127, 1117,  660, 1119, 1129,  658, 1119, 1111,
     1121, 1123, 1131, 1121, 1123, 1113,  656, 1125, 1127,  654,
     1125, 1127, 1129, 1115, 1133, 1129,  652, 1117, 1131,  650,
      648, 1131, 1119,  646, 1135, 1137,  644, 1121, 1123,  642,
     1133, 1139, 1141, 1133, 1125, 1127, 1143, 1145,  640, 1129,
     1135, 1137, 1147, 1135, 1137, 1131, 1149, 1139, 1141,  638,
     1139, 1141, 1143, 1145, 1151, 1143, 1145, 1133, 1147,  636,
      634, 1147, 1149,  632,  630, 1149,  628, 1135, 1137,  626,
     1151, 1153, 1155, 1151, 1139, 1141, 1157, 1159,  624, 1143,

     1145,  622, 1161, 1163, 1165, 1147,  620, 1153, 1155, 1149,
     1153, 1155, 1157, 1159, 1167, 1157, 1159, 1151, 1161, 1163,
     1165, 1161, 1163, 1165,  618, 1169,  616,  614,  612,  610,
     1167,  608, 1171, 1167, 1153, 1155, 1173, 1175,  605, 1157,
     1159, 1169, 1177, 1179, 1169, 1161, 1163, 1165, 1171,  604,
     1181, 1171, 1173, 1175, 1183, 1173, 1175, 1167, 1177, 1179,
      602, 1177, 1179,  600,  599, 1185, 1181,  597, 1169, 1181,
     1183, 1187, 1189, 1183,  596, 1171, 1191,  595,  594, 1173,
     1175, 1185, 1193, 1195, 1185, 1177, 1179, 1187, 1189,  593,
     1187, 1189, 1191, 1181, 1197, 1191,  590, 1183, 1193, 1195,

      589, 1193, 1195,  588, 1199, 1201,  587,  583, 1185,  580,
     1197, 1203, 1205, 1197, 1187, 1189, 1207, 1209,  578, 1191,
     1199, 1201, 1211, 1199, 1201, 1193, 1195, 1203, 1205,  576,
     1203, 1205, 1207, 1209, 1213, 1207, 1209, 1197, 1211,  574,
      573, 1211, 1215,  572,  570,  569,  568, 1199, 1201,  566,
     1213, 1217, 1219, 1213, 1203, 1205, 1221, 1223, 1215, 1207,
     1209, 1215, 1225, 1227, 1229, 1211,  565, 1217, 1219,  564,
     1217, 1219, 1221, 1223, 1231, 1221, 1223, 1213, 1225, 1227,
     1229, 1225, 1227, 1229,  562, 1215,  557,  556,  554,  553,
     1231,  552, 1233, 1231, 1217, 1219, 1235, 1237,  551, 1221,

     1223,  550, 1239, 1241, 1243, 1225, 1227, 1229, 1233, 1245,
     1247, 1233, 1235, 1237, 1249, 1235, 1237, 1231, 1239, 1241,
     1243, 1239, 1241, 1243,  549, 1245, 1247,  548, 1245, 1247,
     1249,  546, 1251, 1249,  545, 1233,  544,  543,  540, 1235,
     1237,  539, 1253, 1255, 1257, 1239, 1241, 1243, 1251, 1259,
     1261, 1251, 1245, 1247, 1263, 1265,  538, 1249, 1253, 1255,
     1257, 1253, 1255, 1257, 1267, 1259, 1261,  536, 1259, 1261,
     1263, 1265, 1269, 1263, 1265, 1251,  535,  534,  533,  531,
     1267,  530,  529, 1267, 1271, 1253, 1255, 1257, 1269, 1273,
     1275, 1269, 1259, 1261, 1277, 1279,  526, 1263, 1265,  525,

     1271, 1281, 1283, 1271,  523, 1273, 1275, 1267, 1273, 1275,
     1277, 1279, 1285, 1277, 1279, 1269,  522, 1281, 1283,  521,
     1281, 1283,  520, 1287, 1289,  517,  516, 1271, 1285,  515,
     1291, 1285, 1273, 1275, 1293, 1295,  513, 1277, 1279, 1287,
     1289, 1297, 1287, 1289, 1281, 1283, 1291,  511,  509, 1291,
     1293, 1295, 1299, 1293, 1295, 1285, 1301, 1297,  500,  498,
     1297,  497,  496, 1303, 1305,  495, 1287, 1289, 1299, 1307,
     1309, 1299, 1301, 1291, 1311, 1301,  494, 1293, 1295, 1303,
     1305, 1313, 1303, 1305, 1297, 1307, 1309,  491, 1307, 1309,
     1311,  490, 1315, 1311,  489, 1299,  488, 1313,  485, 1301,

     1313,  484, 1317, 1319, 1321,  483, 1303, 1305, 1315, 1323,
     1325, 1315, 1307, 1309, 1327, 1329,  482, 1311, 1317, 1319,
     1321, 1317, 1319, 1321, 1313, 1323, 1325,  481, 1323, 1325,
     1327, 1329, 1331, 1327, 1329, 1315,  480,  479,  474,  473,
     1333,  469,  467,  463, 1335, 1317, 1319, 1321, 1331, 1337,
     1339, 1331, 1323, 1325, 1341, 1343, 1333, 1327, 1329, 1333,
     1335, 1345, 1347, 1335,  462, 1337, 1339,  461, 1337, 1339,
     1341, 1343, 1349, 1341, 1343, 1331,  459, 1345, 1347,  458,
     1345, 1347,  457, 1333, 1351,  456,  455, 1335, 1349,  454,
     1353, 1349, 1337, 1339, 1355, 1357,  453, 1341, 1343,  451,

     1351, 1359, 1361, 1351, 1345, 1347, 1353, 1363,  450, 1353,
     1355, 1357, 1365, 1355, 1357, 1349,  449, 1359, 1361,  448,
     1359, 1361,  447, 1363,  446,  445, 1363, 1351, 1365,  444,
      443, 1365,  441, 1353,  438,  437,  436, 1355, 1357,  435,
      431,  430,  429,  426, 1359, 1361,  423,  422,  421,  420,
     1363,  418,  416,  415,  414, 1365, 1367, 1367, 1367, 1367,
     1367, 1367, 1367, 1367, 1367, 1367, 1367, 1368, 1368, 1368,
     1368, 1368, 1368, 1368, 1368, 1368, 1368, 1368, 1369, 1369,
     1369, 1369, 1369, 1369, 1369, 1369, 1369, 1369, 1369, 1370,
     1370, 1370, 1370, 1370, 1370, 1370, 1370, 1370, 1370, 1370,

     1371, 1371, 1371, 1371, 1371, 1371, 1371, 1371, 1371, 1371,
     1371, 1372, 1372, 1372, 1372, 1372, 1372, 1372, 1372, 1372,
      413, 1372, 1373, 1373, 1373, 1373,  412, 1373, 1373, 1373,
     1373, 1373, 1373, 1375, 1375, 1375, 1375, 1375, 1375, 1375,
     1375, 1375, 1375, 1375, 1376,  411, 1376, 1377, 1377, 1377,
      410, 1377, 1377, 1377, 1377, 1377, 1377, 1378, 1378, 1378,
     1378, 1378, 1378, 1378, 1378, 1378, 1378, 1378, 1379, 1379,
     1379, 1379, 1379, 1379,  408, 1379, 1379, 1379, 1379, 1380,
     1380, 1380,  407, 1380, 1380, 1380,  405, 1380, 1381,  404,
     1381,  403, 1381, 1381, 1381, 1381, 1381, 1381, 1382,  402,

     1382, 1383,  399, 1383, 1384, 1384, 1384, 1384, 1384, 1384,
     1384,  396, 1384, 1384, 1384, 1385, 1385,  395, 1385, 1385,
      394, 1385, 1385, 1385, 1385, 1385, 1386, 1386, 1386, 1386,
     1386, 1386, 1386, 1386, 1386, 1386, 1386, 1387,  393, 1387,
     1388, 1388, 1388, 1388, 1388, 1388, 1388, 1388, 1388, 1388,
     1388, 1389,  391,  389,  388,  387,  385,  384,  381,  380,
     1389, 1390, 1390, 1390, 1390, 1390, 1390, 1390, 1390, 1390,
     1390, 1390, 1391,  378,  377,  374,  371,  370, 1391,  369,
     1391, 1392, 1392, 1392, 1392, 1392, 1392, 1392, 1392, 1392,
     1392, 1392, 1393, 1393, 1393, 1393, 1393, 1393, 1393, 1393,

     1393, 1393, 1393, 1394, 1394, 1394, 1394, 1394, 1394, 1394,
     1394, 1394, 1394, 1394, 1395, 1395, 1395, 1395, 1395, 1395,
     1395, 1395, 1395, 1395, 1395, 1396, 1396, 1396, 1396, 1396,
     1396, 1396, 1396, 1396, 1396, 1396, 1397, 1397, 1397, 1397,
     1397, 1397, 1397, 1397, 1397, 1397, 1397, 1398, 1398, 1398,
     1398, 1398, 1398, 1398, 1398, 1398, 1398, 1398, 1399, 1399,
     1399, 1399, 1399, 1399, 1399, 1399, 1399, 1399, 1399, 1400,
     1400, 1400, 1400, 1400, 1400, 1400, 1400, 1400, 1400, 1400,
     1401, 1401, 1401, 1401, 1401, 1401, 1401, 1401, 1401, 1401,
     1401, 1402, 1402, 1402, 1402, 1402, 1402, 1402, 1402, 1402,

     1402, 1402, 1403, 1403, 1403, 1403, 1403, 1403, 1403, 1403,
     1403, 1403, 1403, 1404, 1404, 1404, 1404, 1404, 1404, 1404,
     1404, 1404, 1404, 1404, 1405, 1405, 1405, 1405, 1405, 1405,
     1405, 1405, 1405, 1405, 1405, 1406, 1406, 1406, 1406, 1406,
     1406, 1406, 1406, 1406, 1406, 1406, 1407, 1407, 1407, 1407,
     1407, 1407, 1407, 1407, 1407, 1407, 1407, 1408, 1408, 1408,
     1408, 1408, 1408, 1408, 1408, 1408, 1408, 1408, 1409, 1409,
     1409, 1409, 1409, 1409, 1409, 1409, 1409, 1409, 1409, 1410,
     1410, 1410, 1410, 1410, 1410, 1410, 1410, 1410, 1410, 1410,
     1411, 1411, 1411, 1411, 1411, 1411, 1411, 1411, 1411, 1411,

     1411, 1412, 1412, 1412, 1412, 1412, 1412, 1412, 1412, 1412,
     1412, 1412, 1413, 1413, 1413, 1413, 1413, 1413, 1413, 1413,
     1413, 1413, 1413, 1414, 1414, 1414, 1414, 1414, 1414, 1414,
     1414, 1414, 1414, 1414, 1415, 1415, 1415, 1415, 1415, 1415,
     1415, 1415, 1415, 1415, 1415, 1416, 1416, 1416, 1416, 1416,
     1416, 1416, 1416, 1416, 1416, 1416, 1417, 1417, 1417, 1417,
     1417, 1417, 1417, 1417, 1417, 1417, 1417, 1418, 1418, 1418,
     1418, 1418, 1418, 1418, 1418, 1418, 1418, 1418, 1419, 1419,
     1419, 1419, 1419, 1419, 1419, 1419, 1419, 1419, 1419, 1420,
     1420, 1420, 1420, 1420, 1420, 1420, 1420, 1420, 1420, 1420,

     1421, 1421, 1421, 1421, 1421, 1421, 1421, 1421, 1421, 1421,
     1421, 1422, 1422, 1422, 1422, 1422, 1422, 1422, 1422, 1422,
     1422, 1422, 1423, 1423, 1423, 1423, 1423, 1423, 1423, 1423,
     1423, 1423, 1423, 1424, 1424, 1424, 1424, 1424, 1424, 1424,
     1424, 1424, 1424, 1424, 1425, 1425, 1425, 1425, 1425, 1425,
     1425, 1425, 1425, 1425, 1425, 1426, 1426, 1426, 1426, 1426,
     1426, 1426, 1426, 1426, 1426, 1426, 1427, 1427, 1427, 1427,
     1427, 1427, 1427, 1427, 1427, 1427, 1427, 1428, 1428, 1428,
     1428, 1428, 1428, 1428, 1428, 1428, 1428, 1428, 1429, 1429,
     1429, 1429, 1429, 1429, 1429, 1429, 1429, 1429, 1429, 1430,

     1430, 1430, 1430, 1430, 1430, 1430, 1430, 1430, 1430, 1430,
     1431, 1431, 1431, 1431, 1431, 1431, 1431, 1431, 1431, 1431,
     1431, 1432, 1432, 1432, 1432, 1432, 1432, 1432, 1432, 1432,
     1432, 1432, 1433, 1433, 1433, 1433, 1433, 1433, 1433, 1433,
     1433, 1433, 1433, 1434, 1434, 1434, 1434, 1434, 1434, 1434,
     1434, 1434, 1434, 1434, 1435, 1435, 1435, 1435, 1435, 1435,
     1435, 1435, 1435, 1435, 1435, 1436, 1436, 1436, 1436, 1436,
     1436, 1436, 1436, 1436, 1436, 1436, 1437, 1437, 1437, 1437,
     1437, 1437, 1437, 1437, 1437, 1437, 1437, 1438, 1438, 1438,
     1438, 1438, 1438, 1438, 1438, 1438, 1438, 1438, 1439, 1439,

     1439, 1439, 1439, 1439, 1439, 1439, 1439, 1439, 1439, 1440,
     1440, 1440, 1440, 1440, 1440, 1440, 1440, 1440, 1440, 1440,
     1441, 1441, 1441, 1441, 1441, 1441, 1441, 1441, 1441, 1441,
     1441, 1442, 1442, 1442, 1442, 1442, 1442, 1442, 1442, 1442,
     1442, 1442, 1443, 1443, 1443, 1443, 1443, 1443, 1443, 1443,
     1443, 1443, 1443, 1444, 1444, 1444, 1444, 1444, 1444, 1444,
     1444, 1444, 1444, 1444, 1445, 1445, 1445, 1445, 1445, 1445,
     1445, 1445, 1445, 1445, 1445, 1446, 1446, 1446, 1446, 1446,
     1446, 1446, 1446, 1446, 1446, 1446, 1447, 1447, 1447, 1447,
     1447, 1447, 1447, 1447, 1447, 1447, 1447, 1448, 1448, 1448,

     1448, 1448, 1448, 1448, 1448, 1448, 1448, 1448, 1449, 1449,
     1449, 1449, 1449, 1449, 1449, 1449, 1449, 1449, 1449, 1450,
     1450, 1450, 1450, 1450, 1450, 1450, 1450, 1450, 1450, 1450,
     1451, 1451, 1451, 1451, 1451, 1451, 1451, 1451, 1451, 1451,
     1451, 1452, 1452, 1452, 1452, 1452, 1452, 1452, 1452, 1452,
     1452, 1452, 1453, 1453, 1453, 1453, 1453, 1453, 1453, 1453,
     1453, 1453, 1453, 1454, 1454, 1454, 1454, 1454, 1454, 1454,
     1454, 1454, 1454, 1454, 1455, 1455, 1455, 1455, 1455, 1455,
     1455, 1455, 1455, 1455, 1455, 1456, 1456, 1456, 1456, 1456,
     1456, 1456, 1456, 1456, 1456, 1456, 1457, 1457, 1457, 1457,

     1457, 1457, 1457, 1457, 1457, 1457, 1457, 1458, 1458, 1458,
     1458, 1458, 1458, 1458, 1458, 1458, 1458, 1458, 1459, 1459,
     1459, 1459, 1459, 1459, 1459, 1459, 1459, 1459, 1459, 1460,
     1460, 1460, 1460, 1460, 1460, 1460, 1460, 1460, 1460, 1460,
     1461, 1461, 1461, 1461, 1461, 1461, 1461, 1461, 1461, 1461,
     1461, 1462, 1462, 1462, 1462, 1462, 1462, 1462, 1462, 1462,
     1462, 1462, 1463, 1463, 1463, 1463, 1463, 1463, 1463, 1463,
     1463, 1463, 1463, 1464, 1464, 1464, 1464, 1464, 1464, 1464,
     1464, 1464, 1464, 1464, 1465, 1465, 1465, 1465, 1465, 1465,
     1465, 1465, 1465, 1465, 1465, 1466, 1466, 1466, 1466, 1466,

     1466, 1466, 1466, 1466, 1466, 1466, 1467, 1467, 1467, 1467,
     1467, 1467, 1467, 1467, 1467, 1467, 1467, 1468, 1468, 1468,
     1468, 1468, 1468, 1468, 1468, 1468, 1468, 1468, 1469, 1469,
     1469, 1469, 1469, 1469, 1469, 1469, 1469, 1469, 1469, 1470,
     1470, 1470, 1470, 1470, 1470, 1470, 1470, 1470, 1470, 1470,
     1471, 1471, 1471, 1471, 1471, 1471, 1471, 1471, 1471, 1471,
     1471, 1472, 1472, 1472, 1472, 1472, 1472, 1472, 1472, 1472,
     1472, 1472, 1473, 1473, 1473, 1473, 1473, 1473, 1473, 1473,
     1473, 1473, 1473, 1474, 1474, 1474, 1474, 1474, 1474, 1474,
     1474, 1474, 1474, 1474, 1475, 1475, 1475, 1475, 1475, 1475,

     1475, 1475, 1475, 1475, 1475, 1476, 1476, 1476, 1476, 1476,
     1476, 1476, 1476, 1476, 1476, 1476, 1477, 1477, 1477, 1477,
     1477, 1477, 1477, 1477, 1477, 1477, 1477, 1478, 1478, 1478,
     1478, 1478, 1478, 1478, 1478, 1478, 1478, 1478, 1479, 1479,
     1479, 1479, 1479, 1479, 1479, 1479, 1479, 1479, 1479, 1480,
     1480, 1480, 1480, 1480, 1480, 1480, 1480, 1480, 1480, 1480,
     1481, 1481, 1481, 1481, 1481, 1481, 1481, 1481, 1481, 1481,
     1481, 1482, 1482, 1482, 1482, 1482, 1482, 1482, 1482, 1482,
     1482, 1482, 1483, 1483, 1483, 1483, 1483, 1483, 1483, 1483,
     1483, 1483, 1483, 1484, 1484, 1484, 1484, 1484, 1484, 1484,

     1484, 1484, 1484, 1484, 1485, 1485, 1485, 1485, 1485, 1485,
     1485, 1485, 1485, 1485, 1485, 1486, 1486, 1486, 1486, 1486,
     1486, 1486, 1486, 1486, 1486, 1486, 1487, 1487, 1487, 1487,
     1487, 1487, 1487, 1487, 1487, 1487, 1487, 1488, 1488, 1488,
     1488, 1488, 1488, 1488, 1488, 1488, 1488, 1488, 1489, 1489,
     1489, 1489, 1489, 1489, 1489, 1489, 1489, 1489, 1489, 1490,
     1490, 1490, 1490, 1490, 1490, 1490, 1490, 1490, 1490, 1490,
     1491, 1491, 1491, 1491, 1491, 1491, 1491, 1491, 1491, 1491,
     1491, 1492, 1492, 1492, 1492, 1492, 1492, 1492, 1492, 1492,
     1492, 1492, 1493, 1493, 1493, 1493, 1493, 1493, 1493, 1493,

     1493, 1493, 1493, 1494, 1494, 1494, 1494, 1494, 1494, 1494,
     1494, 1494, 1494, 1494, 1495, 1495, 1495, 1495, 1495, 1495,
     1495, 1495, 1495, 1495, 1495, 1496, 1496, 1496, 1496, 1496,
     1496, 1496, 1496, 1496, 1496, 1496, 1497, 1497, 1497, 1497,
     1497, 1497, 1497, 1497, 1497, 1497, 1497, 1498, 1498, 1498,
     1498, 1498, 1498, 1498, 1498, 1498, 1498, 1498, 1499, 1499,
     1499, 1499, 1499, 1499, 1499, 1499, 1499, 1499, 1499, 1500,
     1500, 1500, 1500, 1500, 1500, 1500, 1500, 1500, 1500, 1500,
     1501, 1501, 1501, 1501, 1501, 1501, 1501, 1501, 1501, 1501,
     1501, 1502, 1502, 1502, 1502, 1502, 1502, 1502, 1502, 1502,

     1502, 1502, 1503, 1503, 1503, 1503, 1503, 1503, 1503, 1503,
     1503, 1503, 1503, 1504, 1504, 1504, 1504, 1504, 1504, 1504,
     1504, 1504, 1504, 1504, 1505, 1505, 1505, 1505, 1505, 1505,
     1505, 1505, 1505, 1505, 1505, 1506, 1506, 1506, 1506, 1506,
     1506, 1506, 1506, 1506, 1506, 1506, 1507, 1507, 1507, 1507,
     1507, 1507, 1507, 1507, 1507, 1507, 1507, 1508, 1508, 1508,
     1508, 1508, 1508, 1508, 1508, 1508, 1508, 1508, 1509, 1509,
     1509, 1509, 1509, 1509, 1509, 1509, 1509, 1509, 1509, 1510,
     1510, 1510, 1510, 1510, 1510, 1510, 1510, 1510, 1510, 1510,
     1511, 1511, 1511, 1511, 1511, 1511, 1511, 1511, 1511, 1511,

     1511, 1512, 1512, 1512, 1512, 1512, 1512, 1512, 1512, 1512,
     1512, 1512, 1513, 1513, 1513, 1513, 1513, 1513, 1513, 1513,
     1513, 1513, 1513, 1514, 1514, 1514, 1514, 1514, 1514, 1514,
     1514, 1514, 1514, 1514, 1515, 1515, 1515, 1515, 1515, 1515,
     1515, 1515, 1515, 1515, 1515, 1516, 1516, 1516, 1516, 1516,
     1516, 1516, 1516, 1516, 1516, 1516, 1517, 1517, 1517, 1517,
     1517, 1517, 1517, 1517, 1517, 1517, 1517, 1518, 1518, 1518,
     1518, 1518, 1518, 1518, 1518, 1518, 1518, 1518, 1519, 1519,
     1519, 1519, 1519, 1519, 1519, 1519, 1519, 1519, 1519, 1520,
     1520, 1520, 1520, 1520, 1520, 1520, 1520, 1520, 1520, 1520,

     1521, 1521, 1521, 1521, 1521, 1521, 1521, 1521, 1521, 1521,
     1521, 1522, 1522, 1522, 1522, 1522, 1522, 1522, 1522, 1522,
     1522, 1522, 1523, 1523, 1523, 1523, 1523, 1523, 1523, 1523,
     1523, 1523, 1523, 1524, 1524, 1524, 1524, 1524, 1524, 1524,
     1524, 1524, 1524, 1524, 1525, 1525, 1525, 1525, 1525, 1525,
     1525, 1525, 1525, 1525, 1525, 1526, 1526, 1526, 1526, 1526,
     1526, 1526, 1526, 1526, 1526, 1526, 1527, 1527, 1527, 1527,
     1527, 1527, 1527, 1527, 1527, 1527, 1527, 1528, 1528, 1528,
     1528, 1528, 1528, 1528, 1528, 1528, 1528, 1528, 1529, 1529,
     1529, 1529, 1529, 1529, 1529, 1529, 1529, 1529, 1529, 1530,

     1530, 1530, 1530, 1530, 1530, 1530, 1530, 1530, 1530, 1530,
     1531, 1531, 1531, 1531, 1531, 1531, 1531, 1531, 1531, 1531,
     1531, 1532, 1532, 1532, 1532, 1532, 1532, 1532, 1532, 1532,
     1532, 1532, 1533, 1533, 1533, 1533, 1533, 1533, 1533, 1533,
     1533, 1533, 1533, 1534, 1534, 1534, 1534, 1534, 1534, 1534,
     1534, 1534, 1534, 1534, 1535, 1535, 1535, 1535, 1535, 1535,
     1535, 1535, 1535, 1535, 1535, 1536, 1536, 1536, 1536, 1536,
     1536, 1536, 1536, 1536, 1536, 1536, 1537, 1537, 1537, 1537,
     1537, 1537, 1537, 1537, 1537, 1537, 1537, 1538, 1538, 1538,
     1538, 1538, 1538, 1538, 1538, 1538, 1538, 1538, 1539, 1539,

     1539, 1539, 1539, 1539, 1539, 1539, 1539, 1539, 1539, 1540,
     1540, 1540, 1540, 1540, 1540, 1540, 1540, 1540, 1540, 1540,
     1541, 1541, 1541, 1541, 1541, 1541, 1541, 1541, 1541, 1541,
     1541, 1542, 1542, 1542, 1542, 1542, 1542, 1542, 1542, 1542,
     1542, 1542, 1543, 1543, 1543, 1543, 1543, 1543, 1543, 1543,
     1543, 1543, 1543, 1544, 1544, 1544, 1544, 1544, 1544, 1544,
     1544, 1544, 1544, 1544, 1545, 1545, 1545, 1545, 1545, 1545,
     1545, 1545, 1545, 1545, 1545, 1546, 1546, 1546, 1546, 1546,
     1546, 1546, 1546, 1546, 1546, 1546, 1547, 1547, 1547, 1547,
     1547, 1547, 1547, 1547, 1547, 1547, 1547, 1548, 1548, 1548,

     1548, 1548, 1548, 1548, 1548, 1548, 1548, 1548, 1549, 1549,
     1549, 1549, 1549, 1549, 1549, 1549, 1549, 1549, 1549, 1550,
     1550, 1550, 1550, 1550, 1550, 1550, 1550, 1550, 1550, 1550,
     1551, 1551, 1551, 1551, 1551, 1551, 1551, 1551, 1551, 1551,
     1551, 1552, 1552, 1552, 1552, 1552, 1552, 1552, 1552, 1552,
     1552, 1552, 1553, 1553, 1553, 1553, 1553, 1553, 1553, 1553,
     1553, 1553, 1553, 1554, 1554, 1554, 1554, 1554, 1554, 1554,
     1554, 1554, 1554, 1554, 1555, 1555, 1555, 1555, 1555, 1555,
     1555, 1555, 1555, 1555, 1555, 1556, 1556, 1556, 1556, 1556,
     1556, 1556, 1556, 1556, 1556, 1556, 1557, 1557, 1557, 1557,

     1557, 1557, 1557, 1557, 1557, 1557, 1557, 1558, 1558, 1558,
     1558, 1558, 1558, 1558, 1558, 1558, 1558, 1558, 1559, 1559,
     1559, 1559, 1559, 1559, 1559, 1559, 1559, 1559, 1559, 1560,
     1560, 1560, 1560, 1560, 1560, 1560, 1560, 1560, 1560, 1560,
     1561, 1561, 1561, 1561, 1561, 1561, 1561, 1561, 1561, 1561,
     1561, 1562, 1562, 1562, 1562, 1562, 1562, 1562, 1562, 1562,
     1562, 1562, 1563, 1563, 1563, 1563, 1563, 1563, 1563, 1563,
     1563, 1563, 1563, 1564, 1564, 1564, 1564, 1564, 1564, 1564,
     1564, 1564, 1564, 1564, 1565, 1565, 1565, 1565, 1565, 1565,
     1565, 1565, 1565, 1565, 1565, 1566, 1566, 1566, 1566, 1566,

     1566, 1566, 1566, 1566, 1566, 1566, 1567, 1567, 1567, 1567,
     1567, 1567, 1567, 1567, 1567, 1567, 1567, 1568, 1568, 1568,
     1568, 1568, 1568, 1568, 1568, 1568, 1568, 1568, 1569, 1569,
     1569, 1569, 1569, 1569, 1569, 1569, 1569, 1569, 1569, 1570,
     1570, 1570, 1570, 1570, 1570, 1570, 1570, 1570, 1570, 1570,
     1571, 1571, 1571, 1571, 1571, 1571, 1571, 1571, 1571, 1571,
     1571, 1572, 1572, 1572, 1572, 1572, 1572, 1572, 1572, 1572,
     1572, 1572, 1573, 1573, 1573, 1573, 1573, 1573, 1573, 1573,
     1573, 1573, 1573, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1575, 1575, 1575, 1575, 1575, 1575,

     1575, 1575, 1575, 1575, 1575, 1576, 1576, 1576, 1576, 1576,
     1576, 1576, 1576, 1576, 1576, 1576, 1577, 1577, 1577, 1577,
     1577, 1577, 1577, 1577, 1577, 1577, 1577, 1578, 1578, 1578,
     1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1579, 1579,
     1579, 1579, 1579, 1579, 1579, 1579, 1579, 1579, 1579, 1580,
     1580, 1580, 1580, 1580, 1580, 1580, 1580, 1580, 1580, 1580,
     1581, 1581, 1581, 1581, 1581, 1581, 1581, 1581, 1581, 1581,
     1581, 1582, 1582, 1582, 1582, 1582, 1582, 1582, 1582, 1582,
     1582, 1582, 1583, 1583, 1583, 1583, 1583, 1583, 1583, 1583,
     1583, 1583, 1583, 1584, 1584, 1584, 1584, 1584, 1584, 1584,

     1584, 1584, 1584, 1584, 1585, 1585, 1585, 1585, 1585, 1585,
     1585, 1585, 1585, 1585, 1585, 1586, 1586, 1586, 1586, 1586,
     1586, 1586, 1586, 1586, 1586, 1586, 1587, 1587, 1587, 1587,
     1587, 1587, 1587, 1587, 1587, 1587, 1587, 1588, 1588, 1588,
     1588, 1588, 1588, 1588, 1588, 1588, 1588, 1588, 1589, 1589,
     1589, 1589, 1589, 1589, 1589, 1589, 1589, 1589, 1589, 1590,
     1590, 1590, 1590, 1590, 1590, 1590, 1590, 1590, 1590, 1590,
     1591, 1591, 1591, 1591, 1591, 1591, 1591, 1591, 1591, 1591,
     1591, 1592, 1592, 1592, 1592, 1592, 1592, 1592, 1592, 1592,
     1592, 1592, 1593, 1593, 1593, 1593, 1593, 1593, 1593, 1593,

     1593, 1593, 1593, 1594, 1594, 1594, 1594, 1594, 1594, 1594,
     1594, 1594, 1594, 1594, 1595, 1595, 1595, 1595, 1595, 1595,
     1595, 1595, 1595, 1595, 1595, 1596, 1596, 1596, 1596, 1596,
     1596, 1596, 1596, 1596, 1596, 1596, 1597, 1597, 1597, 1597,
     1597, 1597, 1597, 1597, 1597, 1597, 1597, 1598, 1598, 1598,
     1598, 1598, 1598, 1598, 1598, 1598, 1598, 1598, 1599, 1599,
     1599, 1599, 1599, 1599, 1599, 1599, 1599, 1599, 1599, 1600,
     1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600, 1600,
     1601, 1601, 1601, 1601, 1601, 1601, 1601, 1601, 1601, 1601,
     1601, 1602, 1602, 1602, 1602, 1602, 1602, 1602, 1602, 1602,

     1602, 1602, 1603, 1603, 1603, 1603, 1603, 1603, 1603, 1603,
     1603, 1603, 1603, 1604, 1604, 1604, 1604, 1604, 1604, 1604,
     1604, 1604, 1604, 1604, 1605, 1605, 1605, 1605, 1605, 1605,
     1605, 1605, 1605, 1605, 1605, 1606, 1606, 1606, 1606, 1606,
     1606, 1606, 1606, 1606, 1606, 1606, 1607, 1607, 1607, 1607,
     1607, 1607, 1607, 1607, 1607, 1607, 1607, 1608, 1608, 1608,
     1608, 1608, 1608, 1608, 1608, 1608, 1608, 1608, 1609, 1609,
     1609, 1609, 1609, 1609, 1609, 1609, 1609, 1609, 1609, 1610,
     1610, 1610, 1610, 1610, 1610, 1610, 1610, 1610, 1610, 1610,
     1611, 1611, 1611, 1611, 1611, 1611, 1611, 1611, 1611, 1611,

     1611, 1612, 1612, 1612, 1612, 1612, 1612, 1612, 1612, 1612,
     1612, 1612, 1613, 1613, 1613, 1613, 1613, 1613, 1613, 1613,
     1613, 1613, 1613, 1614, 1614, 1614, 1614, 1614, 1614, 1614,
     1614, 1614, 1614, 1614, 1615, 1615, 1615, 1615, 1615, 1615,
     1615, 1615, 1615, 1615, 1615, 1616, 1616, 1616, 1616, 1616,
     1616, 1616, 1616, 1616, 1616, 1616, 1617, 1617, 1617, 1617,
     1617, 1617, 1617, 1617, 1617, 1617, 1617, 1618, 1618, 1618,
     1618, 1618, 1618, 1618, 1618, 1618, 1618, 1618, 1619, 1619,
     1619, 1619, 1619, 1619, 1619, 1619, 1619, 1619, 1619, 1620,
     1620, 1620, 1620, 1620, 1620, 1620, 1620, 1620, 1620, 1620,

     1621, 1621, 1621, 1621, 1621, 1621, 1621, 1621, 1621, 1621,
     1621, 1622, 1622, 1622, 1622, 1622, 1622, 1622, 1622, 1622,
     1622, 1622, 1623, 1623, 1623, 1623, 1623, 1623, 1623, 1623,
     1623, 1623, 1623, 1624, 1624, 1624, 1624, 1624, 1624, 1624,
     1624, 1624, 1624, 1624, 1625, 1625, 1625, 1625, 1625, 1625,
     1625, 1625, 1625, 1625, 1625, 1626, 1626, 1626, 1626, 1626,
     1626, 1626, 1626, 1626, 1626, 1626, 1627, 1627, 1627, 1627,
     1627, 1627, 1627, 1627, 1627, 1627, 1627, 1628, 1628, 1628,
     1628, 1628, 1628, 1628, 1628, 1628, 1628, 1628, 1629, 1629,
     1629, 1629, 1629, 1629, 1629, 1629, 1629, 1629, 1629, 1630,

     1630, 1630, 1630, 1630, 1630, 1630, 1630, 1630, 1630, 1630,
     1631, 1631, 1631, 1631, 1631, 1631, 1631, 1631, 1631, 1631,
     1631, 1632, 1632, 1632, 1632, 1632, 1632, 1632, 1632, 1632,
     1632, 1632, 1633, 1633, 1633, 1633, 1633, 1633, 1633, 1633,
     1633, 1633, 1633, 1634, 1634, 1634, 1634, 1634, 1634, 1634,
     1634, 1634, 1634, 1634, 1635, 1635, 1635, 1635, 1635, 1635,
     1635, 1635, 1635, 1635, 1635, 1636, 1636, 1636, 1636, 1636,
     1636, 1636, 1636, 1636, 1636, 1636, 1637, 1637, 1637, 1637,
     1637, 1637, 1637, 1637, 1637, 1637, 1637, 1638, 1638, 1638,
     1638, 1638, 1638, 1638, 1638, 1638, 1638, 1638, 1639, 1639,

     1639, 1639, 1639, 1639, 1639, 1639, 1639, 1639, 1639, 1640,
     1640, 1640, 1640, 1640, 1640, 1640, 1640, 1640, 1640, 1640,
     1641, 1641, 1641, 1641, 1641, 1641, 1641, 1641, 1641, 1641,
     1641, 1642, 1642, 1642, 1642, 1642, 1642, 1642, 1642, 1642,
     1642, 1642, 1643, 1643, 1643, 1643, 1643, 1643, 1643, 1643,
     1643, 1643, 1643, 1644, 1644, 1644, 1644, 1644, 1644, 1644,
     1644, 1644, 1644, 1644, 1645, 1645, 1645, 1645, 1645, 1645,
     1645, 1645, 1645, 1645, 1645, 1646, 1646, 1646, 1646, 1646,
     1646, 1646, 1646, 1646, 1646, 1646, 1647, 1647, 1647, 1647,
     1647, 1647, 1647, 1647, 1647, 1647, 1647, 1648, 1648, 1648,

     1648, 1648, 1648, 1648, 1648, 1648, 1648, 1648, 1649, 1649,
     1649, 1649, 1649, 1649, 1649, 1649, 1649, 1649, 1649, 1650,
     1650, 1650, 1650, 1650, 1650, 1650, 1650, 1650, 1650, 1650,
     1651, 1651, 1651, 1651, 1651, 1651, 1651, 1651, 1651, 1651,
     1651, 1652, 1652, 1652, 1652, 1652, 1652, 1652, 1652, 1652,
     1652, 1652, 1653, 1653, 1653, 1653, 1653, 1653, 1653, 1653,
     1653, 1653, 1653, 1654, 1654, 1654, 1654, 1654, 1654, 1654,
     1654, 1654, 1654, 1654, 1655, 1655, 1655, 1655, 1655, 1655,
     1655, 1655, 1655, 1655, 1655, 1656, 1656, 1656, 1656, 1656,
     1656, 1656, 1656, 1656, 1656, 1656, 1657, 1657, 1657, 1657,

     1657, 1657, 1657, 1657, 1657, 1657, 1657, 1658, 1658, 1658,
     1658, 1658, 1658, 1658, 1658, 1658, 1658, 1658, 1659, 1659,
     1659, 1659, 1659, 1659, 1659, 1659, 1659, 1659, 1659, 1660,
     1660, 1660, 1660, 1660, 1660, 1660, 1660, 1660, 1660, 1660,
     1661, 1661, 1661, 1661, 1661, 1661, 1661, 1661, 1661, 1661,
     1661, 1662, 1662, 1662, 1662, 1662, 1662, 1662, 1662, 1662,
     1662, 1662, 1663, 1663, 1663, 1663, 1663, 1663, 1663, 1663,
     1663, 1663, 1663, 1664, 1664, 1664, 1664, 1664, 1664, 1664,
     1664, 1664, 1664, 1664, 1665, 1665, 1665, 1665, 1665, 1665,
     1665, 1665, 1665, 1665, 1665, 1666, 1666, 1666, 1666, 1666,

     1666, 1666, 1666, 1666, 1666, 1666, 1667, 1667, 1667, 1667,
     1667, 1667, 1667, 1667, 1667, 1667, 1667, 1668, 1668, 1668,
     1668, 1668, 1668, 1668, 1668, 1668, 1668, 1668, 1669, 1669,
     1669, 1669, 1669, 1669, 1669, 1669, 1669, 1669, 1669, 1670,
     1670, 1670, 1670, 1670, 1670, 1670, 1670, 1670, 1670, 1670,
     1671, 1671, 1671, 1671, 1671, 1671, 1671, 1671, 1671, 1671,
     1671, 1672, 1672, 1672, 1672, 1672, 1672, 1672, 1672, 1672,
     1672, 1672, 1673, 1673, 1673, 1673, 1673, 1673, 1673, 1673,
     1673, 1673, 1673, 1674, 1674, 1674, 1674, 1674, 1674, 1674,
     1674, 1674, 1674, 1674, 1675, 1675, 1675, 1675, 1675, 1675,

     1675, 1675, 1675, 1675, 1675, 1676, 1676, 1676, 1676, 1676,
     1676, 1676, 1676, 1676, 1676, 1676, 1677, 1677, 1677, 1677,
     1677, 1677, 1677, 1677, 1677, 1677, 1677, 1678, 1678, 1678,
     1678, 1678, 1678, 1678, 1678, 1678, 1678, 1678, 1679, 1679,
     1679, 1679, 1679, 1679, 1679, 1679, 1679, 1679, 1679, 1680,
     1680, 1680, 1680, 1680, 1680, 1680, 1680, 1680, 1680, 1680,
     1681, 1681, 1681, 1681, 1681, 1681, 1681, 1681, 1681, 1681,
     1681, 1682, 1682, 1682, 1682, 1682, 1682, 1682, 1682, 1682,
     1682, 1682, 1683, 1683, 1683, 1683, 1683, 1683, 1683, 1683,
     1683, 1683, 1683, 1684, 1684, 1684, 1684, 1684, 1684, 1684,

     1684, 1684, 1684, 1684, 1685, 1685, 1685, 1685, 1685, 1685,
     1685, 1685, 1685, 1685, 1685, 1686, 1686, 1686, 1686, 1686,
     1686, 1686, 1686, 1686, 1686, 1686, 1687, 1687, 1687, 1687,
     1687, 1687, 1687, 1687, 1687, 1687, 1687, 1688, 1688, 1688,
     1688, 1688, 1688, 1688, 1688, 1688, 1688, 1688, 1689, 1689,
     1689, 1689, 1689, 1689, 1689, 1689, 1689, 1689, 1689, 1690,
     1690, 1690, 1690, 1690, 1690, 1690, 1690, 1690, 1690, 1690,
     1691, 1691, 1691, 1691, 1691, 1691, 1691, 1691, 1691, 1691,
     1691, 1692, 1692, 1692, 1692, 1692, 1692, 1692, 1692, 1692,
     1692, 1692, 1693, 1693, 1693, 1693, 1693, 1693, 1693, 1693,

     1693, 1693, 1693, 1694, 1694, 1694, 1694, 1694, 1694, 1694,
     1694, 1694, 1694, 1694, 1695, 1695, 1695, 1695, 1695, 1695,
     1695, 1695, 1695, 1695, 1695, 1696, 1696, 1696, 1696, 1696,
     1696, 1696, 1696, 1696, 1696, 1696, 1697, 1697, 1697, 1697,
     1697, 1697, 1697, 1697, 1697, 1697, 1697, 1698, 1698, 1698,
     1698, 1698, 1698, 1698, 1698, 1698, 1698, 1698, 1699, 1699,
     1699, 1699, 1699, 1699, 1699, 1699, 1699, 1699, 1699, 1700,
     1700, 1700, 1700, 1700, 1700, 1700, 1700, 1700, 1700, 1700,
     1701, 1701, 1701, 1701, 1701, 1701, 1701, 1701, 1701, 1701,
     1701, 1702, 1702, 1702, 1702, 1702, 1702, 1702, 1702, 1702,

     1702, 1702, 1703, 1703, 1703, 1703, 1703, 1703, 1703, 1703,
     1703, 1703, 1703, 1704, 1704, 1704, 1704, 1704, 1704, 1704,
     1704, 1704, 1704, 1704, 1705, 1705, 1705, 1705, 1705, 1705,
     1705, 1705, 1705, 1705, 1705, 1706, 1706, 1706, 1706, 1706,
     1706, 1706, 1706, 1706, 1706, 1706, 1707, 1707, 1707, 1707,
     1707, 1707, 1707, 1707, 1707, 1707, 1707, 1708, 1708, 1708,
     1708, 1708, 1708, 1708, 1708, 1708, 1708, 1708, 1709, 1709,
     1709, 1709, 1709, 1709, 1709, 1709, 1709, 1709, 1709, 1710,
     1710, 1710, 1710, 1710, 1710, 1710, 1710, 1710, 1710, 1710,
     1711, 1711, 1711, 1711, 1711, 1711, 1711, 1711, 1711, 1711,

     1711, 1712, 1712, 1712, 1712, 1712, 1712, 1712, 1712, 1712,
     1712, 1712, 1713, 1713, 1713, 1713, 1713, 1713, 1713, 1713,
     1713, 1713, 1713, 1714, 1714, 1714, 1714, 1714, 1714, 1714,
     1714, 1714, 1714, 1714, 1715, 1715, 1715, 1715, 1715, 1715,
     1715, 1715, 1715, 1715, 1715, 1716, 1716, 1716, 1716, 1716,
     1716, 1716, 1716, 1716, 1716, 1716, 1717, 1717, 1717, 1717,
     1717, 1717, 1717, 1717, 1717, 1717, 1717, 1718, 1718, 1718,
     1718, 1718, 1718, 1718, 1718, 1718, 1718, 1718, 1719, 1719,
     1719, 1719, 1719, 1719, 1719, 1719, 1719, 1719, 1719, 1720,
     1720, 1720, 1720, 1720, 1720, 1720, 1720, 1720, 1720, 1720,

     1721, 1721, 1721, 1721, 1721, 1721, 1721, 1721, 1721, 1721,
     1721, 1722, 1722, 1722, 1722, 1722, 1722, 1722, 1722, 1722,
     1722, 1722, 1723, 1723, 1723, 1723, 1723, 1723, 1723, 1723,
     1723, 1723, 1723, 1724, 1724, 1724, 1724, 1724, 1724, 1724,
     1724, 1724, 1724, 1724, 1725, 1725, 1725, 1725, 1725, 1725,
     1725, 1725, 1725, 1725, 1725, 1726, 1726, 1726, 1726, 1726,
     1726, 1726, 1726, 1726, 1726, 1726, 1727, 1727, 1727, 1727,
     1727, 1727, 1727, 1727, 1727, 1727, 1727, 1728, 1728, 1728,
     1728, 1728, 1728, 1728, 1728, 1728, 1728, 1728, 1729, 1729,
     1729, 1729, 1729, 1729, 1729, 1729, 1729, 1729, 1729, 1730,

     1730, 1730, 1730, 1730, 1730, 1730, 1730, 1730, 1730, 1730,
     1731, 1731, 1731, 1731, 1731, 1731, 1731, 1731, 1731, 1731,
     1731, 1732, 1732, 1732, 1732, 1732, 1732, 1732, 1732, 1732,
     1732, 1732, 1733, 1733, 1733, 1733, 1733, 1733, 1733, 1733,
     1733, 1733, 1733, 1734, 1734, 1734, 1734, 1734, 1734, 1734,
     1734, 1734, 1734, 1734, 1735, 1735, 1735, 1735, 1735, 1735,
     1735, 1735, 1735, 1735, 1735, 1736, 1736, 1736, 1736, 1736,
     1736, 1736, 1736, 1736, 1736, 1736, 1737, 1737, 1737, 1737,
     1737, 1737, 1737, 1737, 1737, 1737, 1737, 1738, 1738, 1738,
     1738, 1738, 1738, 1738, 1738, 1738, 1738, 1738, 1739, 1739,

     1739, 1739, 1739, 1739, 1739, 1739, 1739, 1739, 1739, 1740,
     1740, 1740, 1740, 1740, 1740, 1740, 1740, 1740, 1740, 1740,
     1741, 1741, 1741, 1741, 1741, 1741, 1741, 1741, 1741, 1741,
     1741, 1742, 1742, 1742, 1742, 1742, 1742, 1742, 1742, 1742,
     1742, 1742, 1743, 1743, 1743, 1743, 1743, 1743, 1743, 1743,
     1743, 1743, 1743, 1744, 1744, 1744, 1744, 1744, 1744, 1744,
     1744, 1744, 1744, 1744, 1745, 1745, 1745, 1745, 1745, 1745,
     1745, 1745, 1745, 1745, 1745, 1746, 1746, 1746, 1746, 1746,
     1746, 1746, 1746, 1746, 1746, 1746, 1747, 1747, 1747, 1747,
     1747, 1747, 1747, 1747, 1747, 1747, 1747, 1748, 1748, 1748,

     1748, 1748, 1748, 1748, 1748, 1748, 1748, 1748, 1749, 1749,
     1749, 1749, 1749, 1749, 1749, 1749, 1749, 1749, 1749, 1750,
     1750, 1750, 1750, 1750, 1750, 1750, 1750, 1750, 1750, 1750,
     1751, 1751, 1751, 1751, 1751, 1751, 1751, 1751, 1751, 1751,
     1751, 1752, 1752, 1752, 1752, 1752, 1752, 1752, 1752, 1752,
     1752, 1752, 1753, 1753, 1753, 1753, 1753, 1753, 1753, 1753,
     1753, 1753, 1753, 1754, 1754, 1754, 1754, 1754, 1754, 1754,
     1754, 1754, 1754, 1754, 1755, 1755, 1755, 1755, 1755, 1755,
     1755, 1755, 1755, 1755, 1755, 1756, 1756, 1756, 1756, 1756,
     1756, 1756, 1756, 1756, 1756, 1756, 1757, 1757, 1757, 1757,

     1757, 1757, 1757, 1757, 1757, 1757, 1757, 1758, 1758, 1758,
     1758, 1758, 1758, 1758, 1758, 1758, 1758, 1758, 1759, 1759,
     1759, 1759, 1759, 1759, 1759, 1759, 1759, 1759, 1759, 1760,
     1760, 1760, 1760, 1760, 1760, 1760, 1760, 1760, 1760, 1760,
     1761, 1761, 1761, 1761, 1761, 1761, 1761, 1761, 1761, 1761,
     1761, 1762, 1762, 1762, 1762, 1762, 1762, 1762, 1762, 1762,
     1762, 1762, 1763, 1763, 1763, 1763, 1763, 1763, 1763, 1763,
     1763, 1763, 1763, 1764, 1764, 1764, 1764, 1764, 1764, 1764,
     1764, 1764, 1764, 1764, 1765, 1765, 1765, 1765, 1765, 1765,
     1765, 1765, 1765, 1765, 1765, 1766, 1766, 1766, 1766, 1766,

     1766, 1766, 1766, 1766, 1766, 1766, 1767, 1767, 1767, 1767,
     1767, 1767, 1767, 1767, 1767, 1767, 1767, 1768, 1768, 1768,
     1768, 1768, 1768, 1768, 1768, 1768, 1768, 1768, 1769, 1769,
     1769, 1769, 1769, 1769, 1769, 1769, 1769, 1769, 1769, 1770,
     1770, 1770, 1770, 1770, 1770, 1770, 1770, 1770, 1770, 1770,
     1771, 1771, 1771, 1771, 1771, 1771, 1771, 1771, 1771, 1771,
     1771, 1772, 1772, 1772, 1772, 1772, 1772, 1772, 1772, 1772,
     1772, 1772, 1773, 1773, 1773, 1773, 1773, 1773, 1773, 1773,
     1773, 1773, 1773, 1774, 1774, 1774, 1774, 1774, 1774, 1774,
     1774, 1774, 1774, 1774, 1775, 1775, 1775, 1775, 1775, 1775,

     1775, 1775, 1775, 1775, 1775, 1776, 1776, 1776, 1776, 1776,
     1776, 1776, 1776, 1776, 1776, 1776, 1777, 1777, 1777, 1777,
     1777, 1777, 1777, 1777, 1777, 1777, 1777, 1778, 1778, 1778,
     1778, 1778, 1778, 1778, 1778, 1778, 1778, 1778, 1779, 1779,
     1779, 1779, 1779, 1779, 1779, 1779, 1779, 1779, 1779, 1780,
     1780, 1780, 1780, 1780, 1780, 1780, 1780, 1780, 1780, 1780,
     1781, 1781, 1781, 1781, 1781, 1781, 1781, 1781, 1781, 1781,
     1781, 1782, 1782, 1782, 1782, 1782, 1782, 1782, 1782, 1782,
     1782, 1782, 1783, 1783, 1783, 1783, 1783, 1783, 1783, 1783,
     1783, 1783, 1783, 1784, 1784, 1784, 1784, 1784, 1784, 1784,

     1784, 1784, 1784, 1784, 1785, 1785, 1785, 1785, 1785, 1785,
     1785, 1785, 1785, 1785, 1785, 1786, 1786, 1786, 1786, 1786,
     1786, 1786, 1786, 1786, 1786, 1786,  368,  367,  366,  365,
      364,  362,  361,  360,  359,  358,  357,  354,  353,  352,
      351,  350,  349,  348,  346,  345,  344,  343,  342,  341,
      339,  338,  337,  336,  335,  334,  332,  331,  330,  329,
      328,  327,  325,  324,  323,  322,  321,  320,  318,  312,
      309,  308,  307,  306,  305,  304,  303,  301,  300,  299,
      298,  297,  296,  295,  294,  293,  291,  290,  289,  287,
      286,  284,  283,  282,  281,  280,  278,  276,  275,  270,

      269,  264,  263,  262,  261,  260,  259,  258,  257,  256,
      255,  251,  250,  247,  237,  230,  226,  223,  222,  220,
      208,  203,  202,  201,  200,  199,  198,  197,  195,  193,
      192,  191,  190,  189,  187,  186,  185,  183,  182,  181,
      180,  179,  177,  175,  174,  173,  172,  171,  169,  168,
      163,  160,  156,  139,  138,  137,  136,  135,  134,  133,
      132,  131,  129,  118,  116,  114,  113,  111,  110,  108,
      107,  104,   97,   86,   83,   82,   81,   80,   68,   67,
       66,   63,   62,   60,   59,   56,   51,   48,   47,   46,
       42,   35,   26,   22,   21,   18,   17,    2,    1, 1366,

     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366, 1366,
     1366, 1366
    } ;

static yy_state_type yy_last_accepting_state;
static char *yy_last_accepting_cpos;

/* The intent behind this definition is that it'll catch
 * any uses of REJECT which flex missed.
 */
#define REJECT reject_used_but_not_detected
static int yy_more_flag = 0;
static int yy_more_len = 0;
#define yymore() (yy_more_flag = 1)
#define YY_MORE_ADJ yy_more_len
#define YY_RESTORE_YY_MORE_OFFSET
char *yytext;
#define INITIAL 0

/*
   +----------------------------------------------------------------------+
   | Zend Engine                                                          |
   +----------------------------------------------------------------------+
   | Copyright (c) 1998-2002 Zend Technologies Ltd. (http://www.zend.com) |
   +----------------------------------------------------------------------+
   | This source file is subject to version 2.00 of the Zend license,     |
   | that is bundled with this package in the file LICENSE, and is        | 
   | available at through the world-wide-web at                           |
   | http://www.zend.com/license/2_00.txt.                                |
   | If you did not receive a copy of the Zend license and are unable to  |
   | obtain it through the world-wide-web, please send a note to          |
   | license@zend.com so we can mail you a copy immediately.              |
   +----------------------------------------------------------------------+
   | Authors: Andi Gutmans <andi@zend.com>                                |
   |          Zeev Suraski <zeev@zend.com>                                |
   +----------------------------------------------------------------------+
*/

#define yyleng SCNG(yy_leng)
#define yytext SCNG(yy_text)
#define yytext_ptr SCNG(yy_text)
#define yyin SCNG(yy_in)
#define yyout SCNG(yy_out)
#define yy_last_accepting_state SCNG(_yy_last_accepting_state)
#define yy_last_accepting_cpos SCNG(_yy_last_accepting_cpos)
#define yy_more_flag SCNG(_yy_more_flag)
#define yy_more_len SCNG(_yy_more_len)

#define ST_IN_SCRIPTING 1

#define ST_DOUBLE_QUOTES 2

#define ST_SINGLE_QUOTE 3

#define ST_BACKQUOTE 4

#define ST_HEREDOC 5

#define ST_LOOKING_FOR_PROPERTY 6

#define ST_LOOKING_FOR_VARNAME 7

#define ST_COMMENT 8

#define ST_ONE_LINE_COMMENT 9

#define YY_STACK_USED 1

#ifdef ZEND_WIN32
#include <io.h>
#endif

#include <errno.h>
#include "zend.h"
#include "zend_alloc.h"
#include "zend_language_parser.h"
#include "zend_compile.h"
#include "zend_language_scanner.h"
#include "zend_highlight.h"
#include "zend_constants.h"
#include "zend_variables.h"
#include "zend_operators.h"

#ifdef HAVE_STDARG_H
# include <stdarg.h>
#endif

#ifdef HAVE_UNISTD_H
# include <unistd.h>
#endif

#define YY_DECL int lex_scan(zval *zendlval TSRMLS_DC)

#define ECHO { ZEND_WRITE( yytext, yyleng ); }

#ifdef ZTS
#  define MY_INPUT yyinput
#else
#  define MY_INPUT input
#endif


/* Globals Macros */
#define SCNG	LANG_SCNG
#ifdef ZTS
ZEND_API ts_rsrc_id language_scanner_globals_id;
#else
ZEND_API zend_scanner_globals language_scanner_globals;
#endif


#define YY_FATAL_ERROR zend_fatal_scanner_error

#define HANDLE_NEWLINES(s, l)													\
do {																			\
	char *p = (s), *boundary = p+(l);											\
																				\
	while (p<boundary) {														\
		if (*p == '\n') {														\
			CG(zend_lineno)++;													\
		} else if ((*p == '\r') && (p+1 < boundary) && (*(p+1) != '\n')) {		\
			CG(zend_lineno)++;													\
		}																		\
		p++;																	\
	}																			\
} while (0)

#define HANDLE_NEWLINE(c) \
{ \
	if (c == '\n' || c == '\r') { \
		CG(zend_lineno)++; \
	} \
}
		

#define ZEND_IS_OCT(c)  ((c)>='0' && (c)<='7')
#define ZEND_IS_HEX(c)  (((c)>='0' && (c)<='9') || ((c)>='a' && (c)<='f') || ((c)>='A' && (c)<='F'))


void zend_fatal_scanner_error(char *message)
{
	zend_error(E_COMPILE_ERROR, message);
}

BEGIN_EXTERN_C()
void startup_scanner(TSRMLS_D)
{
	CG(heredoc) = NULL;
	CG(heredoc_len)=0;
	SCNG(yy_start_stack_ptr) = 0;
	SCNG(yy_start_stack_depth) = 0;
}


void shutdown_scanner(TSRMLS_D)
{
	if (CG(heredoc)) {
		efree(CG(heredoc));
		CG(heredoc_len)=0;
	}
}
END_EXTERN_C()


ZEND_API void zend_save_lexical_state(zend_lex_state *lex_state TSRMLS_DC)
{
	memcpy(&lex_state->buffer_state, &YY_CURRENT_BUFFER, sizeof(YY_BUFFER_STATE));
	lex_state->in = SCNG(yy_in);
	lex_state->state = YYSTATE;
	lex_state->filename = zend_get_compiled_filename(TSRMLS_C);
	lex_state->lineno = CG(zend_lineno);
#ifdef ZEND_MULTIBYTE
	lex_state->code = SCNG(code);
	lex_state->code_size = SCNG(code_size);
	lex_state->current_code = SCNG(current_code);
	lex_state->current_code_size = SCNG(current_code_size);
	lex_state->input_filter = SCNG(input_filter);
	lex_state->output_filter = SCNG(output_filter);
	lex_state->script_encoding = SCNG(script_encoding);
	lex_state->internal_encoding = SCNG(internal_encoding);
#endif /* ZEND_MULTIBYTE */
}


ZEND_API void zend_restore_lexical_state(zend_lex_state *lex_state TSRMLS_DC)
{
	YY_BUFFER_STATE original_buffer_state = YY_CURRENT_BUFFER;

	if (lex_state->buffer_state) {
		yy_switch_to_buffer(lex_state->buffer_state TSRMLS_CC);
	} else {
		YY_CURRENT_BUFFER = NULL;
	}
		
	yy_delete_buffer(original_buffer_state TSRMLS_CC);
	SCNG(yy_in) = lex_state->in;
	BEGIN(lex_state->state);
	CG(zend_lineno) = lex_state->lineno;
	zend_restore_compiled_filename(lex_state->filename TSRMLS_CC);
#ifdef ZEND_MULTIBYTE
	SCNG(code) = lex_state->code;
	SCNG(code_size) = lex_state->code_size;
	SCNG(current_code) = lex_state->current_code;
	SCNG(current_code_size) = lex_state->current_code_size;
	SCNG(input_filter) = lex_state->input_filter;
	SCNG(output_filter) = lex_state->output_filter;
	SCNG(script_encoding) = lex_state->script_encoding;
	SCNG(internal_encoding) = lex_state->internal_encoding;
#endif /* ZEND_MULTIBYTE */
}


BEGIN_EXTERN_C()


ZEND_API void zend_file_handle_dtor(zend_file_handle *fh)
{
	switch (fh->type) {
		case ZEND_HANDLE_FP:
			fclose(fh->handle.fp);
			break;
		case ZEND_HANDLE_FILENAME:
			/* We're only supposed to get here when destructing the used_files hash,
			 * which doesn't really contain open files, but references to their names/paths
			 */
			break;
	}
	if (fh->opened_path) {
		efree(fh->opened_path);
	}
	if (fh->free_filename && fh->filename) {
		efree(fh->filename);
	}
}


int zend_compare_file_handles(zend_file_handle *fh1, zend_file_handle *fh2)
{
	if (fh1->type != fh2->type) {
		return 0;
	}
	switch (fh1->type) {
		case ZEND_HANDLE_FP:
			return fh1->handle.fp==fh2->handle.fp;
			break;
	}
	return 0;
}


ZEND_API void zend_destroy_file_handle(zend_file_handle *file_handle TSRMLS_DC)
{
	zend_llist_del_element(&CG(open_files), file_handle, (int (*)(void *, void *)) zend_compare_file_handles);
}


ZEND_API int open_file_for_scanning(zend_file_handle *file_handle TSRMLS_DC)
{
	char *file_path=NULL;

	switch (file_handle->type) {
		case ZEND_HANDLE_FILENAME:
			file_handle->handle.fp = zend_fopen(file_handle->filename, &file_handle->opened_path);
			break;
		case ZEND_HANDLE_FD:
			file_handle->handle.fp = fdopen(file_handle->handle.fd, "r");
			break;
		case ZEND_HANDLE_FP:
			file_handle->handle.fp = file_handle->handle.fp;
			break;
	}
	if (!file_handle->handle.fp) {
		return FAILURE;
	}

	file_handle->type = ZEND_HANDLE_FP;	
	if (file_handle->handle.fp != stdin) {
		zend_llist_add_element(&CG(open_files), file_handle);
	}
	/* Reset the scanner for scanning the new file */
	SCNG(yy_in) = file_handle->handle.fp;
#ifdef ZEND_MULTIBYTE
	if (zend_read_file(TSRMLS_C) != 0) {
		return FAILURE;
	}
	
	/* force flex to use buffer only */
	SCNG(yy_in) = NULL;
	SCNG(init) = 0;
	SCNG(start) = 1;

	zend_multibyte_set_filter(NULL TSRMLS_CC);

	if (!SCNG(input_filter)) {
		SCNG(current_code) = (char*)emalloc(SCNG(code_size)+1);
		if (!SCNG(current_code)) {
			return FAILURE;
		}
		memcpy(SCNG(current_code), SCNG(code), SCNG(code_size)+1);
		SCNG(current_code_size) = SCNG(code_size);
	} else {
		SCNG(input_filter)(&SCNG(current_code), &SCNG(current_code_size), SCNG(code), SCNG(code_size) TSRMLS_CC);
		if (!SCNG(current_code) || !SCNG(current_code_size)) {
			return FAILURE;
		}
	}
	
	/* we need two nulls so that ralloc... */
	SCNG(current_code) = (char*)erealloc(SCNG(current_code), SCNG(current_code_size)+2);
	if (!SCNG(current_code)) {
		return FAILURE;
	}
	*(SCNG(current_code)+SCNG(current_code_size)) = (char)NULL;
	*(SCNG(current_code)+SCNG(current_code_size)+1) = (char)NULL;
	yy_scan_buffer(SCNG(current_code), SCNG(current_code_size)+2 TSRMLS_CC);
#else /* ZEND_MULTIBYTE */
	yy_switch_to_buffer(yy_create_buffer(SCNG(yy_in), YY_BUF_SIZE TSRMLS_CC) TSRMLS_CC);
#endif /* ZEND_MULTIBYTE */
	BEGIN(INITIAL);

	if (file_handle->opened_path) {
		file_path = file_handle->opened_path; 
	} else {
		file_path = file_handle->filename;
	}

	zend_set_compiled_filename(file_path TSRMLS_CC);
	
	if (CG(zend_lineno) < 0) { /* position is (n_lines * -1), position was changed by an external app */
		CG(zend_lineno) = CG(zend_lineno) * -1;
	} else {
		CG(zend_lineno) = 1;
	}
	
	CG(increment_lineno) = 0;
	return SUCCESS;
}
END_EXTERN_C()


ZEND_API zend_op_array *compile_file(zend_file_handle *file_handle, int type TSRMLS_DC)
{
	zend_lex_state original_lex_state;
	zend_op_array *op_array = (zend_op_array *) emalloc(sizeof(zend_op_array));
	zend_op_array *original_active_op_array = CG(active_op_array);
	zend_op_array *retval=NULL;
	int compiler_result;
	zend_bool compilation_successful=0;
	znode retval_znode;
	zend_bool original_in_compilation = CG(in_compilation);

	retval_znode.op_type = IS_CONST;
	retval_znode.u.constant.type = IS_LONG;
	retval_znode.u.constant.value.lval = 1;
	retval_znode.u.constant.is_ref = 0;
	retval_znode.u.constant.refcount = 1;

	zend_save_lexical_state(&original_lex_state TSRMLS_CC);

	retval = op_array; /* success oriented */

	if (open_file_for_scanning(file_handle TSRMLS_CC)==FAILURE) {
		if (type==ZEND_REQUIRE) {
			zend_message_dispatcher(ZMSG_FAILED_REQUIRE_FOPEN, file_handle->filename);
			zend_bailout();		
		} else {
			zend_message_dispatcher(ZMSG_FAILED_INCLUDE_FOPEN, file_handle->filename);
		}
		compilation_successful=0;
	} else {
		init_op_array(op_array, ZEND_USER_FUNCTION, INITIAL_OP_ARRAY_SIZE TSRMLS_CC);
		CG(in_compilation) = 1;
		CG(active_op_array) = op_array;
		compiler_result = zendparse(TSRMLS_C);
		zend_do_return(&retval_znode, 0 TSRMLS_CC);
		CG(in_compilation) = original_in_compilation;
		if (compiler_result==1) { /* parser error */
			CG(unclean_shutdown) = 1;
			retval = NULL;
		}
		compilation_successful=1;
#ifdef ZEND_MULTIBYTE
		if (SCNG(code)) {
			efree(SCNG(code));
		}
		if (SCNG(current_code)) {
			efree(SCNG(current_code));
		}
#endif /* ZEND_MULTIBYTE */
	}

	if (retval) {
		CG(active_op_array) = original_active_op_array;
		if (compilation_successful) {
			pass_two(op_array TSRMLS_CC);
		} else {
			efree(op_array);
			retval = NULL;
		}
	}
	if (compilation_successful) {
		zend_restore_lexical_state(&original_lex_state TSRMLS_CC);
	}
	return retval;
}


zend_op_array *compile_filename(int type, zval *filename TSRMLS_DC)
{
	zend_file_handle file_handle;
	zval tmp;
	zend_op_array *retval;
	char *opened_path = NULL;

	if (filename->type != IS_STRING) {
		tmp = *filename;
		zval_copy_ctor(&tmp);
		convert_to_string(&tmp);
		filename = &tmp;
	}
	file_handle.filename = filename->value.str.val;
	file_handle.free_filename = 0;
	file_handle.type = ZEND_HANDLE_FILENAME;
	file_handle.opened_path = NULL;


	retval = zend_compile_file(&file_handle, type TSRMLS_CC);
	if (retval && file_handle.handle.fp) {
		int dummy = 1;
	
		if (!file_handle.opened_path) {
			file_handle.opened_path = opened_path = estrndup(filename->value.str.val, filename->value.str.len);
		}
		
		zend_hash_add(&EG(included_files), file_handle.opened_path, strlen(file_handle.opened_path)+1, (void *)&dummy, sizeof(int), NULL);
		
		if (opened_path) {
			efree(opened_path);
		}
	}
	zend_destroy_file_handle(&file_handle TSRMLS_CC);

	if (filename==&tmp) {
		zval_dtor(&tmp);
	}
	return retval;
}

ZEND_API int zend_prepare_string_for_scanning(zval *str, char *filename TSRMLS_DC)
{
	/* enforce two trailing NULLs for flex... */
	STR_REALLOC(str->value.str.val, str->value.str.len+2);

	str->value.str.val[str->value.str.len+1]=0;

	SCNG(yy_in)=NULL;
#ifdef ZEND_MULTIBYTE
	/* instead of zend_readfile() */
	SCNG(code) = estrdup(str->value.str.val);
	if (!SCNG(code)) {
		return FAILURE;
	}
	SCNG(code_size) = str->value.str.len;

	zend_multibyte_set_filter(CG(internal_encoding) TSRMLS_CC);

	if (!SCNG(input_filter)) {
		SCNG(current_code) = (char*)emalloc(SCNG(code_size)+1);
		if (!SCNG(current_code)) {
			return FAILURE;
		}
		memcpy(SCNG(current_code), SCNG(code), SCNG(code_size)+1);
		SCNG(current_code_size) = SCNG(code_size);
	} else {
		SCNG(input_filter)(&SCNG(current_code), &SCNG(current_code_size), SCNG(code), SCNG(code_size) TSRMLS_CC);
		if (!SCNG(current_code) || !SCNG(current_code_size)) {
			return FAILURE;
		}
	}

	SCNG(current_code) = (char*)erealloc(SCNG(current_code), SCNG(current_code_size)+2);
	if (!SCNG(current_code)) {
		return FAILURE;
	}
	*(SCNG(current_code)+SCNG(current_code_size)) = (char)NULL;
	*(SCNG(current_code)+SCNG(current_code_size)+1) = (char)NULL;
	yy_scan_buffer(SCNG(current_code), SCNG(current_code_size)+2 TSRMLS_CC);
#else /* ZEND_MULTIBYTE */
	yy_scan_buffer(str->value.str.val, str->value.str.len+2 TSRMLS_CC);
#endif /* ZEND_MULTIBYTE */

	zend_set_compiled_filename(filename TSRMLS_CC);
	CG(zend_lineno) = 1;
	CG(increment_lineno) = 0;
	return SUCCESS;
}


zend_op_array *compile_string(zval *source_string, char *filename TSRMLS_DC)
{
	zend_lex_state original_lex_state;
	zend_op_array *op_array = (zend_op_array *) emalloc(sizeof(zend_op_array));
	zend_op_array *original_active_op_array = CG(active_op_array);
	zend_op_array *retval;
	zval tmp;
	int compiler_result;
	zend_bool original_in_compilation = CG(in_compilation);

	if (source_string->value.str.len==0) {
		efree(op_array);
		return NULL;
	}

	CG(in_compilation) = 1;

	tmp = *source_string;
	zval_copy_ctor(&tmp);
	convert_to_string(&tmp);
	source_string = &tmp;

	zend_save_lexical_state(&original_lex_state TSRMLS_CC);
	if (zend_prepare_string_for_scanning(source_string, filename TSRMLS_CC)==FAILURE) {
		efree(op_array);
		retval = NULL;
	} else {
		init_op_array(op_array, ZEND_EVAL_CODE, INITIAL_OP_ARRAY_SIZE TSRMLS_CC);
		CG(active_op_array) = op_array;
		BEGIN(ST_IN_SCRIPTING);
		compiler_result = zendparse(TSRMLS_C);
#ifdef ZEND_MULTIBYTE
		if (SCNG(code)) {
			efree(SCNG(code));
		}
		if (SCNG(current_code)) {
			efree(SCNG(current_code));
		}
#endif /* ZEND_MULTIBYTE */
		
		if (compiler_result==1) {
			CG(active_op_array) = original_active_op_array;
			CG(unclean_shutdown)=1;
			retval = NULL;
		} else {
			zend_do_return(NULL, 0 TSRMLS_CC);
			CG(active_op_array) = original_active_op_array;
			pass_two(op_array TSRMLS_CC);
			retval = op_array;
		}
		zend_restore_lexical_state(&original_lex_state TSRMLS_CC);
	}
	zval_dtor(&tmp);
	CG(in_compilation) = original_in_compilation;
	return retval;
}


BEGIN_EXTERN_C()
int highlight_file(char *filename, zend_syntax_highlighter_ini *syntax_highlighter_ini TSRMLS_DC)
{
	zend_lex_state original_lex_state;
	zend_file_handle file_handle;

	file_handle.type = ZEND_HANDLE_FILENAME;
	file_handle.filename = filename;
	file_handle.free_filename = 0;
	file_handle.opened_path = NULL;
	zend_save_lexical_state(&original_lex_state TSRMLS_CC);
	if (open_file_for_scanning(&file_handle TSRMLS_CC)==FAILURE) {
		zend_message_dispatcher(ZMSG_FAILED_HIGHLIGHT_FOPEN, filename);
		return FAILURE;
	}
	zend_highlight(syntax_highlighter_ini TSRMLS_CC);
#ifdef ZEND_MULTIBYTE
	if (SCNG(code)) {
		efree(SCNG(code));
	}
	if (SCNG(current_code)) {
		efree(SCNG(current_code));
	}
#endif /* ZEND_MULTIBYTE */
	zend_destroy_file_handle(&file_handle TSRMLS_CC);
	zend_restore_lexical_state(&original_lex_state TSRMLS_CC);
	return SUCCESS;
}

int highlight_string(zval *str, zend_syntax_highlighter_ini *syntax_highlighter_ini, char *str_name TSRMLS_DC)
{
	zend_lex_state original_lex_state;
	zval tmp = *str;

	str = &tmp;
	zval_copy_ctor(str);
	zend_save_lexical_state(&original_lex_state TSRMLS_CC);
	if (zend_prepare_string_for_scanning(str, str_name TSRMLS_CC)==FAILURE) {
		return FAILURE;
	}
	zend_highlight(syntax_highlighter_ini TSRMLS_CC);
#ifdef ZEND_MULTIBYTE
	if (SCNG(code)) {
		efree(SCNG(code));
	}
	if (SCNG(current_code)) {
		efree(SCNG(current_code));
	}
#endif /* ZEND_MULTIBYTE */
	zend_restore_lexical_state(&original_lex_state TSRMLS_CC);
	zval_dtor(str);
	return SUCCESS;
}
END_EXTERN_C()

#ifdef ZEND_MULTIBYTE
BEGIN_EXTERN_C()
ZEND_API void zend_yyinput_again(zend_multibyte_filter old_input_filter, zend_encoding *old_encoding TSRMLS_DC)
{
	YY_BUFFER_STATE b = YY_CURRENT_BUFFER;
	int offset, original_offset, length, free_flag;
	char *p;
	zend_encoding *new_encoding;

	/* calculate current position */
	offset = original_offset = yy_c_buf_p - b->yy_ch_buf;
	if (old_input_filter && original_offset > 0) {
		/* we need to adjust offset ? (i've gotta improve this...) */
		new_encoding = SCNG(script_encoding);
		SCNG(script_encoding) = old_encoding;
		do {
			(old_input_filter)(&p, &length, SCNG(code), offset TSRMLS_CC);
			if (!p) {
				SCNG(script_encoding) = new_encoding;
				return;
			}
			efree(p);
			if (length > original_offset) {
				offset--;
			} else if (length < original_offset) {
				offset++;
			}
		} while (original_offset != length);
		SCNG(script_encoding) = new_encoding;
	}

	/* convert and set */
	if (!SCNG(input_filter)) {
		length = SCNG(code_size)-offset-1;
		p = SCNG(code)+offset+1;
		free_flag = 0;
	} else {
		SCNG(input_filter)(&p, &length, SCNG(code)+offset+1, SCNG(code_size)-offset-1 TSRMLS_CC);
		free_flag = 1;
	}
	if (original_offset+length+1 > (int)b->yy_buf_size) {
		b->yy_buf_size = original_offset+length+1;
		b->yy_ch_buf = (char*)erealloc(b->yy_ch_buf, b->yy_buf_size+2);
		SCNG(current_code) = b->yy_ch_buf;
		SCNG(current_code_size) = b->yy_buf_size;
	}
	yy_c_buf_p = b->yy_ch_buf + original_offset;
	strncpy(yy_c_buf_p+1, p, length);
 	b->yy_n_chars = original_offset + length + 1;
	SCNG(yy_n_chars) = b->yy_n_chars;
	b->yy_ch_buf[SCNG(yy_n_chars)] = YY_END_OF_BUFFER_CHAR;
	b->yy_ch_buf[SCNG(yy_n_chars)+1] = YY_END_OF_BUFFER_CHAR;

	if (free_flag) {
		efree(p);
	}
}


ZEND_API int zend_read_file(TSRMLS_D)
{
	char buf[8192];
	int n;

	SCNG(code) = NULL;
	SCNG(code_size) = 0;

	do {
		n = fread(buf, 1, 8192, SCNG(yy_in));
		if (n) {
			SCNG(code_size) += n;
			if (SCNG(code)) {
				SCNG(code) = (char*)erealloc(SCNG(code), SCNG(code_size)+1);
				if (!SCNG(code)) {
					return -1;
				}
			} else {
				SCNG(code) = (char*)emalloc(SCNG(code_size)+1);
				if (!SCNG(code)) {
					return -1;
				}
			}
			memcpy(SCNG(code)+SCNG(code_size)-n, buf, n);
		}
	} while(n);
	if (ferror(SCNG(yy_in))) {
		return -1;
	}
	if (!SCNG(code)) {
		SCNG(code) = emalloc(SCNG(code_size)+1);
	}
	*(SCNG(code)+SCNG(code_size)) = (char)NULL;

	return 0;
}


/*
 *	macros for yytext -> zval
 */
# define zend_copy_value(zendlval, yytext, yyleng) \
	if (SCNG(output_filter)) { \
		SCNG(output_filter)(&(zendlval->value.str.val), &(zendlval->value.str.len), yytext, yyleng TSRMLS_CC); \
	} else { \
		zendlval->value.str.val = (char *) estrndup(yytext, yyleng); \
		zendlval->value.str.len = yyleng; \
	}
#else /* ZEND_MULTIBYTE */
# define zend_copy_value(zendlval, yytext, yyleng) \
	zendlval->value.str.val = (char *)estrndup(yytext, yyleng); \
	zendlval->value.str.len = yyleng;
#endif /* ZEND_MULTIBYTE */

/* Macros after this point can all be overridden by user definitions in
 * section 1.
 */

#ifndef YY_SKIP_YYWRAP
#ifdef __cplusplus
extern "C" int yywrap YY_PROTO(( void ));
#else
extern int yywrap YY_PROTO(( void ));
#endif
#endif

#ifndef YY_NO_UNPUT
static void yyunput YY_PROTO(( int c, char *buf_ptr TSRMLS_DC ));
#endif

#ifndef yytext_ptr
static void yy_flex_strncpy YY_PROTO(( char *, yyconst char *, int ));
#endif

#ifdef YY_NEED_STRLEN
static int yy_flex_strlen YY_PROTO(( yyconst char * ));
#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
static int 3 YY_PROTO(( TSRMLS_D ));
#else
static int input YY_PROTO(( TSRMLS_D ));
#endif
#endif

#if YY_STACK_USED
#define yy_start_stack_ptr SCNG(yy_start_stack_ptr)
#define yy_start_stack_depth SCNG(yy_start_stack_depth)
#define yy_start_stack SCNG(yy_start_stack)
/*
static int yy_start_stack_ptr = 0;
static int yy_start_stack_depth = 0;
static int *yy_start_stack = 0;
*/
#ifndef YY_NO_PUSH_STATE
static void yy_push_state YY_PROTO(( int new_state TSRMLS_DC ));
#endif
#ifndef YY_NO_POP_STATE
static void yy_pop_state YY_PROTO(( TSRMLS_D ));
#endif
#ifndef YY_NO_TOP_STATE
static int yy_top_state YY_PROTO(( TSRMLS_D ));
#endif

#else
#define YY_NO_PUSH_STATE 1
#define YY_NO_POP_STATE 1
#define YY_NO_TOP_STATE 1
#endif

#ifdef YY_MALLOC_DECL
YY_MALLOC_DECL
#else
#if __STDC__
#ifndef __cplusplus
#include <stdlib.h>
#endif
#else
/* Just try to get by without declaring the routines.  This will fail
 * miserably on non-ANSI systems for which sizeof(size_t) != sizeof(int)
 * or sizeof(void*) != sizeof(int).
 */
#endif
#endif

/* Amount of stuff to slurp up with each read. */
#ifndef YY_READ_BUF_SIZE
#define YY_READ_BUF_SIZE 8192
#endif

/* Copy whatever the last rule matched to the standard output. */

#ifndef ECHO
/* This used to be an fputs(), but since the string might contain NUL's,
 * we now use fwrite().
 */
#define ECHO (void) fwrite( yytext, yyleng, 1, SCNG(yy_out) )
#endif

/* Gets input and stuffs it into "buf".  number of characters read, or YY_NULL,
 * is returned in "result".
 */
#ifndef YY_INPUT
#define YY_INPUT(buf,result,max_size) \
	if ( yy_current_buffer->yy_is_interactive ) \
		{ \
		int c = '*', n; \
		for ( n = 0; n < max_size && \
			     (c = getc( yyin )) != EOF && c != '\n'; ++n ) \
			buf[n] = (char) c; \
		if ( c == '\n' ) \
			buf[n++] = (char) c; \
		if ( c == EOF && ferror( yyin ) ) \
			YY_FATAL_ERROR( "input in flex scanner failed" ); \
		result = n; \
		} \
	else if ( ((result = fread( buf, 1, max_size, yyin )) == 0) \
		  && ferror( yyin ) ) \
		YY_FATAL_ERROR( "input in flex scanner failed" );
#endif

/* No semi-colon after return; correct usage is to write "yyterminate();" -
 * we don't want an extra ';' after the "return" because that will cause
 * some compilers to complain about unreachable statements.
 */
#ifndef yyterminate
#define yyterminate() return YY_NULL
#endif

/* Number of entries by which start-condition stack grows. */
#ifndef YY_START_STACK_INCR
#define YY_START_STACK_INCR 25
#endif

/* Report a fatal error. */
#ifndef YY_FATAL_ERROR
#define YY_FATAL_ERROR(msg) yy_fatal_error( msg )
#endif


/* Default declaration of generated scanner - a define so the user can
 * easily add parameters.
 */
#ifndef YY_DECL
#define YY_DECL int yylex YY_PROTO(( void ))
#endif

/* Code executed at the beginning of each rule, after yytext and yyleng
 * have been set up.
 */
#ifndef YY_USER_ACTION
#define YY_USER_ACTION
#endif

/* Code executed at the end of each rule. */
#ifndef YY_BREAK
#define YY_BREAK break;
#endif

#define YY_RULE_SETUP \
	if ( yyleng > 0 ) \
		yy_current_buffer->yy_at_bol = \
				(yytext[yyleng - 1] == '\n'); \
	YY_USER_ACTION

YY_DECL
	{
	register yy_state_type yy_current_state;
	register char *yy_cp, *yy_bp;
	register int yy_act;




	if ( yy_init )
		{
		yy_init = 0;

#ifdef YY_USER_INIT
		YY_USER_INIT;
#endif

		if ( ! yy_start )
			yy_start = 1;	/* first start state */

		if ( ! SCNG(yy_in) )
			SCNG(yy_in) = stdin;

		if ( ! SCNG(yy_out) )
			SCNG(yy_out) = stdout;

		if ( ! yy_current_buffer )
			yy_current_buffer =
				yy_create_buffer( SCNG(yy_in), YY_BUF_SIZE TSRMLS_CC );

		yy_load_buffer_state(TSRMLS_C);
		}

	while ( 1 )		/* loops until end-of-file is reached */
		{
		yy_more_len = 0;
		if ( yy_more_flag )
			{
			yy_more_len = yy_c_buf_p - yytext_ptr;
			yy_more_flag = 0;
			}
		yy_cp = yy_c_buf_p;

		/* Support of yytext. */
		*yy_cp = yy_hold_char;

		/* yy_bp points to the position in yy_ch_buf of the start of
		 * the current run.
		 */
		yy_bp = yy_cp;

		yy_current_state = yy_start;
		yy_current_state += YY_AT_BOL();
yy_match:
		do
			{
			register YY_CHAR yy_c = yy_ec[YY_SC_TO_UI(*yy_cp)];
			if ( yy_accept[yy_current_state] )
				{
				yy_last_accepting_state = yy_current_state;
				yy_last_accepting_cpos = yy_cp;
				}
			while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
				{
				yy_current_state = (int) yy_def[yy_current_state];
				if ( yy_current_state >= 1367 )
					yy_c = yy_meta[(unsigned int) yy_c];
				}
			yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
			++yy_cp;
			}
		while ( yy_base[yy_current_state] != 7800 );

yy_find_action:
		yy_act = yy_accept[yy_current_state];
		if ( yy_act == 0 )
			{ /* have to back up */
			yy_cp = yy_last_accepting_cpos;
			yy_current_state = yy_last_accepting_state;
			yy_act = yy_accept[yy_current_state];
			}

		YY_DO_BEFORE_ACTION;


do_action:	/* This label is used only to access EOF actions. */


		switch ( yy_act )
	{ /* beginning of action switch */
			case 0: /* must back up */
			/* undo the effects of YY_DO_BEFORE_ACTION */
			*yy_cp = yy_hold_char;
			yy_cp = yy_last_accepting_cpos;
			yy_current_state = yy_last_accepting_state;
			goto yy_find_action;

case 1:
YY_RULE_SETUP
{
	return T_EXIT;
}
	YY_BREAK
case 2:
YY_RULE_SETUP
{
	return T_EXIT;
}
	YY_BREAK
case 3:
YY_RULE_SETUP
{
	return T_OLD_FUNCTION;
}
	YY_BREAK
case 4:
YY_RULE_SETUP
{
	return T_FUNCTION;
}
	YY_BREAK
case 5:
YY_RULE_SETUP
{
	return T_CONST;
}
	YY_BREAK
case 6:
YY_RULE_SETUP
{
	return T_RETURN;
}
	YY_BREAK
case 7:
YY_RULE_SETUP
{
	return T_IF;
}
	YY_BREAK
case 8:
YY_RULE_SETUP
{
	return T_ELSEIF;
}
	YY_BREAK
case 9:
YY_RULE_SETUP
{
	return T_ENDIF;
}
	YY_BREAK
case 10:
YY_RULE_SETUP
{
	return T_ELSE;
}
	YY_BREAK
case 11:
YY_RULE_SETUP
{
	return T_WHILE;
}
	YY_BREAK
case 12:
YY_RULE_SETUP
{
	return T_ENDWHILE;
}
	YY_BREAK
case 13:
YY_RULE_SETUP
{
	return T_DO;
}
	YY_BREAK
case 14:
YY_RULE_SETUP
{
	return T_FOR;
}
	YY_BREAK
case 15:
YY_RULE_SETUP
{
	return T_ENDFOR;
}
	YY_BREAK
case 16:
YY_RULE_SETUP
{
	return T_FOREACH;
}
	YY_BREAK
case 17:
YY_RULE_SETUP
{
	return T_ENDFOREACH;
}
	YY_BREAK
case 18:
YY_RULE_SETUP
{
	return T_DECLARE;
}
	YY_BREAK
case 19:
YY_RULE_SETUP
{
	return T_ENDDECLARE;
}
	YY_BREAK
case 20:
YY_RULE_SETUP
{
	return T_AS;
}
	YY_BREAK
case 21:
YY_RULE_SETUP
{
	return T_SWITCH;
}
	YY_BREAK
case 22:
YY_RULE_SETUP
{
	return T_ENDSWITCH;
}
	YY_BREAK
case 23:
YY_RULE_SETUP
{
	return T_CASE;
}
	YY_BREAK
case 24:
YY_RULE_SETUP
{
	return T_DEFAULT;
}
	YY_BREAK
case 25:
YY_RULE_SETUP
{
	return T_BREAK;
}
	YY_BREAK
case 26:
YY_RULE_SETUP
{
	return T_CONTINUE;
}
	YY_BREAK
case 27:
YY_RULE_SETUP
{
	return T_ECHO;
}
	YY_BREAK
case 28:
YY_RULE_SETUP
{
	return T_PRINT;
}
	YY_BREAK
case 29:
YY_RULE_SETUP
{
	return T_CLASS;
}
	YY_BREAK
case 30:
YY_RULE_SETUP
{
	return T_EXTENDS;
}
	YY_BREAK
case 31:
YY_RULE_SETUP
{
	yy_push_state(ST_LOOKING_FOR_PROPERTY TSRMLS_CC);
	return T_OBJECT_OPERATOR;
}
	YY_BREAK
case 32:
YY_RULE_SETUP
{
	yy_pop_state(TSRMLS_C);
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	return T_STRING;
}
	YY_BREAK
case 33:
YY_RULE_SETUP
{
	yyless(0);
	yy_pop_state(TSRMLS_C);
}
	YY_BREAK
case 34:
YY_RULE_SETUP
{
	return T_PAAMAYIM_NEKUDOTAYIM;
}
	YY_BREAK
case 35:
YY_RULE_SETUP
{
	return T_NEW;
}
	YY_BREAK
case 36:
YY_RULE_SETUP
{
	return T_VAR;
}
	YY_BREAK
case 37:
YY_RULE_SETUP
{
	return T_INT_CAST;
}
	YY_BREAK
case 38:
YY_RULE_SETUP
{
	return T_DOUBLE_CAST;
}
	YY_BREAK
case 39:
YY_RULE_SETUP
{
	return T_STRING_CAST;
}
	YY_BREAK
case 40:
YY_RULE_SETUP
{
	return T_ARRAY_CAST;
}
	YY_BREAK
case 41:
YY_RULE_SETUP
{
	return T_OBJECT_CAST;
}
	YY_BREAK
case 42:
YY_RULE_SETUP
{
	return T_BOOL_CAST;
}
	YY_BREAK
case 43:
YY_RULE_SETUP
{
	return T_UNSET_CAST;
}
	YY_BREAK
case 44:
YY_RULE_SETUP
{
	return T_EVAL;
}
	YY_BREAK
case 45:
YY_RULE_SETUP
{
	return T_INCLUDE;
}
	YY_BREAK
case 46:
YY_RULE_SETUP
{
	return T_INCLUDE_ONCE;
}
	YY_BREAK
case 47:
YY_RULE_SETUP
{
	return T_REQUIRE;
}
	YY_BREAK
case 48:
YY_RULE_SETUP
{
	return T_REQUIRE_ONCE;
}
	YY_BREAK
case 49:
YY_RULE_SETUP
{
	return T_USE;
}
	YY_BREAK
case 50:
YY_RULE_SETUP
{
	return T_GLOBAL;
}
	YY_BREAK
case 51:
YY_RULE_SETUP
{
	return T_ISSET;
}
	YY_BREAK
case 52:
YY_RULE_SETUP
{
	return T_EMPTY;
}
	YY_BREAK
case 53:
YY_RULE_SETUP
{
	return T_STATIC;
}
	YY_BREAK
case 54:
YY_RULE_SETUP
{
	return T_UNSET;
}
	YY_BREAK
case 55:
YY_RULE_SETUP
{
	return T_DOUBLE_ARROW;
}
	YY_BREAK
case 56:
YY_RULE_SETUP
{
	return T_LIST;
}
	YY_BREAK
case 57:
YY_RULE_SETUP
{
	return T_ARRAY;
}
	YY_BREAK
case 58:
YY_RULE_SETUP
{
	return T_INC;
}
	YY_BREAK
case 59:
YY_RULE_SETUP
{
	return T_DEC;
}
	YY_BREAK
case 60:
YY_RULE_SETUP
{
	return T_IS_IDENTICAL;
}
	YY_BREAK
case 61:
YY_RULE_SETUP
{
	return T_IS_NOT_IDENTICAL;
}
	YY_BREAK
case 62:
YY_RULE_SETUP
{
	return T_IS_EQUAL;
}
	YY_BREAK
case 63:
YY_RULE_SETUP
{
	return T_IS_NOT_EQUAL;
}
	YY_BREAK
case 64:
YY_RULE_SETUP
{
	return T_IS_SMALLER_OR_EQUAL;
}
	YY_BREAK
case 65:
YY_RULE_SETUP
{
	return T_IS_GREATER_OR_EQUAL;
}
	YY_BREAK
case 66:
YY_RULE_SETUP
{
	return T_PLUS_EQUAL;
}
	YY_BREAK
case 67:
YY_RULE_SETUP
{
	return T_MINUS_EQUAL;
}
	YY_BREAK
case 68:
YY_RULE_SETUP
{
	return T_MUL_EQUAL;
}
	YY_BREAK
case 69:
YY_RULE_SETUP
{
	return T_DIV_EQUAL;
}
	YY_BREAK
case 70:
YY_RULE_SETUP
{
	return T_CONCAT_EQUAL;
}
	YY_BREAK
case 71:
YY_RULE_SETUP
{
	return T_MOD_EQUAL;
}
	YY_BREAK
case 72:
YY_RULE_SETUP
{
	return T_SL_EQUAL;
}
	YY_BREAK
case 73:
YY_RULE_SETUP
{
	return T_SR_EQUAL;
}
	YY_BREAK
case 74:
YY_RULE_SETUP
{
	return T_AND_EQUAL;
}
	YY_BREAK
case 75:
YY_RULE_SETUP
{
	return T_OR_EQUAL;
}
	YY_BREAK
case 76:
YY_RULE_SETUP
{
	return T_XOR_EQUAL;
}
	YY_BREAK
case 77:
YY_RULE_SETUP
{
	return T_BOOLEAN_OR;
}
	YY_BREAK
case 78:
YY_RULE_SETUP
{
	return T_BOOLEAN_AND;
}
	YY_BREAK
case 79:
YY_RULE_SETUP
{
	return T_LOGICAL_OR;
}
	YY_BREAK
case 80:
YY_RULE_SETUP
{
	return T_LOGICAL_AND;
}
	YY_BREAK
case 81:
YY_RULE_SETUP
{
	return T_LOGICAL_XOR;
}
	YY_BREAK
case 82:
YY_RULE_SETUP
{
	return T_SL;
}
	YY_BREAK
case 83:
YY_RULE_SETUP
{
	return T_SR;
}
	YY_BREAK
case 84:
YY_RULE_SETUP
{
	return yytext[0];
}
	YY_BREAK
case 85:
YY_RULE_SETUP
{
	yy_push_state(ST_IN_SCRIPTING TSRMLS_CC);
	return '{';
}
	YY_BREAK
case 86:
YY_RULE_SETUP
{
	yy_push_state(ST_LOOKING_FOR_VARNAME TSRMLS_CC);
	return T_DOLLAR_OPEN_CURLY_BRACES;
}
	YY_BREAK
case 87:
YY_RULE_SETUP
{
	/* This is a temporary fix which is dependant on flex and it's implementation */
	if (yy_start_stack_ptr) {
		yy_pop_state(TSRMLS_C);
	}
	return '}';
}
	YY_BREAK
case 88:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	yy_pop_state(TSRMLS_C);
	yy_push_state(ST_IN_SCRIPTING TSRMLS_CC);
	return T_STRING_VARNAME;
}
	YY_BREAK
case 89:
YY_RULE_SETUP
{
	yyless(0);
	yy_pop_state(TSRMLS_C);
	yy_push_state(ST_IN_SCRIPTING TSRMLS_CC);
}
	YY_BREAK
case 90:
YY_RULE_SETUP
{
	errno = 0;
	zendlval->value.lval = strtol(yytext, NULL, 0);
	if (errno == ERANGE) { /* overflow */
		zendlval->value.dval = strtod(yytext, NULL);
		zendlval->type = IS_DOUBLE;
		return T_DNUMBER;
	} else {
		zendlval->type = IS_LONG;
		return T_LNUMBER;
	}
}
	YY_BREAK
case 91:
YY_RULE_SETUP
{
	errno = 0;
	zendlval->value.lval = strtoul(yytext, NULL, 16);
	if (errno == ERANGE) { /* overflow */
		/* not trying strtod - it returns trash on 0x-es */
		zendlval->value.lval = LONG_MAX; /* maximal long */
		zend_error(E_NOTICE,"Hex number is too big: %s", yytext);
	} else {
		if (zendlval->value.lval < 0) {
			/* maintain consistency with the old way */
			zendlval->value.dval = (unsigned long) zendlval->value.lval;
			zendlval->type = IS_DOUBLE;
			return T_DNUMBER;
		}
		zendlval->type = IS_LONG;
	}
	zendlval->type = IS_LONG;
	return T_LNUMBER;
}
	YY_BREAK
case 92:
YY_RULE_SETUP
{ /* treat numbers (almost) as strings inside encapsulated strings */
	zendlval->value.str.val = (char *)estrndup(yytext, yyleng);
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	return T_NUM_STRING;
}
	YY_BREAK
case 93:
YY_RULE_SETUP
{
	zendlval->value.dval = strtod(yytext, NULL);
	zendlval->type = IS_DOUBLE;
	return T_DNUMBER;
}
	YY_BREAK
case 94:
YY_RULE_SETUP
{
	char *class_name = NULL;

	if (CG(active_class_entry)) {
		class_name = CG(active_class_entry)->name;
	}
	
	if (!class_name) {
		class_name = "";
	}
	zendlval->value.str.len = strlen(class_name);
	zendlval->value.str.val = estrndup(class_name, zendlval->value.str.len);
	zendlval->type = IS_STRING;
	return T_CLASS_C;
}
	YY_BREAK
case 95:
YY_RULE_SETUP
{
	char *func_name = CG(active_op_array)->function_name;
	
	if (!func_name) {
		func_name = "";
	}
	zendlval->value.str.len = strlen(func_name);
	zendlval->value.str.val = estrndup(func_name, zendlval->value.str.len);
	zendlval->type = IS_STRING;
	return T_FUNC_C;
}
	YY_BREAK
case 96:
YY_RULE_SETUP
{
	zendlval->value.lval = CG(zend_lineno);
	zendlval->type = IS_LONG;
	return T_LINE;
}
	YY_BREAK
case 97:
YY_RULE_SETUP
{
	char *filename = zend_get_compiled_filename(TSRMLS_C);
	
	if (!filename) {
		filename = "";
	}
	zendlval->value.str.len = strlen(filename);
	zendlval->value.str.val = estrndup(filename, zendlval->value.str.len);
	zendlval->type = IS_STRING;
	return T_FILE;
}
	YY_BREAK
case 98:
YY_RULE_SETUP
{
#ifdef ZEND_MULTIBYTE
	if (SCNG(output_filter)) {
		int readsize;
		readsize = SCNG(output_filter)(&(zendlval->value.str.val), &(zendlval->value.str.len), yytext, yyleng TSRMLS_CC);
		if (readsize < yyleng) {
			yyless(readsize);
		}
	} else {
		zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
		zendlval->value.str.len = yyleng;
	}
#else /* ZEND_MULTIBYTE */
	zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
	zendlval->value.str.len = yyleng;
#endif /* ZEND_MULTIBYTE */
	zendlval->type = IS_STRING;
	HANDLE_NEWLINES(yytext, yyleng);
	return T_INLINE_HTML;
}
	YY_BREAK
case 99:
YY_RULE_SETUP
{
	HANDLE_NEWLINES(yytext, yyleng);
	if (CG(short_tags) || yyleng>2) { /* yyleng>2 means it's not <? but <script> */
		zendlval->value.str.val = yytext; /* no copying - intentional */
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		BEGIN(ST_IN_SCRIPTING);
		return T_OPEN_TAG;
	} else {
		zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		return T_INLINE_HTML;
	}
}
	YY_BREAK
case 100:
YY_RULE_SETUP
{
	if ((yytext[1]=='%' && CG(asp_tags)) || (yytext[1]=='?' && CG(short_tags))) {
		zendlval->value.str.val = yytext; /* no copying - intentional */
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		BEGIN(ST_IN_SCRIPTING);
		return T_OPEN_TAG_WITH_ECHO;
	} else {
		zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		return T_INLINE_HTML;
	}
}
	YY_BREAK
case 101:
YY_RULE_SETUP
{
	if (CG(asp_tags)) {
		zendlval->value.str.val = yytext; /* no copying - intentional */
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		BEGIN(ST_IN_SCRIPTING);
		return T_OPEN_TAG;
	} else {
		zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		return T_INLINE_HTML;
	}
}
	YY_BREAK
case 102:
YY_RULE_SETUP
{
	zendlval->value.str.val = yytext; /* no copying - intentional */
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	HANDLE_NEWLINE(yytext[yyleng-1]);
	BEGIN(ST_IN_SCRIPTING);
	return T_OPEN_TAG;
}
	YY_BREAK
case 103:
YY_RULE_SETUP
{
	zend_error(E_WARNING, "&lt;?php_track_vars?&gt; is no longer supported - please use the track_vars INI directive instead");
	HANDLE_NEWLINE(yytext[yyleng-1]);
	zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	return T_INLINE_HTML;
}
	YY_BREAK
case 104:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, (yytext+1), (yyleng-1));
	zendlval->type = IS_STRING;
	return T_VARIABLE;
}
	YY_BREAK
case 105:
YY_RULE_SETUP
{
	HANDLE_NEWLINES(yytext, yyleng);
	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	return T_STRING;
}
	YY_BREAK
case 106:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	return T_STRING;
}
	YY_BREAK
case 107:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	return T_STRING;
}
	YY_BREAK
case 108:
YY_RULE_SETUP
{
	zendlval->value.str.val = yytext; /* no copying - intentional */
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	HANDLE_NEWLINES(yytext, yyleng);
	return T_WHITESPACE;
}
	YY_BREAK
case 109:
YY_RULE_SETUP
{
	BEGIN(ST_ONE_LINE_COMMENT);
	yymore();
}
	YY_BREAK
case 110:
YY_RULE_SETUP
{
	yymore();
}
	YY_BREAK
case 111:
YY_RULE_SETUP
{
	yymore();
}
	YY_BREAK
case 112:
YY_RULE_SETUP
{
	zendlval->value.str.val = yytext; /* no copying - intentional */
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	BEGIN(ST_IN_SCRIPTING);
	CG(zend_lineno)++;
	return T_COMMENT;
}
	YY_BREAK
case 113:
YY_RULE_SETUP
{
    if (CG(asp_tags) || yytext[yyleng-2] != '%') { /* asp comment? */
		zendlval->value.str.val = yytext; /* no copying - intentional */
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		yyless(yyleng-2);
		BEGIN(ST_IN_SCRIPTING);
		return T_COMMENT;
	} else {
		yymore();
	}
}
	YY_BREAK
case 114:
YY_RULE_SETUP
{
	CG(comment_start_line) = CG(zend_lineno);
	BEGIN(ST_COMMENT);
	yymore();
}
	YY_BREAK
case 115:
YY_RULE_SETUP
{
	yymore();
}
	YY_BREAK
case 116:
YY_RULE_SETUP
{
	HANDLE_NEWLINES(yytext, yyleng);
	BEGIN(ST_IN_SCRIPTING);
	return T_COMMENT;
}
	YY_BREAK
case 117:
YY_RULE_SETUP
{
	yymore();
}
	YY_BREAK
case 118:
YY_RULE_SETUP
{
	zendlval->value.str.val = yytext; /* no copying - intentional */
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	BEGIN(INITIAL);
	return T_CLOSE_TAG;  /* implicit ';' at php-end tag */
}
	YY_BREAK
case 119:
YY_RULE_SETUP
{
	if (CG(asp_tags)) {
		BEGIN(INITIAL);
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		zendlval->value.str.val = yytext; /* no copying - intentional */
		return T_CLOSE_TAG;  /* implicit ';' at php-end tag */
	} else {
		yyless(1);
		return yytext[0];
	}
}
	YY_BREAK
case 120:
YY_RULE_SETUP
{
	register char *s, *t;
	char *end;
	
	zendlval->value.str.val = estrndup(yytext+1, yyleng-2);
	zendlval->value.str.len = yyleng-2;
	zendlval->type = IS_STRING;
	HANDLE_NEWLINES(yytext, yyleng);
	
	/* convert escape sequences */
	s = t = zendlval->value.str.val;
	end = s+zendlval->value.str.len;
	while (s<end) {
		if (*s=='\\') {
			s++;
			if (s>=end) {
				continue;
			}
			switch(*s) {
				case 'n':
					*t++ = '\n';
					zendlval->value.str.len--;
					break;
				case 'r':
					*t++ = '\r';
					zendlval->value.str.len--;
					break;
				case 't':
					*t++ = '\t';
					zendlval->value.str.len--;
					break;
				case '\\':
				case '$':
				case '"':
					*t++ = *s;
					zendlval->value.str.len--;
					break;
				default:
					/* check for an octal */
					if (ZEND_IS_OCT(*s)) {
						char octal_buf[4] = { 0, 0, 0, 0 };

						octal_buf[0] = *s;
						zendlval->value.str.len--;
						if ((s+1)<end && ZEND_IS_OCT(*(s+1))) {
							octal_buf[1] = *(++s);
							zendlval->value.str.len--;
							if ((s+1)<end && ZEND_IS_OCT(*(s+1))) {
								octal_buf[2] = *(++s);
								zendlval->value.str.len--;
							}
						}
						*t++ = (char) strtol(octal_buf, NULL, 8);
					} else if (*s=='x' && (s+1)<end && ZEND_IS_HEX(*(s+1))) {
						char hex_buf[3] = { 0, 0, 0};

						zendlval->value.str.len--; /* for the 'x' */

						hex_buf[0] = *(++s);
						zendlval->value.str.len--;
						if ((s+1)<end && ZEND_IS_HEX(*(s+1))) {
							hex_buf[1] = *(++s);
							zendlval->value.str.len--;
						}
						*t++ = (char) strtol(hex_buf, NULL, 16);
					} else {
						*t++ = '\\';
						*t++ = *s;
					}
					break;
			}
			s++;
		} else {
			*t++ = *s++;
		}
	}
	*t = 0;

#ifdef ZEND_MULTIBYTE
	if (SCNG(output_filter)) {
		s = zendlval->value.str.val;
		SCNG(output_filter)(&(zendlval->value.str.val), &(zendlval->value.str.len), s, zendlval->value.str.len TSRMLS_CC);
		efree(s);
	}
#endif /* ZEND_MULTIBYTE */

	return T_CONSTANT_ENCAPSED_STRING;
}
	YY_BREAK
case 121:
YY_RULE_SETUP
{
	register char *s, *t;
	char *end;
	
	zendlval->value.str.val = estrndup(yytext+1, yyleng-2);
	zendlval->value.str.len = yyleng-2;
	zendlval->type = IS_STRING;
	HANDLE_NEWLINES(yytext, yyleng);
	
	/* convert escape sequences */
	s = t = zendlval->value.str.val;
	end = s+zendlval->value.str.len;
	while (s<end) {
		if (*s=='\\') {
			s++;
			if (s>=end) {
				continue;
			}
			switch(*s) {
				case '\\':
				case '\'':
					*t++ = *s;
					zendlval->value.str.len--;
					break;
				default:
					*t++ = '\\';
					*t++ = *s;
					break;
			}
			s++;
		} else {
			*t++ = *s++;
		}
	}
	*t = 0;

#ifdef ZEND_MULTIBYTE
	if (SCNG(output_filter)) {
		s = zendlval->value.str.val;
		SCNG(output_filter)(&(zendlval->value.str.val), &(zendlval->value.str.len), s, zendlval->value.str.len TSRMLS_CC);
		efree(s);
	}
#endif /* ZEND_MULTIBYTE */

	return T_CONSTANT_ENCAPSED_STRING;
}
	YY_BREAK
case 122:
YY_RULE_SETUP
{
	BEGIN(ST_DOUBLE_QUOTES);
	return '\"';
}
	YY_BREAK
case 123:
YY_RULE_SETUP
{
	char *s;
	CG(zend_lineno)++;
	CG(heredoc_len) = yyleng-3-1-(yytext[yyleng-2]=='\r'?1:0);
	s = yytext+3;
	while ((*s == ' ') || (*s == '\t')) {
		s++;
		CG(heredoc_len)--;
	}
	CG(heredoc) = estrndup(s, CG(heredoc_len));
	BEGIN(ST_HEREDOC);
	return T_START_HEREDOC;
}
	YY_BREAK
case 124:
YY_RULE_SETUP
{
	BEGIN(ST_BACKQUOTE);
	return '`';
}
	YY_BREAK
case 125:
YY_RULE_SETUP
{
	BEGIN(ST_SINGLE_QUOTE);
	return '\'';
}
	YY_BREAK
case 126:
YY_RULE_SETUP
{
	int label_len;
	unsigned char unput_semicolon;

	CG(zend_lineno)++;
	if (yytext[yyleng-2]=='\r') {
		label_len = yyleng-2;
	} else {
		label_len = yyleng-1;
	}
	
	if (yytext[label_len-1]==';') {
		label_len--;
		unput_semicolon=1;
	} else{
		unput_semicolon=0;
	}

	if (label_len==CG(heredoc_len) && !memcmp(yytext, CG(heredoc), label_len)) {
		zendlval->value.str.val = estrndup(yytext, yyleng); /* unput destroys yytext */
		zendlval->value.str.len = yyleng;
		if (unput_semicolon) {
			unput(';');
		}
		efree(CG(heredoc));
		CG(heredoc)=NULL;
		CG(heredoc_len)=0;
		BEGIN(ST_IN_SCRIPTING);
		return T_END_HEREDOC;
	} else {
 		zend_copy_value(zendlval, yytext, yyleng);
		zendlval->type = IS_STRING;
		return T_STRING;
	}
}
	YY_BREAK
case 127:
YY_RULE_SETUP
{
	HANDLE_NEWLINES(yytext, yyleng);
	zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	return T_ENCAPSED_AND_WHITESPACE;
}
	YY_BREAK
case 128:
YY_RULE_SETUP
{
	HANDLE_NEWLINES(yytext, yyleng);
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	return T_ENCAPSED_AND_WHITESPACE;
}
	YY_BREAK
case 129:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	return T_ENCAPSED_AND_WHITESPACE;
}
	YY_BREAK
case 130:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	return T_ENCAPSED_AND_WHITESPACE;
}
	YY_BREAK
case 131:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) yytext[0];
	if (yyleng == 2) {
		yyless(1);
	}
	return T_CHARACTER;	
}
	YY_BREAK
case 132:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) yytext[0];
	return yytext[0];
}
	YY_BREAK
case 133:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) yytext[0];
	yy_push_state(ST_IN_SCRIPTING TSRMLS_CC);
	yyless(1);
	return T_CURLY_OPEN;
}
	YY_BREAK
case 134:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) '\'';
	return T_CHARACTER;
}
	YY_BREAK
case 135:
YY_RULE_SETUP
{
	zendlval->value.lval = (long)'\\';
	return T_CHARACTER;
}
	YY_BREAK
case 136:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) '"';
	return T_CHARACTER;
}
	YY_BREAK
case 137:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) '`';
	return T_CHARACTER;
}
	YY_BREAK
case 138:
YY_RULE_SETUP
{
	zendlval->value.lval = strtol(yytext+1, NULL, 8);
	return T_CHARACTER;
}
	YY_BREAK
case 139:
YY_RULE_SETUP
{
	zendlval->value.lval = strtol (yytext+2, NULL, 16);
	return T_CHARACTER;
}
	YY_BREAK
case 140:
YY_RULE_SETUP
{
	switch (yytext[1]) {
		case 'n':
			zendlval->value.lval = (long) '\n';
			break;
		case 't':
			zendlval->value.lval = (long) '\t';
			break;
		case 'r':
			zendlval->value.lval = (long) '\r';
			break;
		case '\\':
			zendlval->value.lval = (long) '\\';
			break;
		case '$':
			zendlval->value.lval = (long) yytext[1];
			break;
		case '{':
			zendlval->value.lval = (long) yytext[1];
			break;
		default:
			zendlval->value.str.val = estrndup(yytext, yyleng);
			zendlval->value.str.len = yyleng;
			zendlval->type = IS_STRING;
			return T_BAD_CHARACTER;
			break;
	}
	return T_CHARACTER;
}
	YY_BREAK
case 141:
YY_RULE_SETUP
{
	zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	return T_ENCAPSED_AND_WHITESPACE;
}
	YY_BREAK
case 142:
YY_RULE_SETUP
{
	BEGIN(ST_IN_SCRIPTING);
	return '\"';
}
	YY_BREAK
case 143:
YY_RULE_SETUP
{
	BEGIN(ST_IN_SCRIPTING);
	return '`';
}
	YY_BREAK
case 144:
YY_RULE_SETUP
{
	BEGIN(ST_IN_SCRIPTING);
	return '\'';
}
	YY_BREAK
case YY_STATE_EOF(ST_DOUBLE_QUOTES):
case YY_STATE_EOF(ST_BACKQUOTE):
case YY_STATE_EOF(INITIAL):
case YY_STATE_EOF(ST_IN_SCRIPTING):
case YY_STATE_EOF(ST_LOOKING_FOR_PROPERTY):
{
	return 0;
}
	YY_BREAK
case YY_STATE_EOF(ST_COMMENT):
{
	zend_error(E_COMPILE_WARNING,"Unterminated comment starting line %d", CG(comment_start_line));
	return 0;
}
	YY_BREAK
case 145:
YY_RULE_SETUP
{
	zend_error(E_COMPILE_WARNING,"Unexpected character in input:  '%c' (ASCII=%d) state=%d", yytext[0], yytext[0], YYSTATE);
}
	YY_BREAK
case 146:
YY_RULE_SETUP
ECHO;
	YY_BREAK
case YY_STATE_EOF(ST_SINGLE_QUOTE):
case YY_STATE_EOF(ST_HEREDOC):
case YY_STATE_EOF(ST_LOOKING_FOR_VARNAME):
case YY_STATE_EOF(ST_ONE_LINE_COMMENT):
	yyterminate();

	case YY_END_OF_BUFFER:
		{
		/* Amount of text matched not including the EOB char. */
		int yy_amount_of_matched_text = (int) (yy_cp - yytext_ptr) - 1;

		/* Undo the effects of YY_DO_BEFORE_ACTION. */
		*yy_cp = yy_hold_char;

		if ( yy_current_buffer->yy_buffer_status == YY_BUFFER_NEW )
			{
			/* We're scanning a new file or input source.  It's
			 * possible that this happened because the user
			 * just pointed yyin at a new source and called
			 * yylex().  If so, then we have to assure
			 * consistency between yy_current_buffer and our
			 * globals.  Here is the right place to do so, because
			 * this is the first action (other than possibly a
			 * back-up) that will match for the new input source.
			 */
			SCNG(yy_n_chars) = yy_current_buffer->yy_n_chars;
			yy_current_buffer->yy_input_file = SCNG(yy_in);
			yy_current_buffer->yy_buffer_status = YY_BUFFER_NORMAL;
			}

		/* Note that here we test for yy_c_buf_p "<=" to the position
		 * of the first EOB in the buffer, since yy_c_buf_p will
		 * already have been incremented past the NUL character
		 * (since all states make transitions on EOB to the
		 * end-of-buffer state).  Contrast this with the test
		 * in input().
		 */
		if ( yy_c_buf_p <= &yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars)] )
			{ /* This was really a NUL. */
			yy_state_type yy_next_state;

			yy_c_buf_p = yytext_ptr + yy_amount_of_matched_text;

			yy_current_state = yy_get_previous_state(TSRMLS_C);

			/* Okay, we're now positioned to make the NUL
			 * transition.  We couldn't have
			 * yy_get_previous_state() go ahead and do it
			 * for us because it doesn't know how to deal
			 * with the possibility of jamming (and we don't
			 * want to build jamming into it because then it
			 * will run more slowly).
			 */

			yy_next_state = yy_try_NUL_trans( yy_current_state TSRMLS_CC );

			yy_bp = yytext_ptr + YY_MORE_ADJ;

			if ( yy_next_state )
				{
				/* Consume the NUL. */
				yy_cp = ++yy_c_buf_p;
				yy_current_state = yy_next_state;
				goto yy_match;
				}

			else
				{
				yy_cp = yy_c_buf_p;
				goto yy_find_action;
				}
			}

		else switch ( yy_get_next_buffer(TSRMLS_C) )
			{
			case EOB_ACT_END_OF_FILE:
				{
				yy_did_buffer_switch_on_eof = 0;

				if ( yywrap() )
					{
					/* Note: because we've taken care in
					 * yy_get_next_buffer() to have set up
					 * yytext, we can now set up
					 * yy_c_buf_p so that if some total
					 * hoser (like flex itself) wants to
					 * call the scanner after we return the
					 * YY_NULL, it'll still work - another
					 * YY_NULL will get returned.
					 */
					yy_c_buf_p = yytext_ptr + YY_MORE_ADJ;

					yy_act = YY_STATE_EOF(YY_START);
					goto do_action;
					}

				else
					{
					if ( ! yy_did_buffer_switch_on_eof )
						YY_NEW_FILE;
					}
				break;
				}

			case EOB_ACT_CONTINUE_SCAN:
				yy_c_buf_p =
					yytext_ptr + yy_amount_of_matched_text;

				yy_current_state = yy_get_previous_state(TSRMLS_C);

				yy_cp = yy_c_buf_p;
				yy_bp = yytext_ptr + YY_MORE_ADJ;
				goto yy_match;

			case EOB_ACT_LAST_MATCH:
				yy_c_buf_p =
				&yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars)];

				yy_current_state = yy_get_previous_state(TSRMLS_C);

				yy_cp = yy_c_buf_p;
				yy_bp = yytext_ptr + YY_MORE_ADJ;
				goto yy_find_action;
			}
		break;
		}

	default:
		YY_FATAL_ERROR(
			"fatal flex scanner internal error--no action found" );
	} /* end of action switch */
		} /* end of scanning one token */
	} /* end of yylex */


/* yy_get_next_buffer - try to read in a new buffer
 *
 * Returns a code representing an action:
 *	EOB_ACT_LAST_MATCH -
 *	EOB_ACT_CONTINUE_SCAN - continue scanning from current position
 *	EOB_ACT_END_OF_FILE - end of file
 */

static int yy_get_next_buffer(TSRMLS_D)
	{
	register char *dest = yy_current_buffer->yy_ch_buf;
	register char *source = yytext_ptr;
	register int number_to_move, i;
	int ret_val;

	if ( yy_c_buf_p > &yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars) + 1] )
		YY_FATAL_ERROR(
		"fatal flex scanner internal error--end of buffer missed" );

	if ( yy_current_buffer->yy_fill_buffer == 0 )
		{ /* Don't try to fill the buffer, so this is an EOF. */
		if ( yy_c_buf_p - yytext_ptr - YY_MORE_ADJ == 1 )
			{
			/* We matched a single character, the EOB, so
			 * treat this as a final EOF.
			 */
			return EOB_ACT_END_OF_FILE;
			}

		else
			{
			/* We matched some text prior to the EOB, first
			 * process it.
			 */
			return EOB_ACT_LAST_MATCH;
			}
		}

	/* Try to read more data. */

	/* First move last chars to start of buffer. */
	number_to_move = (int) (yy_c_buf_p - yytext_ptr) - 1;

	for ( i = 0; i < number_to_move; ++i )
		*(dest++) = *(source++);

	if ( yy_current_buffer->yy_buffer_status == YY_BUFFER_EOF_PENDING )
		/* don't do the read, it's not guaranteed to return an EOF,
		 * just force an EOF
		 */
		yy_current_buffer->yy_n_chars = SCNG(yy_n_chars) = 0;

	else
		{
		int num_to_read =
			yy_current_buffer->yy_buf_size - number_to_move - 1;

		while ( num_to_read <= 0 )
			{ /* Not enough room in the buffer - grow it. */
#ifdef YY_USES_REJECT
			YY_FATAL_ERROR(
"input buffer overflow, can't enlarge buffer because scanner uses REJECT" );
#else

			/* just a shorter name for the current buffer */
			YY_BUFFER_STATE b = yy_current_buffer;

			int yy_c_buf_p_offset =
				(int) (yy_c_buf_p - b->yy_ch_buf);

			if ( b->yy_is_our_buffer )
				{
				int new_size = b->yy_buf_size * 2;

				if ( new_size <= 0 )
					b->yy_buf_size += b->yy_buf_size / 8;
				else
					b->yy_buf_size *= 2;

				b->yy_ch_buf = (char *)
					/* Include room in for 2 EOB chars. */
					yy_flex_realloc( (void *) b->yy_ch_buf,
							 b->yy_buf_size + 2 );
				}
			else
				/* Can't grow it, we don't own it. */
				b->yy_ch_buf = 0;

			if ( ! b->yy_ch_buf )
				YY_FATAL_ERROR(
				"fatal error - scanner input buffer overflow" );

			yy_c_buf_p = &b->yy_ch_buf[yy_c_buf_p_offset];

			num_to_read = yy_current_buffer->yy_buf_size -
						number_to_move - 1;
#endif
			}

		if ( num_to_read > YY_READ_BUF_SIZE )
			num_to_read = YY_READ_BUF_SIZE;

		/* Read in more data. */
		YY_INPUT( (&yy_current_buffer->yy_ch_buf[number_to_move]),
			SCNG(yy_n_chars), num_to_read );

		yy_current_buffer->yy_n_chars = SCNG(yy_n_chars);
		}

	if ( SCNG(yy_n_chars) == 0 )
		{
		if ( number_to_move == YY_MORE_ADJ )
			{
			ret_val = EOB_ACT_END_OF_FILE;
			yyrestart( SCNG(yy_in) TSRMLS_CC );
			}

		else
			{
			ret_val = EOB_ACT_LAST_MATCH;
			yy_current_buffer->yy_buffer_status =
				YY_BUFFER_EOF_PENDING;
			}
		}

	else
		ret_val = EOB_ACT_CONTINUE_SCAN;

	SCNG(yy_n_chars) += number_to_move;
	yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars)] = YY_END_OF_BUFFER_CHAR;
	yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars) + 1] = YY_END_OF_BUFFER_CHAR;

	yytext_ptr = &yy_current_buffer->yy_ch_buf[0];

	return ret_val;
	}


/* yy_get_previous_state - get the state just before the EOB char was reached */

static yy_state_type yy_get_previous_state(TSRMLS_D)
	{
	register yy_state_type yy_current_state;
	register char *yy_cp;

	yy_current_state = yy_start;
	yy_current_state += YY_AT_BOL();

	for ( yy_cp = yytext_ptr + YY_MORE_ADJ; yy_cp < yy_c_buf_p; ++yy_cp )
		{
		register YY_CHAR yy_c = (*yy_cp ? yy_ec[YY_SC_TO_UI(*yy_cp)] : 1);
		if ( yy_accept[yy_current_state] )
			{
			yy_last_accepting_state = yy_current_state;
			yy_last_accepting_cpos = yy_cp;
			}
		while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
			{
			yy_current_state = (int) yy_def[yy_current_state];
			if ( yy_current_state >= 1367 )
				yy_c = yy_meta[(unsigned int) yy_c];
			}
		yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
		}

	return yy_current_state;
	}


/* yy_try_NUL_trans - try to make a transition on the NUL character
 *
 * synopsis
 *	next_state = yy_try_NUL_trans( current_state );
 */

#ifdef YY_USE_PROTOS
static yy_state_type yy_try_NUL_trans( yy_state_type yy_current_state TSRMLS_DC )
#else
static yy_state_type yy_try_NUL_trans( yy_current_state TSRMLS_CC )
yy_state_type yy_current_state;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	register int yy_is_jam;
	register char *yy_cp = yy_c_buf_p;

	register YY_CHAR yy_c = 1;
	if ( yy_accept[yy_current_state] )
		{
		yy_last_accepting_state = yy_current_state;
		yy_last_accepting_cpos = yy_cp;
		}
	while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
		{
		yy_current_state = (int) yy_def[yy_current_state];
		if ( yy_current_state >= 1367 )
			yy_c = yy_meta[(unsigned int) yy_c];
		}
	yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
	yy_is_jam = (yy_current_state == 1366);

	return yy_is_jam ? 0 : yy_current_state;
	}


#ifndef YY_NO_UNPUT
#ifdef YY_USE_PROTOS
static void yyunput( int c, register char *yy_bp TSRMLS_DC )
#else
static void yyunput( c, yy_bp TSRMLS_CC )
int c;
register char *yy_bp;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	register char *yy_cp = yy_c_buf_p;

	/* undo effects of setting up yytext */
	*yy_cp = yy_hold_char;

	if ( yy_cp < yy_current_buffer->yy_ch_buf + 2 )
		{ /* need to shift things up to make room */
		/* +2 for EOB chars. */
		register int number_to_move = SCNG(yy_n_chars) + 2;
		register char *dest = &yy_current_buffer->yy_ch_buf[
					yy_current_buffer->yy_buf_size + 2];
		register char *source =
				&yy_current_buffer->yy_ch_buf[number_to_move];

		while ( source > yy_current_buffer->yy_ch_buf )
			*--dest = *--source;

		yy_cp += (int) (dest - source);
		yy_bp += (int) (dest - source);
		yy_current_buffer->yy_n_chars =
			SCNG(yy_n_chars) = yy_current_buffer->yy_buf_size;

		if ( yy_cp < yy_current_buffer->yy_ch_buf + 2 )
			YY_FATAL_ERROR( "flex scanner push-back overflow" );
		}

	*--yy_cp = (char) c;


	yytext_ptr = yy_bp;
	yy_hold_char = *yy_cp;
	yy_c_buf_p = yy_cp;
	}
#endif	/* ifndef YY_NO_UNPUT */


#ifdef __cplusplus
static int yyinput(TSRMLS_D)
#else
static int input(TSRMLS_C)
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	int c;

	*yy_c_buf_p = yy_hold_char;

	if ( *yy_c_buf_p == YY_END_OF_BUFFER_CHAR )
		{
		/* yy_c_buf_p now points to the character we want to return.
		 * If this occurs *before* the EOB characters, then it's a
		 * valid NUL; if not, then we've hit the end of the buffer.
		 */
		if ( yy_c_buf_p < &yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars)] )
			/* This was really a NUL. */
			*yy_c_buf_p = '\0';

		else
			{ /* need more input */
			int offset = yy_c_buf_p - yytext_ptr;
			++yy_c_buf_p;

			switch ( yy_get_next_buffer(TSRMLS_C) )
				{
				case EOB_ACT_LAST_MATCH:
					/* This happens because yy_g_n_b()
					 * sees that we've accumulated a
					 * token and flags that we need to
					 * try matching the token before
					 * proceeding.  But for input(),
					 * there's no matching to consider.
					 * So convert the EOB_ACT_LAST_MATCH
					 * to EOB_ACT_END_OF_FILE.
					 */

					/* Reset buffer status. */
					yyrestart( SCNG(yy_in) TSRMLS_CC );

					/* fall through */

				case EOB_ACT_END_OF_FILE:
					{
					if ( yywrap() )
						return EOF;

					if ( ! yy_did_buffer_switch_on_eof )
						YY_NEW_FILE;
#ifdef __cplusplus
					return yyinput(TSRMLS_C);
#else
					return input(TSRMLS_C);
#endif
					}

				case EOB_ACT_CONTINUE_SCAN:
					yy_c_buf_p = yytext_ptr + offset;
					break;
				}
			}
		}

	c = *(unsigned char *) yy_c_buf_p;	/* cast for 8-bit char's */
	*yy_c_buf_p = '\0';	/* preserve yytext */
	yy_hold_char = *++yy_c_buf_p;

	yy_current_buffer->yy_at_bol = (c == '\n');

	return c;
	}


#ifdef YY_USE_PROTOS
void yyrestart( FILE *input_file TSRMLS_DC )
#else
void yyrestart( input_file TSRMLS_CC )
FILE *input_file;
#endif
	{
	if ( ! yy_current_buffer )
		yy_current_buffer = yy_create_buffer( SCNG(yy_in), YY_BUF_SIZE TSRMLS_CC );

	yy_init_buffer( yy_current_buffer, input_file TSRMLS_CC );
	yy_load_buffer_state(TSRMLS_C);
	}


#ifdef YY_USE_PROTOS
void yy_switch_to_buffer( YY_BUFFER_STATE new_buffer TSRMLS_DC)
#else
void yy_switch_to_buffer( new_buffer TSRMLS_CC)
YY_BUFFER_STATE new_buffer;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	if ( yy_current_buffer == new_buffer )
		return;

	if ( yy_current_buffer )
		{
		/* Flush out information for old buffer. */
		*yy_c_buf_p = yy_hold_char;
		yy_current_buffer->yy_buf_pos = yy_c_buf_p;
		yy_current_buffer->yy_n_chars = SCNG(yy_n_chars);
		}

	yy_current_buffer = new_buffer;
	yy_load_buffer_state(TSRMLS_C);

	/* We don't actually know whether we did this switch during
	 * EOF (yywrap()) processing, but the only time this flag
	 * is looked at is after yywrap() is called, so it's safe
	 * to go ahead and always set it.
	 */
	yy_did_buffer_switch_on_eof = 1;
	}


#ifdef YY_USE_PROTOS
void yy_load_buffer_state( TSRMLS_D )
#else
void yy_load_buffer_state(TSRMLS_C)
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	SCNG(yy_n_chars) = yy_current_buffer->yy_n_chars;
	yytext_ptr = yy_c_buf_p = yy_current_buffer->yy_buf_pos;
	SCNG(yy_in) = yy_current_buffer->yy_input_file;
	yy_hold_char = *yy_c_buf_p;
	}


#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_create_buffer( FILE *file, int size TSRMLS_DC )
#else
YY_BUFFER_STATE yy_create_buffer( file, size TSRMLS_CC )
FILE *file;
int size;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	YY_BUFFER_STATE b;

	b = (YY_BUFFER_STATE) yy_flex_alloc( sizeof( struct yy_buffer_state ) );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_buf_size = size;

	/* yy_ch_buf has to be 2 characters longer than the size given because
	 * we need to put in 2 end-of-buffer characters.
	 */
	b->yy_ch_buf = (char *) yy_flex_alloc( b->yy_buf_size + 2 );
	if ( ! b->yy_ch_buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_is_our_buffer = 1;

	yy_init_buffer( b, file TSRMLS_CC );

	return b;
	}


#ifdef YY_USE_PROTOS
void yy_delete_buffer( YY_BUFFER_STATE b TSRMLS_DC )
#else
void yy_delete_buffer( b TSRMLS_CC )
YY_BUFFER_STATE b;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	if ( ! b )
		return;

	if ( b == yy_current_buffer )
		yy_current_buffer = (YY_BUFFER_STATE) 0;

	if ( b->yy_is_our_buffer )
		yy_flex_free( (void *) b->yy_ch_buf );

	yy_flex_free( (void *) b );
	}


#ifndef YY_ALWAYS_INTERACTIVE
#ifndef YY_NEVER_INTERACTIVE
extern int isatty YY_PROTO(( int ));
#endif
#endif

#ifdef YY_USE_PROTOS
void yy_init_buffer( YY_BUFFER_STATE b, FILE *file TSRMLS_DC )
#else
void yy_init_buffer( b, file TSRMLS_CC )
YY_BUFFER_STATE b;
FILE *file;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif


	{
	yy_flush_buffer( b TSRMLS_CC );

	b->yy_input_file = file;
	b->yy_fill_buffer = 1;

#if YY_ALWAYS_INTERACTIVE
	b->yy_is_interactive = 1;
#else
#if YY_NEVER_INTERACTIVE
	b->yy_is_interactive = 0;
#else
	b->yy_is_interactive = file ? (isatty( fileno(file) ) > 0) : 0;
#endif
#endif
	}


#ifdef YY_USE_PROTOS
void yy_flush_buffer( YY_BUFFER_STATE b TSRMLS_DC )
#else
void yy_flush_buffer( b TSRMLS_CC )
YY_BUFFER_STATE b;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif

	{
	if ( ! b )
		return;

	b->yy_n_chars = 0;

	/* We always need two end-of-buffer characters.  The first causes
	 * a transition to the end-of-buffer state.  The second causes
	 * a jam in that state.
	 */
	b->yy_ch_buf[0] = YY_END_OF_BUFFER_CHAR;
	b->yy_ch_buf[1] = YY_END_OF_BUFFER_CHAR;

	b->yy_buf_pos = &b->yy_ch_buf[0];

	b->yy_at_bol = 1;
	b->yy_buffer_status = YY_BUFFER_NEW;

	if ( b == yy_current_buffer )
		yy_load_buffer_state(TSRMLS_C);
	}


#ifndef YY_NO_SCAN_BUFFER
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_buffer( char *base, yy_size_t size TSRMLS_DC )
#else
YY_BUFFER_STATE yy_scan_buffer( base, size TSRMLS_CC )
char *base;
yy_size_t size;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	YY_BUFFER_STATE b;

	if ( size < 2 ||
	     base[size-2] != YY_END_OF_BUFFER_CHAR ||
	     base[size-1] != YY_END_OF_BUFFER_CHAR )
		/* They forgot to leave room for the EOB's. */
		return 0;

	b = (YY_BUFFER_STATE) yy_flex_alloc( sizeof( struct yy_buffer_state ) );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_buffer()" );

	b->yy_buf_size = size - 2;	/* "- 2" to take care of EOB's */
	b->yy_buf_pos = b->yy_ch_buf = base;
	b->yy_is_our_buffer = 0;
	b->yy_input_file = 0;
	b->yy_n_chars = b->yy_buf_size;
	b->yy_is_interactive = 0;
	b->yy_at_bol = 1;
	b->yy_fill_buffer = 0;
	b->yy_buffer_status = YY_BUFFER_NEW;

	yy_switch_to_buffer( b TSRMLS_CC );

	return b;
	}
#endif


#ifndef YY_NO_SCAN_STRING
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_string( yyconst char *yy_str TSRMLS_DC )
#else
YY_BUFFER_STATE yy_scan_string( yy_str TSRMLS_CC )
yyconst char *yy_str;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	int len;
	for ( len = 0; yy_str[len]; ++len )
		;

	return yy_scan_bytes( yy_str, len TSRMLS_CC );
	}
#endif


#ifndef YY_NO_SCAN_BYTES
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_bytes( yyconst char *bytes, int len TSRMLS_DC )
#else
YY_BUFFER_STATE yy_scan_bytes( bytes, len TSRMLS_CC )
yyconst char *bytes;
int len;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	YY_BUFFER_STATE b;
	char *buf;
	yy_size_t n;
	int i;

	/* Get memory for full buffer, including space for trailing EOB's. */
	n = len + 2;
	buf = (char *) yy_flex_alloc( n );
	if ( ! buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_bytes()" );

	for ( i = 0; i < len; ++i )
		buf[i] = bytes[i];

	buf[len] = buf[len+1] = YY_END_OF_BUFFER_CHAR;

	b = yy_scan_buffer( buf, n TSRMLS_CC);
	if ( ! b )
		YY_FATAL_ERROR( "bad buffer in yy_scan_bytes()" );

	/* It's okay to grow etc. this buffer, and we should throw it
	 * away when we're done.
	 */
	b->yy_is_our_buffer = 1;

	return b;
	}
#endif


#ifndef YY_NO_PUSH_STATE
#ifdef YY_USE_PROTOS
static void yy_push_state( int new_state TSRMLS_DC )
#else
static void yy_push_state( new_state TSRMLS_CC )
int new_state;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	if ( yy_start_stack_ptr >= yy_start_stack_depth )
		{
		yy_size_t new_size;

		yy_start_stack_depth += YY_START_STACK_INCR;
		new_size = yy_start_stack_depth * sizeof( int );

		if ( ! yy_start_stack )
			yy_start_stack = (int *) yy_flex_alloc( new_size );

		else
			yy_start_stack = (int *) yy_flex_realloc(
					(void *) yy_start_stack, new_size );

		if ( ! yy_start_stack )
			YY_FATAL_ERROR(
			"out of memory expanding start-condition stack" );
		}

	yy_start_stack[yy_start_stack_ptr++] = YY_START;

	BEGIN(new_state);
	}
#endif


#ifndef YY_NO_POP_STATE
static void yy_pop_state(TSRMLS_D)
	{
	if ( --yy_start_stack_ptr < 0 )
		YY_FATAL_ERROR( "start-condition stack underflow" );

	BEGIN(yy_start_stack[yy_start_stack_ptr]);
	}
#endif


#ifndef YY_NO_TOP_STATE
static int yy_top_state(TSRMLS_D)
	{
	return yy_start_stack[yy_start_stack_ptr - 1];
	}
#endif

#ifndef YY_EXIT_FAILURE
#define YY_EXIT_FAILURE 2
#endif

#ifdef YY_USE_PROTOS
static void yy_fatal_error( yyconst char msg[] )
#else
static void yy_fatal_error( msg )
char msg[];
#endif
	{
	(void) fprintf( stderr, "%s\n", msg );
	exit( YY_EXIT_FAILURE );
	}



/* Redefine yyless() so it works in section 3 code. */

#undef yyless
#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
		yytext[yyleng] = yy_hold_char; \
		yy_c_buf_p = yytext + n; \
		yy_hold_char = *yy_c_buf_p; \
		*yy_c_buf_p = '\0'; \
		yyleng = n; \
		} \
	while ( 0 )


/* Internal utility routines. */

#ifndef yytext_ptr
#ifdef YY_USE_PROTOS
static void yy_flex_strncpy( char *s1, yyconst char *s2, int n )
#else
static void yy_flex_strncpy( s1, s2, n )
char *s1;
yyconst char *s2;
int n;
#endif
	{
	register int i;
	for ( i = 0; i < n; ++i )
		s1[i] = s2[i];
	}
#endif

#ifdef YY_NEED_STRLEN
#ifdef YY_USE_PROTOS
static int yy_flex_strlen( yyconst char *s )
#else
static int yy_flex_strlen( s )
yyconst char *s;
#endif
	{
	register int n;
	for ( n = 0; s[n]; ++n )
		;

	return n;
	}
#endif


#ifdef YY_USE_PROTOS
static void *yy_flex_alloc( yy_size_t size )
#else
static void *yy_flex_alloc( size )
yy_size_t size;
#endif
	{
	return (void *) malloc( size );
	}

#ifdef YY_USE_PROTOS
static void *yy_flex_realloc( void *ptr, yy_size_t size )
#else
static void *yy_flex_realloc( ptr, size )
void *ptr;
yy_size_t size;
#endif
	{
	/* The cast to (char *) in the following accommodates both
	 * implementations that use char* generic pointers, and those
	 * that use void* generic pointers.  It works with the latter
	 * because both ANSI C and C++ allow castless assignment from
	 * any pointer type to void*, and deal with argument conversions
	 * as though doing an assignment.
	 */
	return (void *) realloc( (char *) ptr, size );
	}

#ifdef YY_USE_PROTOS
static void yy_flex_free( void *ptr )
#else
static void yy_flex_free( ptr )
void *ptr;
#endif
	{
	free( ptr );
	}

#if YY_MAIN
int main()
	{
	yylex();
	return 0;
	}
#endif
