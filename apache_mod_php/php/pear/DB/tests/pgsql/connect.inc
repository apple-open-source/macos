<?php
require_once "DB.php";
$dbh = DB::connect("pgsql://unix+localhost/test");
?>
