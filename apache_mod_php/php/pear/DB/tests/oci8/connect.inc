<?php
require_once "DB.php";
$dbh = DB::connect("oci8://system:manager@test");
?>
