<?php
require_once "DB.php";
$dbh = DB::connect("ibase://localhost/test.gdb");
?>
