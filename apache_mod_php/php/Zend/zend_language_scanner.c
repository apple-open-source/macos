#define yy_create_buffer zend_create_buffer
#define yy_delete_buffer zend_delete_buffer
#define yy_scan_buffer zend_scan_buffer
#define yy_scan_string zend_scan_string
#define yy_scan_bytes zend_scan_bytes
#define yy_flex_debug zend_flex_debug
#define yy_init_buffer zend_init_buffer
#define yy_flush_buffer zend_flush_buffer
#define yy_load_buffer_state zend_load_buffer_state
#define yy_switch_to_buffer zend_switch_to_buffer
#define yyin zendin
#define yyleng zendleng
#define yylex zendlex
#define yyout zendout
#define yyrestart zendrestart
#define yytext zendtext

/* A Lexical scanner generated by flex */

/* Scanner skeleton version:
 * $Header: /repository/Zend/Attic/flex.skl,v 1.27.4.4 2003/05/31 01:37:43 sniper Exp $
 */

#define FLEX_SCANNER
#define YY_FLEX_MAJOR_VERSION 2
#define YY_FLEX_MINOR_VERSION 5


/* for HAVE_* */
#include "zend.h"

/* for recv */
#ifdef HAVE_SYS_TYPES_H
# include <sys/types.h>
#endif
#ifdef HAVE_SYS_SOCKET_H
# include <sys/socket.h> 
#endif

/* for read */
#ifdef HAVE_UNISTD_H
# include <unistd.h>
#endif
#include <stdio.h>


/* cfront 1.2 defines "c_plusplus" instead of "__cplusplus" */
#ifdef c_plusplus
#ifndef __cplusplus
#define __cplusplus
#endif
#endif


#ifdef __cplusplus

#include <stdlib.h>
#if HAVE_UNISTD_H
#include <unistd.h>
#endif

/* Use prototypes in function declarations. */
#define YY_USE_PROTOS

/* The "const" storage-class-modifier is valid. */
#define YY_USE_CONST

#else	/* ! __cplusplus */

#if __STDC__

#define YY_USE_PROTOS
#define YY_USE_CONST

#endif	/* __STDC__ */
#endif	/* ! __cplusplus */

#ifdef __TURBOC__
 #pragma warn -rch
 #pragma warn -use
#include <io.h>
#include <stdlib.h>
#define YY_USE_CONST
#define YY_USE_PROTOS
#endif

#ifdef YY_USE_CONST
#define yyconst const
#else
#define yyconst
#endif

#undef YY_USE_PROTOS
#define YY_USE_PROTOS

#ifdef YY_USE_PROTOS
#define YY_PROTO(proto) proto
#else
#define YY_PROTO(proto) ()
#endif

/* Returned upon end-of-file. */
#define YY_NULL 0

/* Promotes a possibly negative, possibly signed char to an unsigned
 * integer for use as an array index.  If the signed char is negative,
 * we want to instead treat it as an 8-bit unsigned char, hence the
 * double cast.
 */
#define YY_SC_TO_UI(c) ((unsigned int) (unsigned char) c)

/* Enter a start condition.  This macro really ought to take a parameter,
 * but we do it the disgusting crufty way forced on us by the ()-less
 * definition of BEGIN.
 */
#define BEGIN yy_start = 1 + 2 *

/* Translate the current start state into a value that can be later handed
 * to BEGIN to return to the state.  The YYSTATE alias is for lex
 * compatibility.
 */
#define YY_START ((yy_start - 1) / 2)
#define YYSTATE YY_START

/* Action number for EOF rule of a given start state. */
#define YY_STATE_EOF(state) (YY_END_OF_BUFFER + state + 1)

/* Special action meaning "start processing a new file". */
#define YY_NEW_FILE yyrestart( SCNG(yy_in) TSRMLS_CC )

#define YY_END_OF_BUFFER_CHAR 0

/* Size of default input buffer. */
#define YY_BUF_SIZE 16384

typedef struct yy_buffer_state *YY_BUFFER_STATE;

extern int yyleng;


#define EOB_ACT_CONTINUE_SCAN 0
#define EOB_ACT_END_OF_FILE 1
#define EOB_ACT_LAST_MATCH 2

/* The funky do-while in the following #define is used to turn the definition
 * int a single C statement (which needs a semi-colon terminator).  This
 * avoids problems with code like:
 *
 * 	if ( condition_holds )
 *		yyless( 5 );
 *	else
 *		do_something_else();
 *
 * Prior to using the do-while the compiler would get upset at the
 * "else" because it interpreted the "if" statement as being all
 * done when it reached the ';' after the yyless() call.
 */

/* Return all but the first 'n' matched characters back to the input stream. */

#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
		*yy_cp = yy_hold_char; \
		yy_c_buf_p = yy_cp = yy_bp + n - YY_MORE_ADJ; \
		YY_DO_BEFORE_ACTION; /* set up yytext again */ \
		} \
	while ( 0 )

#define unput(c) yyunput( c, yytext_ptr TSRMLS_CC )

/* The following is because we cannot portably get our hands on size_t
 * (without autoconf's help, which isn't available because we want
 * flex-generated scanners to compile on their own).
 */
typedef unsigned int yy_size_t;


struct yy_buffer_state
	{
	struct _zend_file_handle *yy_input_file;

	char *yy_ch_buf;		/* input buffer */
	char *yy_buf_pos;		/* current position in input buffer */

	/* Size of input buffer in bytes, not including room for EOB
	 * characters.
	 */
	yy_size_t yy_buf_size;

	/* Number of characters read into yy_ch_buf, not including EOB
	 * characters.
	 */
	int yy_n_chars;

	/* Whether we "own" the buffer - i.e., we know we created it,
	 * and can realloc() it to grow it, and should free() it to
	 * delete it.
	 */
	int yy_is_our_buffer;

	/* Whether we're considered to be at the beginning of a line.
	 * If so, '^' rules will be active on the next match, otherwise
	 * not.
	 */
	int yy_at_bol;

	/* Whether to try to fill the input buffer when we reach the
	 * end of it.
	 */
	int yy_fill_buffer;

	int yy_buffer_status;
#define YY_BUFFER_NEW 0
#define YY_BUFFER_NORMAL 1
	/* When an EOF's been seen but there's still some text to process
	 * then we mark the buffer as YY_EOF_PENDING, to indicate that we
	 * shouldn't try reading from the input source any more.  We might
	 * still have a bunch of tokens to match, though, because of
	 * possible backing-up.
	 *
	 * When we actually see the EOF, we change the status to "new"
	 * (via yyrestart()), so that the user can continue scanning by
	 * just pointing yyin at a new input file.
	 */
#define YY_BUFFER_EOF_PENDING 2
	};

#define yy_current_buffer SCNG(current_buffer)
#define yy_hold_char SCNG(_yy_hold_char)

/* We provide macros for accessing buffer states in case in the
 * future we want to put the buffer states in a more general
 * "scanner state".
 */
#define YY_CURRENT_BUFFER yy_current_buffer


/* yy_hold_char holds the character lost when yytext is formed. */

#if 0
static char yy_hold_char;

static int yy_n_chars;		/* number of characters read into yy_ch_buf */
#endif

/* Points to current character in buffer. */
#define yy_c_buf_p SCNG(c_buf_p)
#define yy_init SCNG(init)
#define yy_start SCNG(start)

/* Flag which is used to allow yywrap()'s to do buffer switches
 * instead of setting up a fresh yyin.  A bit of a hack ...
 */
/* static int yy_did_buffer_switch_on_eof; */
#define yy_did_buffer_switch_on_eof SCNG(_yy_did_buffer_switch_on_eof)

void yyrestart YY_PROTO(( struct _zend_file_handle  *input_file TSRMLS_DC ));

void yy_switch_to_buffer YY_PROTO(( YY_BUFFER_STATE new_buffer TSRMLS_DC ));
void yy_load_buffer_state YY_PROTO(( TSRMLS_D ));
YY_BUFFER_STATE yy_create_buffer YY_PROTO(( struct _zend_file_handle *file, int size TSRMLS_DC ));
void yy_delete_buffer YY_PROTO(( YY_BUFFER_STATE b TSRMLS_DC ));
void yy_init_buffer YY_PROTO(( YY_BUFFER_STATE b, struct _zend_file_handle *file TSRMLS_DC ));
void yy_flush_buffer YY_PROTO(( YY_BUFFER_STATE b TSRMLS_DC ));
#define YY_FLUSH_BUFFER yy_flush_buffer( yy_current_buffer TSRMLS_CC )

YY_BUFFER_STATE yy_scan_buffer YY_PROTO(( char *base, yy_size_t size TSRMLS_DC ));
YY_BUFFER_STATE yy_scan_string YY_PROTO(( yyconst char *yy_str TSRMLS_DC ));
YY_BUFFER_STATE yy_scan_bytes YY_PROTO(( yyconst char *bytes, int len TSRMLS_DC ));


static void *yy_flex_alloc YY_PROTO(( yy_size_t ));
static void *yy_flex_realloc YY_PROTO(( void *, yy_size_t ));
static void yy_flex_free YY_PROTO(( void * ));

#define yy_new_buffer yy_create_buffer

#define yy_set_interactive(is_interactive) \
	{ \
	if ( ! yy_current_buffer ) \
		yy_current_buffer = yy_create_buffer( SCNG(yy_in), YY_BUF_SIZE TSRMLS_CC ); \
	}

#define yy_set_bol(at_bol) \
	{ \
	if ( ! yy_current_buffer ) \
		yy_current_buffer = yy_create_buffer( SCNG(yy_in), YY_BUF_SIZE TSRMLS_CC ); \
	yy_current_buffer->yy_at_bol = at_bol; \
	}

#define YY_AT_BOL() (yy_current_buffer->yy_at_bol)


#define yywrap() 1
#define YY_SKIP_YYWRAP
typedef unsigned char YY_CHAR;
FILE *yyin = (FILE *) 0, *yyout = (FILE *) 0;
typedef int yy_state_type;
extern char *yytext;
#define yytext_ptr yytext
#undef yyleng
#define yyleng SCNG(yy_leng)
#undef yytext
#define yytext SCNG(yy_text)
#undef yytext_ptr
#define yytext_ptr SCNG(yy_text)
#undef yyin
#define yyin SCNG(yy_in)
#undef yyout
#define yyout SCNG(yy_out)
#undef yy_last_accepting_state
#define yy_last_accepting_state SCNG(_yy_last_accepting_state)
#undef yy_last_accepting_cpos
#define yy_last_accepting_cpos SCNG(_yy_last_accepting_cpos)
#undef yy_more_flag
#define yy_more_flag SCNG(_yy_more_flag)
#undef yy_more_len
#define yy_more_len SCNG(_yy_more_len)


static yy_state_type yy_get_previous_state YY_PROTO(( TSRMLS_D ));
static yy_state_type yy_try_NUL_trans YY_PROTO(( yy_state_type current_state TSRMLS_DC ));
static int yy_get_next_buffer YY_PROTO(( TSRMLS_D ));
static void yy_fatal_error YY_PROTO(( yyconst char msg[] ));

/* Done after the current pattern has been matched and before the
 * corresponding action - sets up yytext.
 */
#define YY_DO_BEFORE_ACTION \
	yytext_ptr = yy_bp; \
	yytext_ptr -= yy_more_len; \
	yyleng = (int) (yy_cp - yytext_ptr); \
	yy_hold_char = *yy_cp; \
	*yy_cp = '\0'; \
	yy_c_buf_p = yy_cp;

#undef yyleng
#undef yytext
#undef yytext_ptr
#undef yyin
#undef yyout
#undef yy_last_accepting_state
#undef yy_last_accepting_cpos
#undef yy_more_flag
#undef yy_more_len


#define YY_NUM_RULES 145
#define YY_END_OF_BUFFER 146
static yyconst short int yy_accept[1351] =
    {   0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
      146,   98,   98,  144,  107,   84,  121,  108,   84,   84,
       84,  124,   84,   84,   84,   84,   84,   84,   84,   90,
       90,   84,   84,   84,   84,   84,   84,  105,  123,  105,
      105,  105,  105,  105,  105,  105,  105,  105,  105,  105,
      105,  105,  105,  105,  105,  105,  105,  105,   85,   84,
       87,  126,  141,  131,  126,   92,   92,  131,  144,  106,
      128,  131,  127,  143,  144,  129,  144,  142,  140,  126,
      144,  106,   33,   32,   89,   88,  114,  116,  110,  111,

      111,  109,  109,  109,   98,    0,   98,  101,   99,   98,
      107,   63,    0,  119,    0,  104,   71,  118,   78,   74,
        0,  120,    0,    0,    0,    0,    0,    0,    0,    0,
        0,    0,    0,   68,   58,   66,   59,   67,   31,   93,
       70,  113,  108,   69,   93,   90,    0,    0,   34,    0,
       82,   64,   63,   62,   55,   65,   83,  117,   76,  105,
      105,  105,  105,   20,  105,  105,  105,  105,  105,  105,
      105,   13,  105,  105,  105,  105,  105,  105,  105,  105,
      105,    7,  105,  105,  105,  105,  105,   79,  105,  105,
      105,  105,  105,  105,  105,  105,  105,   75,   77,  126,

      130,   86,   31,   92,    0,  139,  135,  137,  139,  106,
      128,  132,  127,    0,  133,  134,  129,  136,  140,  126,
      125,  125,  106,    0,   32,   88,  114,  115,  110,  111,
      112,   98,    0,  100,    0,    0,   61,  104,  118,  118,
        0,    0,    0,    0,    0,    0,    0,    0,    0,   93,
        0,   93,   91,    0,    0,   72,   60,   73,  117,  117,
      105,  105,  105,   80,  105,  105,  105,  105,  105,  105,
      105,  105,    2,  105,  105,  105,  105,  105,  105,  105,
       14,  105,  105,  105,  105,  105,   35,  105,  105,  105,
      105,  105,  105,  105,   49,   36,  105,   81,   92,  137,

      138,   98,    0,    0,    0,    0,    0,    0,    0,    0,
        0,    0,    0,    0,    0,    0,    0,  105,  105,  105,
      105,  105,  105,   23,  105,  105,  105,  105,  105,  105,
       27,   10,  105,  105,  105,  105,  105,  105,   44,    1,
      105,  105,  105,  105,  105,  105,   56,  105,  105,  105,
      105,  105,  105,  105,  105,  137,  138,   98,    0,    0,
        0,    0,    0,    0,    0,    0,   37,    0,    0,    0,
        0,    0,    0,  122,  122,    0,  105,  105,  105,  105,
       57,   25,  105,   29,    5,  105,  105,  105,  105,   52,
      105,  105,    9,  105,  105,  105,  105,  105,  105,  105,

       51,  105,   28,  105,  105,  105,  105,   54,   11,   98,
        0,  102,  102,    0,    0,    0,    0,   42,    0,    0,
        0,    0,    0,   38,    0,    0,    0,  105,  105,  105,
      105,  105,  105,  105,  105,    8,  105,   15,  105,  105,
      105,  105,  105,   50,  105,  105,  105,    6,   53,   21,
       98,    0,    0,    0,    0,   40,    0,    0,    0,    0,
        0,   43,    0,  105,  105,  105,  105,  105,  105,   18,
       24,  105,  105,  105,  105,   30,   16,  105,   45,  105,
       47,   98,    0,    0,    0,    0,    0,    0,   41,    0,
       39,    0,  105,   97,  105,   96,  105,   26,  105,  105,

      105,   12,    4,  105,  105,  105,   98,    0,    0,    0,
        0,   94,  105,  105,  105,   22,  105,  105,  105,   98,
        0,    0,    0,  105,   19,   17,  105,  105,  105,   98,
        0,    0,    0,  105,  105,  105,  105,   98,    0,    0,
        0,   95,   46,    3,   48,   98,    0,    0,    0,   98,
        0,    0,    0,   98,    0,    0,    0,   98,    0,    0,
        0,   98,    0,    0,    0,    0,   98,    0,  103,    0,
        0,    0,    0,   98,    0,  103,  103,    0,    0,    0,
       98,    0,    0,    0,    0,   98,    0,    0,    0,    0,
       99,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,

        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,   98,
        0,   98,    0,   98,    0,   98,    0,   98,    0,    0
    } ;

static yyconst int yy_ec[256] =
    {   0,
        1,    1,    1,    1,    1,    1,    1,    1,    2,    3,
        1,    1,    4,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    2,    5,    6,    7,    8,    9,   10,   11,   12,
       13,   14,   15,   16,   17,   18,   19,   20,   21,   21,
       21,   21,   21,   21,   21,   22,   22,   23,   24,   25,
       26,   27,   28,   16,   34,   35,   36,   37,   38,   39,
       40,   41,   42,   43,   44,   45,   46,   47,   48,   49,
       50,   51,   52,   53,   54,   55,   56,   57,   58,   59,
       29,   30,   29,   31,   32,   33,   34,   35,   36,   37,

       38,   39,   40,   41,   42,   43,   44,   45,   46,   47,
       48,   49,   50,   51,   52,   53,   54,   55,   56,   57,
       58,   59,   60,   61,   62,   16,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,

       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59,   59,   59,   59,   59,   59,
       59,   59,   59,   59,   59
    } ;

static yyconst int yy_meta[63] =
    {   0,
        1,    2,    3,    3,    4,    1,    4,    5,    6,    4,
        7,    4,    4,    8,    4,    4,    4,    4,    4,    9,
        9,    9,    4,   10,   11,    4,    6,    6,    1,    1,
        4,   12,    1,   12,   12,   12,   12,   12,   12,   12,
       12,   12,   12,   12,   12,   12,   12,   12,   12,   12,
       12,   12,   12,   12,   12,   12,   12,   12,   12,    1,
        4,    1
    } ;

static yyconst short int yy_base[1771] =
    {   0,
     7910, 7909,    0,    0,   62,    0,  114,  115,  121,  122,
      123,  151,  210,    0,  272,    0, 7919, 7918,  132,  139,
     7931, 7905,  121, 7936,  129, 7903,  131, 7936,    0,  112,
      137,  135,  333, 7936, 7902,  143,  151,  150,  322,  322,
      331, 7904,  320,  148,  153, 7899, 7899, 7892, 7936,  303,
     7872,  332,  340,  347,  308, 7877,    0,  351, 7879, 7882,
      312, 7868, 7880,  305,  312, 7883, 7875, 7867, 7936,  312,
     7936,    0, 7936,  404, 7887,  447,  375, 7936,  464,    0,
     7880, 7904, 7881, 7936,  460, 7904,  453, 7936,  466,  469,
      458,  479, 7936,    0, 7936,    0,    0, 7890,    0, 7936,

     7905, 7880, 7936, 7879, 7880,  467, 7879, 7877,  350, 7866,
      485, 7875,  134, 7936,  383,    0, 7936,  397, 7936, 7936,
      470, 7936, 7897,    0, 7848, 7850, 7849, 7851, 7848, 7859,
     7855, 7839, 7844, 7936, 7936, 7936, 7936, 7936, 7936,  476,
     7936, 7936, 7936, 7936,  485,  491,  505,  496, 7936, 7838,
      468, 7936, 7936, 7863, 7936, 7936, 7862,  533, 7936,    0,
      502, 7850, 7835,    0, 7847, 7832, 7829, 7848, 7834,  503,
     7842,    0, 7838, 7826, 7828, 7839, 7841,  498, 7823, 7826,
     7824,    0, 7835, 7818, 7817, 7812, 7830,    0, 7824,  493,
     7831, 7822, 7811, 7824, 7810, 7818, 7808, 7936, 7936,    0,

     7936, 7936,    0,  528,  532, 7936, 7936,  524,  538,    0,
     7825, 7936, 7827, 7826, 7936, 7936, 7849, 7936,  550,  551,
     7936, 7851,  561,  575,    0,    0,    0, 7936,    0, 7936,
     7936, 7828,  571, 7936, 7811, 7800, 7936,    0, 7936, 7847,
     7798, 7800, 7793, 7798, 7792, 7801, 7809, 7791, 7789,  566,
      569,  572,  580, 7804, 7837, 7936, 7936, 7936, 7936, 7835,
     7792,  553, 7794,    0, 7801, 7800, 7795, 7785, 7779,  529,
     7785, 7795,    0, 7780, 7789, 7773,  569, 7780, 7771, 7785,
     7784, 7785, 7785, 7774, 7780, 7764,    0, 7784, 7768, 7760,
     7759, 7759, 7758, 7772,    0,    0, 7764,    0,  606,  577,

      612, 7783,  611, 7758, 7764, 7771, 7759, 7768, 7768,  622,
     7763, 7755, 7757, 7760, 3005, 3053,  606, 3019, 3007, 3004,
     3003, 2991, 2990,    0, 2997, 2980, 2978, 2988, 2995, 2974,
        0, 2985, 2968, 2973, 2962, 2951, 2931, 2939,    0,    0,
     2924, 2936, 2914, 2932, 2909, 2907,    0, 2920, 2905, 2915,
     2905, 2907, 2905, 2887, 2886, 7936, 7936, 2895,  628,  627,
     2866, 2856,  652, 2848, 2834,  653, 7936, 2775, 2777,  655,
     2765, 2758, 2766, 7936, 2804,  609, 2754, 2767, 2767, 2764,
        0,    0, 2748,    0,    0, 2753, 2747, 2752, 2757,    0,
     2759, 2743,    0, 2751, 2749, 2751, 2748, 2736, 2731, 2728,

        0, 2709,    0, 2711, 2713, 2722, 2712,    0,    0, 2726,
      649, 7936, 2746, 2695, 2677,  659,  660, 7936, 2689, 2682,
     2681, 2665,  662, 7936, 2677,  665, 2665, 2661, 2676, 2650,
     2660, 2641, 2626, 2640, 2624,    0, 2629, 2635, 2610, 2615,
     2605, 2602, 2592,    0, 2600, 2590, 2596,    0,    0,    0,
     2600,  660, 2572,  679,  674, 7936, 2575, 2569,  682,  684,
      687, 7936, 2550, 2568, 2565, 2552, 2558, 2539, 2547,    0,
        0, 2549, 2546, 2532, 2519,    0,    0, 2508, 2522, 2516,
     2518, 2520,  682, 2509,  690,  696,  700,  701, 7936,  702,
     7936,  714, 2509,    0, 2492,    0, 2475,    0, 2464, 2476,

     2470,    0,    0, 2462, 2456, 2458, 2480,  696, 2464, 2461,
      723,    0, 2437, 2437, 2431,    0, 2423, 2427, 2419, 2440,
      711, 2411, 2405, 2417,    0,    0, 2399, 2384, 2394, 2404,
      719, 2394, 2377, 2383, 2376, 2365, 2357, 2367,  721, 2334,
     2332,    0,    0,    0,    0, 2357,  728, 2345, 2343, 2350,
      729, 2321, 2320, 2324,  733, 2295, 2308, 2319,  734, 2314,
      729, 2312,  742, 2308,  762,  772, 2308,  759,  667,  787,
     2283, 2265, 2266, 2279,  787, 7936, 2300, 2261, 2260, 2249,
     2272,  788, 2243, 2238,  797, 2251,  794, 2261, 2253,  802,
     7936, 2237,  798, 2236,  800, 2233,  805, 2232,  809, 2222,

      823, 2219,  834, 2216,  835, 2202,  840, 2199,  844, 2197,
      845, 2196,  846, 2193,  855, 2184,  857, 2182,  875, 2181,
      880, 2179,  885, 2162,  886, 2159,  890, 2156,  892, 2153,
      897, 2149,  903, 2146,  915, 2144,  920, 2142,  925, 2139,
      926, 2127,  932, 2116,  937, 2114,  938, 2113,  943, 2111,
      955, 2109,  960, 2104,  966, 2102,  972, 2100,  973, 2099,
      977, 2081,  978, 2074,  983, 2071,  995, 2070, 1006, 2069,
     1008, 2068, 1012, 2065, 1013, 2064, 1017, 2059, 1018, 2054,
     1023, 2043, 1043, 2034, 1048, 2031, 1052, 2029, 1053, 2028,
     1054, 2025, 1058, 2024, 1063, 2014, 1065, 2011, 1083, 2008,

     1088, 1994, 1093, 1991, 1094, 1989, 1098, 1988, 1100, 1985,
     1105, 1976, 1111, 1974, 1123, 1973, 1128, 1971, 1133, 1954,
     1134, 1951, 1140, 1948, 1145, 1945, 1146, 1941, 1151, 1938,
     1163, 1936, 1168, 1934, 1174, 1931, 1180, 1919, 1181, 1908,
     1185, 1906, 1186, 1905, 1191, 1903, 1203, 1901, 1214, 1896,
     1216, 1894, 1220, 1892, 1221, 1891, 1225, 1873, 1226, 1866,
     1231, 1863, 1251, 1862, 1256, 1861, 1260, 1860, 1261, 1857,
     1262, 1856, 1266, 1851, 1271, 1846, 1273, 1835, 1291, 1826,
     1296, 1823, 1301, 1821, 1302, 1820, 1306, 1817, 1308, 1816,
     1313, 1806, 1319, 1803, 1331, 1800, 1336, 1786, 1341, 1783,

     1342, 1781, 1348, 1780, 1353, 1777, 1354, 1768, 1359, 1766,
     1371, 1765, 1376, 1763, 1382, 1746, 1388, 1743, 1389, 1740,
     1393, 1737, 1394, 1733, 1399, 1730, 1411, 1728, 1422, 1726,
     1424, 1723, 1428, 1711, 1429, 1700, 1433, 1698, 1434, 1697,
     1439, 1695, 1459, 1693, 1464, 1688, 1468, 1686, 1469, 1684,
     1470, 1683, 1474, 1665, 1479, 1658, 1481, 1655, 1499, 1654,
     1504, 1653, 1509, 1652, 1510, 1649, 1514, 1648, 1516, 1643,
     1521, 1638, 1527, 1627, 1539, 1618, 1544, 1615, 1549, 1613,
     1550, 1612, 1556, 1609, 1561, 1608, 1562, 1598, 1567, 1595,
     1579, 1592, 1584, 1578, 1590, 1575, 1596, 1573, 1597, 1572,

     1601, 1569, 1602, 1560, 1607, 1558, 1619, 1557, 1630, 1555,
     1632, 1538, 1636, 1535, 1637, 1532, 1641, 1529, 1642, 1525,
     1647, 1522, 1667, 1520, 1672, 1518, 1676, 1515, 1677, 1503,
     1678, 1492, 1682, 1490, 1687, 1489, 1689, 1487, 1707, 1485,
     1712, 1480, 1717, 1478, 1718, 1476, 1722, 1475, 1724, 1457,
     1729,  125, 1735,  157, 1747,  312, 1752,  340, 1757,  349,
     1758,  364, 1764,  466, 1769,  476, 1770,  483, 1775,  499,
     1787,  503, 1792,  530, 1798,  538, 1804,  578, 1805,  580,
     1809,  597, 1810,  613, 1815,  627, 1827,  654, 1838,  671,
     1840,  674, 1844,  681, 1845,  683, 1849,  686, 1850,  694,

     1855,  697, 1875,  698, 1880,  704, 1884,  715, 1885,  720,
     1886,  727, 1890,  735, 1895,  744, 1897,  747, 1915,  752,
     1920,  754, 1925,  757, 1926,  767, 1930,  770, 1932,  777,
     1937,  783, 1943,  785, 1955,  792, 1960,  795, 1965,  802,
     1966,  806, 1972,  810, 1977,  813, 1978,  816, 1983,  817,
     1995,  820, 2000,  822, 2006,  831, 2012,  833, 2013,  842,
     2017,  851, 2018,  852, 2023,  853, 2035,  854, 2046,  856,
     2048,  863, 2052,  865, 2053,  866, 2057,  868, 2058,  877,
     2063,  879, 2083,  891, 2088,  894, 2092,  896, 2093,  898,
     2094,  901, 2098,  905, 2103,  908, 2105,  911, 2123,  914,

     2128,  931, 2133,  933, 2134,  934, 2138,  936, 2140,  945,
     2145,  948, 2151,  949, 2163,  951, 2168,  954, 2173,  968,
     2174,  971, 2180,  974, 2185,  984, 2186,  985, 2191,  988,
     2203,  989, 2208,  991, 2214,  994, 2220, 1003, 2221, 1014,
     2225, 1019, 2226, 1024, 2231, 1025, 2243, 1028, 2254, 1029,
     2256, 1030, 2260, 1031, 2261, 1034, 2265, 1041, 2266, 1059,
     2271, 1060, 2291, 1062, 2296, 1064, 2300, 1069, 2301, 1071,
     2302, 1073, 2306, 1074, 2311, 1076, 2313, 1087, 2331, 1099,
     2336, 1102, 2341, 1104, 2342, 1106, 2346, 1109, 2348, 1113,
     2353, 1116, 2359, 1119, 2371, 1122, 2376, 1139, 2381, 1141,

     2382, 1142, 2388, 1144, 2393, 1153, 2394, 1156, 2399, 1157,
     2411, 1159, 2416, 1162, 2422, 1176, 2428, 1179, 2429, 1182,
     2433, 1192, 2434, 1193, 2439, 1196, 2451, 1197, 2462, 1199,
     2464, 1202, 2468, 1211, 2469, 1222, 2473, 1227, 2474, 1232,
     2479, 1233, 2499, 1236, 2504, 1237, 2508, 1238, 2509, 1239,
     2510, 1242, 2514, 1249, 2519, 1267, 2521, 1268, 2539, 1270,
     2544, 1272, 2549, 1277, 2550, 1279, 2554, 1281, 2556, 1282,
     2561, 1284, 2567, 1295, 2579, 1307, 2584, 1310, 2589, 1312,
     2590, 1314, 2596, 1317, 2601, 1321, 2602, 1324, 2607, 1327,
     2619, 1330, 2624, 1347, 2630, 1349, 2636, 1350, 2637, 1352,

     2641, 1361, 2642, 1364, 2647, 1365, 2659, 1367, 2670, 1370,
     2672, 1384, 2676, 1387, 2677, 1390, 2681, 1400, 2682, 1401,
     2687, 1404, 2707, 1405, 2712, 1407, 2716, 1410, 2717, 1419,
     2718, 1430, 2722, 1435, 2727, 1440, 2729, 1441, 2747, 1444,
     2752, 1445, 2757, 1446, 2758, 1447, 2762, 7936, 2764, 7936,
     2816, 2828, 2840, 2852, 2864, 2876, 2888, 1463, 2900, 2904,
     2915, 2926, 2930, 2942, 2952, 2956, 2960, 2972, 2984, 2996,
     3000, 3012, 3023, 3035, 3045, 3057, 3069, 3081, 3093, 3105,
     3117, 3129, 3141, 3153, 3165, 3177, 3189, 3201, 3213, 3225,
     3237, 3249, 3261, 3273, 3285, 3297, 3309, 3321, 3333, 3345,

     3357, 3369, 3381, 3393, 3405, 3417, 3429, 3441, 3453, 3465,
     3477, 3489, 3501, 3513, 3525, 3537, 3549, 3561, 3573, 3585,
     3597, 3609, 3621, 3633, 3645, 3657, 3669, 3681, 3693, 3705,
     3717, 3729, 3741, 3753, 3765, 3777, 3789, 3801, 3813, 3825,
     3837, 3849, 3861, 3873, 3885, 3897, 3909, 3921, 3933, 3945,
     3957, 3969, 3981, 3993, 4005, 4017, 4029, 4041, 4053, 4065,
     4077, 4089, 4101, 4113, 4125, 4137, 4149, 4161, 4173, 4185,
     4197, 4209, 4221, 4233, 4245, 4257, 4269, 4281, 4293, 4305,
     4317, 4329, 4341, 4353, 4365, 4377, 4389, 4401, 4413, 4425,
     4437, 4449, 4461, 4473, 4485, 4497, 4509, 4521, 4533, 4545,

     4557, 4569, 4581, 4593, 4605, 4617, 4629, 4641, 4653, 4665,
     4677, 4689, 4701, 4713, 4725, 4737, 4749, 4761, 4773, 4785,
     4797, 4809, 4821, 4833, 4845, 4857, 4869, 4881, 4893, 4905,
     4917, 4929, 4941, 4953, 4965, 4977, 4989, 5001, 5013, 5025,
     5037, 5049, 5061, 5073, 5085, 5097, 5109, 5121, 5133, 5145,
     5157, 5169, 5181, 5193, 5205, 5217, 5229, 5241, 5253, 5265,
     5277, 5289, 5301, 5313, 5325, 5337, 5349, 5361, 5373, 5385,
     5397, 5409, 5421, 5433, 5445, 5457, 5469, 5481, 5493, 5505,
     5517, 5529, 5541, 5553, 5565, 5577, 5589, 5601, 5613, 5625,
     5637, 5649, 5661, 5673, 5685, 5697, 5709, 5721, 5733, 5745,

     5757, 5769, 5781, 5793, 5805, 5817, 5829, 5841, 5853, 5865,
     5877, 5889, 5901, 5913, 5925, 5937, 5949, 5961, 5973, 5985,
     5997, 6009, 6021, 6033, 6045, 6057, 6069, 6081, 6093, 6105,
     6117, 6129, 6141, 6153, 6165, 6177, 6189, 6201, 6213, 6225,
     6237, 6249, 6261, 6273, 6285, 6297, 6309, 6321, 6333, 6345,
     6357, 6369, 6381, 6393, 6405, 6417, 6429, 6441, 6453, 6465,
     6477, 6489, 6501, 6513, 6525, 6537, 6549, 6561, 6573, 6585,
     6597, 6609, 6621, 6633, 6645, 6657, 6669, 6681, 6693, 6705,
     6717, 6729, 6741, 6753, 6765, 6777, 6789, 6801, 6813, 6825,
     6837, 6849, 6861, 6873, 6885, 6897, 6909, 6921, 6933, 6945,

     6957, 6969, 6981, 6993, 7005, 7017, 7029, 7041, 7053, 7065,
     7077, 7089, 7101, 7113, 7125, 7137, 7149, 7161, 7173, 7185,
     7197, 7209, 7221, 7233, 7245, 7257, 7269, 7281, 7293, 7305,
     7317, 7329, 7341, 7353, 7365, 7377, 7389, 7401, 7413, 7425,
     7437, 7449, 7461, 7473, 7485, 7497, 7509, 7521, 7533, 7545,
     7557, 7569, 7581, 7593, 7605, 7617, 7629, 7641, 7653, 7665,
     7677, 7689, 7701, 7713, 7725, 7737, 7749, 7761, 7773, 7785
    } ;

static yyconst short int yy_def[1771] =
    {   0,
     1351, 1351, 1350,    3, 1350,    5, 1352, 1352,    5,    5,
        5,    5, 1350,   13, 1350,   15, 1353, 1353, 1354, 1354,
     1350, 1355, 1356, 1350, 1350, 1350, 1357, 1350, 1358, 1350,
     1350, 1359, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1360, 1350, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1350, 1350,
     1350, 1361, 1350, 1350, 1361, 1350, 1350, 1350, 1362, 1363,
     1350, 1350, 1364, 1350, 1364, 1350, 1362, 1350, 1350, 1361,
     1362, 1365, 1350, 1366, 1350, 1367, 1368, 1350, 1369, 1350,

     1350, 1350, 1350, 1350, 1370, 1355, 1355, 1350, 1350, 1350,
     1350, 1350, 1357, 1350, 1357, 1371, 1350, 1350, 1350, 1350,
     1359, 1350, 1359,   33, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1350, 1350, 1361,

     1350, 1350, 1361, 1350, 1350, 1350, 1350, 1350, 1350, 1363,
     1350, 1350, 1364, 1364, 1350, 1350, 1350, 1350, 1350, 1361,
     1350, 1350, 1365, 1350, 1366, 1367, 1368, 1350, 1369, 1350,
     1350, 1372, 1370, 1350, 1350, 1350, 1350, 1371, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1373, 1350, 1350, 1350, 1350, 1350,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1350, 1350,

     1350, 1374, 1372, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1373, 1375, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1350, 1350, 1376, 1374, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1375, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,

     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1377,
     1376, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1378, 1377, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,
     1360, 1379, 1378, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360,

     1360, 1360, 1360, 1360, 1360, 1360, 1380, 1379, 1350, 1350,
     1350, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1360, 1381,
     1380, 1350, 1350, 1360, 1360, 1360, 1360, 1360, 1360, 1382,
     1381, 1350, 1350, 1360, 1360, 1360, 1360, 1383, 1382, 1350,
     1350, 1360, 1360, 1360, 1360, 1384, 1383, 1350, 1350, 1385,
     1384, 1350, 1350, 1386, 1385, 1350, 1350, 1387, 1386, 1350,
     1350, 1388, 1387, 1350, 1350, 1350, 1389, 1388, 1350, 1350,
     1350, 1350, 1350, 1390, 1389, 1350, 1350, 1350, 1350, 1350,
     1391, 1390, 1350, 1350, 1350, 1392, 1391, 1350, 1350, 1350,
     1350, 1393, 1392, 1394, 1393, 1395, 1394, 1396, 1395, 1397,

     1396, 1398, 1397, 1399, 1398, 1400, 1399, 1401, 1400, 1402,
     1401, 1403, 1402, 1404, 1403, 1405, 1404, 1406, 1405, 1407,
     1406, 1408, 1407, 1409, 1408, 1410, 1409, 1411, 1410, 1412,
     1411, 1413, 1412, 1414, 1413, 1415, 1414, 1416, 1415, 1417,
     1416, 1418, 1417, 1419, 1418, 1420, 1419, 1421, 1420, 1422,
     1421, 1423, 1422, 1424, 1423, 1425, 1424, 1426, 1425, 1427,
     1426, 1428, 1427, 1429, 1428, 1430, 1429, 1431, 1430, 1432,
     1431, 1433, 1432, 1434, 1433, 1435, 1434, 1436, 1435, 1437,
     1436, 1438, 1437, 1439, 1438, 1440, 1439, 1441, 1440, 1442,
     1441, 1443, 1442, 1444, 1443, 1445, 1444, 1446, 1445, 1447,

     1446, 1448, 1447, 1449, 1448, 1450, 1449, 1451, 1450, 1452,
     1451, 1453, 1452, 1454, 1453, 1455, 1454, 1456, 1455, 1457,
     1456, 1458, 1457, 1459, 1458, 1460, 1459, 1461, 1460, 1462,
     1461, 1463, 1462, 1464, 1463, 1465, 1464, 1466, 1465, 1467,
     1466, 1468, 1467, 1469, 1468, 1470, 1469, 1471, 1470, 1472,
     1471, 1473, 1472, 1474, 1473, 1475, 1474, 1476, 1475, 1477,
     1476, 1478, 1477, 1479, 1478, 1480, 1479, 1481, 1480, 1482,
     1481, 1483, 1482, 1484, 1483, 1485, 1484, 1486, 1485, 1487,
     1486, 1488, 1487, 1489, 1488, 1490, 1489, 1491, 1490, 1492,
     1491, 1493, 1492, 1494, 1493, 1495, 1494, 1496, 1495, 1497,

     1496, 1498, 1497, 1499, 1498, 1500, 1499, 1501, 1500, 1502,
     1501, 1503, 1502, 1504, 1503, 1505, 1504, 1506, 1505, 1507,
     1506, 1508, 1507, 1509, 1508, 1510, 1509, 1511, 1510, 1512,
     1511, 1513, 1512, 1514, 1513, 1515, 1514, 1516, 1515, 1517,
     1516, 1518, 1517, 1519, 1518, 1520, 1519, 1521, 1520, 1522,
     1521, 1523, 1522, 1524, 1523, 1525, 1524, 1526, 1525, 1527,
     1526, 1528, 1527, 1529, 1528, 1530, 1529, 1531, 1530, 1532,
     1531, 1533, 1532, 1534, 1533, 1535, 1534, 1536, 1535, 1537,
     1536, 1538, 1537, 1539, 1538, 1540, 1539, 1541, 1540, 1542,
     1541, 1543, 1542, 1544, 1543, 1545, 1544, 1546, 1545, 1547,

     1546, 1548, 1547, 1549, 1548, 1550, 1549, 1551, 1550, 1552,
     1551, 1553, 1552, 1554, 1553, 1555, 1554, 1556, 1555, 1557,
     1556, 1558, 1557, 1559, 1558, 1560, 1559, 1561, 1560, 1562,
     1561, 1563, 1562, 1564, 1563, 1565, 1564, 1566, 1565, 1567,
     1566, 1568, 1567, 1569, 1568, 1570, 1569, 1571, 1570, 1572,
     1571, 1573, 1572, 1574, 1573, 1575, 1574, 1576, 1575, 1577,
     1576, 1578, 1577, 1579, 1578, 1580, 1579, 1581, 1580, 1582,
     1581, 1583, 1582, 1584, 1583, 1585, 1584, 1586, 1585, 1587,
     1586, 1588, 1587, 1589, 1588, 1590, 1589, 1591, 1590, 1592,
     1591, 1593, 1592, 1594, 1593, 1595, 1594, 1596, 1595, 1597,

     1596, 1598, 1597, 1599, 1598, 1600, 1599, 1601, 1600, 1602,
     1601, 1603, 1602, 1604, 1603, 1605, 1604, 1606, 1605, 1607,
     1606, 1608, 1607, 1609, 1608, 1610, 1609, 1611, 1610, 1612,
     1611, 1613, 1612, 1614, 1613, 1615, 1614, 1616, 1615, 1617,
     1616, 1618, 1617, 1619, 1618, 1620, 1619, 1621, 1620, 1622,
     1621, 1623, 1622, 1624, 1623, 1625, 1624, 1626, 1625, 1627,
     1626, 1628, 1627, 1629, 1628, 1630, 1629, 1631, 1630, 1632,
     1631, 1633, 1632, 1634, 1633, 1635, 1634, 1636, 1635, 1637,
     1636, 1638, 1637, 1639, 1638, 1640, 1639, 1641, 1640, 1642,
     1641, 1643, 1642, 1644, 1643, 1645, 1644, 1646, 1645, 1647,

     1646, 1648, 1647, 1649, 1648, 1650, 1649, 1651, 1650, 1652,
     1651, 1653, 1652, 1654, 1653, 1655, 1654, 1656, 1655, 1657,
     1656, 1658, 1657, 1659, 1658, 1660, 1659, 1661, 1660, 1662,
     1661, 1663, 1662, 1664, 1663, 1665, 1664, 1666, 1665, 1667,
     1666, 1668, 1667, 1669, 1668, 1670, 1669, 1671, 1670, 1672,
     1671, 1673, 1672, 1674, 1673, 1675, 1674, 1676, 1675, 1677,
     1676, 1678, 1677, 1679, 1678, 1680, 1679, 1681, 1680, 1682,
     1681, 1683, 1682, 1684, 1683, 1685, 1684, 1686, 1685, 1687,
     1686, 1688, 1687, 1689, 1688, 1690, 1689, 1691, 1690, 1692,
     1691, 1693, 1692, 1694, 1693, 1695, 1694, 1696, 1695, 1697,

     1696, 1698, 1697, 1699, 1698, 1700, 1699, 1701, 1700, 1702,
     1701, 1703, 1702, 1704, 1703, 1705, 1704, 1706, 1705, 1707,
     1706, 1708, 1707, 1709, 1708, 1710, 1709, 1711, 1710, 1712,
     1711, 1713, 1712, 1714, 1713, 1715, 1714, 1716, 1715, 1717,
     1716, 1718, 1717, 1719, 1718, 1720, 1719, 1721, 1720, 1722,
     1721, 1723, 1722, 1724, 1723, 1725, 1724, 1726, 1725, 1727,
     1726, 1728, 1727, 1729, 1728, 1730, 1729, 1731, 1730, 1732,
     1731, 1733, 1732, 1734, 1733, 1735, 1734, 1736, 1735, 1737,
     1736, 1738, 1737, 1739, 1738, 1740, 1739, 1741, 1740, 1742,
     1741, 1743, 1742, 1744, 1743, 1745, 1744, 1746, 1745, 1747,

     1746, 1748, 1747, 1749, 1748, 1750, 1749, 1751, 1750, 1752,
     1751, 1753, 1752, 1754, 1753, 1755, 1754, 1756, 1755, 1757,
     1756, 1758, 1757, 1759, 1758, 1760, 1759, 1761, 1760, 1762,
     1761, 1763, 1762, 1764, 1763, 1765, 1764, 1766, 1765, 1767,
     1766, 1768, 1767, 1769, 1768, 1770, 1769, 1350, 1770,    0,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,

     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,

     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,

     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,

     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350
    } ;

static yyconst short int yy_nxt[7999] =
    {   0,
       24,   25,   25,   25,   26,   27,   28,   29,   30,   31,
       32,   33,   34,   35,   36,   34,   37,   38,   39,   40,
       41,   41,   42,   34,   43,   44,   45,   46,   34,   24,
       47,   48,   49,   50,   51,   52,   53,   54,   55,   56,
       57,   58,   57,   57,   59,   57,   60,   61,   62,   57,
       63,   64,   57,   65,   66,   67,   68,   57,   57,   69,
       70,   71,   24,   72,   72,   72,   72,   73,   72,   74,
       72,   72,   72,   72,   72,   72,   72,   72,   75,   72,
       72,   76,   77,   77,   72,   72,   72,   72,   72,   72,
       78,   79,   72,   80,   81,   80,   80,   80,   80,   80,

       80,   80,   80,   80,   80,   80,   80,   80,   80,   80,
       80,   80,   80,   80,   80,   80,   80,   80,   80,   80,
       80,   82,   72,   78,   84,   84,   86,   86,   89,  108,
      111,  111,  111,   90,  100,  101,  114,  117,  118,  114,
      102,  100,  101,   85,   85,  122,  119,  102,  109,  955,
       87,   87,   91,   88,   88,   89,   89,  135,  103,  104,
      115,   90,  120,  115,  123,  103,  104,  137,  136,  140,
      140,  140,  110,  154,  155,  141,  138,  139,  156,  157,
       91,  957,   92,   89,   92,   92,   92,   92,   92,   92,
       92,   92,   92,   92,   92,   92,   92,   92,   92,   92,

       92,   92,   92,   92,   92,   92,   92,   92,   92,   92,
       93,   93,   93,   93,   93,   93,   93,   93,   93,   93,
       93,   93,   93,   93,   93,   93,   93,   93,   93,   93,
       93,   93,   93,   93,   93,   93,   93,   93,   93,   93,
       93,   94,   93,   94,   94,   94,   94,   94,   94,   94,
       94,   94,   94,   94,   94,   94,   94,   94,   94,   94,
       94,   94,   94,   94,   94,   94,   94,   94,   94,   93,
       93,   93,   95,   95,   95,   95,   95,   95,   95,   95,
       95,   95,   95,   95,   95,   95,   95,   95,   95,   95,
       95,   95,   95,   95,   95,   95,   95,   95,   95,   95,

       95,   95,   95,   96,   95,   96,   96,   96,   96,   96,
       96,   96,   96,   96,   96,   96,   96,   96,   96,   96,
       96,   96,   96,   96,   96,   96,   96,   96,   96,   96,
       96,   95,   95,   95,  124,  142,  959,  198,  150,  145,
      143,  146,  146,  146,  151,  152,  153,  144,  145,  162,
      146,  146,  146,  163,  164,  179,  187,  191,  193,  147,
      192,  180,  188,  194,  961,  166,  125,  126,  147,  127,
      167,  128,  199,  963,  129,  234,  168,  170,  148,  169,
      130,  171,  173,  131,  132, 1350,  133,  172,  965,  182,
      113,  174,  175,  176,  204,  204,  204,  183,  235,  239,

      240,  177,  184,  178,  201,  201,  201,  201,  201,  201,
      201,  201,  201,  201,  201,  201,  201,  201,  201,  201,
      201,  201,  201,  201,  201,  201,  201,  201,  201,  201,
      201,  201,  201,  201,  201,  116,  201,  116,  116,  116,
      116,  116,  116,  116,  116,  116,  116,  116,  116,  116,
      116,  116,  116,  116,  116,  116,  116,  116,  116,  116,
      116,  116,  116,  202,  201,  201,  204,  204,  204,  207,
      215,  219,  208,  208,  219, 1350,  219,  208,  208,  220,
      122,  221,  222,  208,  208,  218,  111,  111,  111,  216,
      967, 1350,  255,  256, 1350,  140,  140,  140,  219,  123,

      969,  219,  224,  205,  250,  250,  250,  971,  145,  209,
      146,  146,  146,  147,  209,  253,  253,  253, 1350,  251,
      209,  251,  147,  973,  252,  252,  252,  975,  147,  253,
      253,  253,  253,  253,  253,  259,  260,  261,  271,  279,
      262,  272,  290,  300,  300,  291,  263,  204,  204,  204,
      280,  299,  299,  299,  977,  219,  219,  301,  301,  301,
      219,  220,  979,  221,  222,  299,  299,  299,  299,  299,
      299,  301,  301,  301,  301,  301,  301,  221,  222, 1350,
      327,  328,  219,  219,  224,  250,  250,  250,  252,  252,
      252,  252,  252,  252,  319, 1350,  356,  356, 1350,  253,

      253,  253,  981,  147,  983,  334,  320,  335,  374,  375,
      336,  374,  375,  253,  253,  253,  253,  253,  253, 1350,
      337,  985, 1350,  366,  338,  299,  299,  299,  412,  412,
      413,  357,  357,  357,  367, 1350, 1350,  987, 1350,  299,
      299,  299,  299,  299,  299,  357,  357,  357,  357,  357,
      357,  989, 1350,  417,  366, 1350,  423, 1350,  414,  368,
      455,  417, 1350,  423,  418,  367,  461,  424, 1350,  576,
      577,  456,  418, 1350,  424,  455, 1350,  462,  991, 1350,
      485,  485,  485,  488, 1350,  490,  456, 1350,  461,  419,
     1350,  485,  485,  485,  489,  993,  491,  417,  995,  462,

     1350,  366,  488,  490, 1350,  997, 1350,  999,  418, 1350,
     1001, 1350,  367,  489,  491,  511,  511,  511, 1003, 1350,
     1350, 1005, 1007, 1350,  511,  511,  511, 1350, 1009, 1350,
      565,  565,  565, 1350,  510, 1350, 1350, 1350, 1350, 1011,
      158, 1350, 1350, 1350, 1013, 1350, 1350, 1350, 1350,  158,
     1350, 1015, 1350, 1350,  566, 1350, 1350, 1350, 1350, 1017,
     1350, 1350, 1350,  565,  565,  565, 1350, 1350, 1019, 1350,
     1350, 1021, 1350,  570,  570,  570, 1023,  571, 1025, 1350,
     1350, 1027,  572, 1350, 1350, 1350, 1350,  566,  570,  570,
      570, 1029,  571, 1350, 1031, 1350, 1350,  572,  590,  590,

      590, 1033, 1350,  590,  590,  590, 1350, 1035, 1350, 1037,
     1350, 1350, 1350, 1350, 1350, 1350, 1039, 1350, 1350, 1041,
      573, 1350, 1350,  591, 1350, 1350, 1043, 1350,  591, 1350,
     1045, 1350, 1350, 1350, 1047,  573, 1350, 1049, 1350, 1350,
     1051, 1053, 1350, 1350, 1055, 1350, 1057, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1059, 1350, 1061, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1063, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1065, 1067, 1069, 1071, 1350,
     1073, 1350, 1350, 1350, 1350, 1350, 1350, 1075, 1350, 1077,
     1079, 1350, 1081, 1350, 1350, 1350, 1350, 1350, 1350, 1350,

     1350, 1083, 1350, 1085, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1087, 1350, 1350, 1089, 1350,
     1091, 1350, 1093, 1350, 1350, 1095, 1350, 1350, 1350, 1097,
     1350, 1350, 1099, 1350, 1350, 1101, 1350, 1350, 1103, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1105, 1350, 1107, 1109, 1350,
     1111, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1113,
     1350, 1350, 1115, 1117, 1350, 1119, 1350, 1350, 1121, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1123, 1350, 1350, 1125, 1350, 1350, 1127, 1350,

     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1129, 1131,
     1350, 1350, 1133, 1135, 1350, 1137, 1350, 1350, 1139, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1141, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1143, 1350,
     1350, 1350, 1350, 1145, 1350, 1350, 1350, 1350, 1147, 1149,
     1350, 1350, 1151, 1153, 1155, 1157, 1350, 1350, 1159, 1350,
     1350, 1350, 1350, 1350, 1350, 1161, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1163, 1165, 1350, 1167, 1350, 1169, 1350,
     1350, 1350, 1350, 1171, 1350, 1173, 1350, 1175, 1177, 1350,

     1179, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1181, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1183, 1350, 1350, 1185, 1350, 1187, 1350,
     1189, 1350, 1350, 1191, 1350, 1350, 1350, 1193, 1350, 1350,
     1195, 1350, 1350, 1197, 1350, 1350, 1199, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1201, 1350, 1203, 1205, 1350, 1207, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1209, 1350, 1350,
     1211, 1213, 1350, 1215, 1350, 1350, 1217, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,

     1219, 1350, 1350, 1221, 1350, 1350, 1223, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1225, 1227, 1350, 1350,
     1229, 1231, 1350, 1233, 1350, 1350, 1235, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1237, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1239, 1350, 1350, 1350,
     1350, 1241, 1350, 1350, 1350, 1350, 1243, 1245, 1350, 1350,
     1247, 1249, 1251, 1253, 1350, 1350, 1255, 1350, 1350, 1350,
     1350, 1350, 1350, 1257, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1259, 1261, 1350, 1263, 1350, 1265, 1350, 1350, 1350,

     1350, 1267, 1350, 1269, 1350, 1271, 1273, 1350, 1275, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1277,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1279, 1350, 1350, 1281, 1350, 1283, 1350, 1285, 1350,
     1350, 1287, 1350, 1350, 1350, 1289, 1350, 1350, 1291, 1350,
     1350, 1293, 1350, 1350, 1295, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1297, 1350, 1299, 1301, 1350, 1303, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1305, 1350, 1350, 1307, 1309,
     1350, 1311, 1350, 1350, 1313, 1350, 1350, 1350, 1350, 1350,

     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1315, 1350,
     1350, 1317, 1350, 1350, 1319, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1321, 1323, 1350, 1350, 1325, 1327,
     1350, 1329, 1350, 1350, 1331, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1333, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1335, 1350, 1350, 1350, 1350, 1337,
     1350, 1350, 1350, 1350, 1339, 1341, 1350, 1350, 1343, 1345,
     1347, 1349, 1350, 1350,  116, 1350, 1350, 1350, 1350, 1350,
     1350,  953, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  951,

      949, 1350,  947, 1350,  945, 1350, 1350, 1350, 1350,  943,
     1350,  941, 1350,  939,  937, 1350,  935, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350,  933, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  931,
     1350, 1350,  929, 1350,  927, 1350,  925, 1350, 1350,  923,
     1350, 1350, 1350,  921, 1350, 1350,  919, 1350, 1350,  917,
     1350, 1350,  915, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  913,
     1350,  911,  909, 1350,  907, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350,  905, 1350, 1350,  903,  901, 1350,  899,

     1350, 1350,  897, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350,  895, 1350, 1350,  893,
     1350, 1350,  891, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350,  889,  887, 1350, 1350,  885,  883, 1350,  881,
     1350, 1350,  879, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350,  877, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350,  875, 1350, 1350, 1350, 1350,  873, 1350, 1350,
     1350, 1350,  871,  869, 1350, 1350,  867,  865,  863,  861,
     1350, 1350,  859, 1350, 1350, 1350, 1350, 1350, 1350,  857,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,

     1350, 1350, 1350, 1350, 1350, 1350, 1350,  855,  853, 1350,
      851, 1350,  849, 1350, 1350, 1350, 1350,  847, 1350,  845,
     1350,  843,  841, 1350,  839, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350,  837, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350,  835, 1350, 1350,
      833, 1350,  831, 1350,  829, 1350, 1350,  827, 1350, 1350,
     1350,  825, 1350, 1350,  823, 1350, 1350,  821, 1350, 1350,
      819, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350,  817, 1350,  815,
      813, 1350,  811, 1350, 1350, 1350, 1350, 1350, 1350, 1350,

     1350,  809, 1350, 1350,  807,  805, 1350,  803, 1350, 1350,
      801, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350,  799, 1350, 1350,  797, 1350, 1350,
      795, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
      793,  791, 1350, 1350,  789,  787, 1350,  785, 1350, 1350,
      783, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  781,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
      779, 1350, 1350, 1350, 1350,  777, 1350, 1350, 1350, 1350,
      775,  773, 1350, 1350,  771,  769,  767,  765, 1350, 1350,
      763, 1350, 1350, 1350, 1350, 1350, 1350,  761, 1350, 1350,

     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350,  759,  757, 1350,  755, 1350,
      753, 1350, 1350, 1350, 1350,  751, 1350,  749, 1350,  747,
      745, 1350,  743, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350,  741, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350,  739, 1350, 1350,  737, 1350,
      735, 1350,  733, 1350, 1350,  731, 1350, 1350, 1350,  729,
     1350, 1350,  727, 1350, 1350,  725, 1350, 1350,  723, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350,  721, 1350,  719,  717, 1350,

      715, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  713,
     1350, 1350,  711,  709, 1350,  707, 1350, 1350,  705, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350,  703, 1350, 1350,  701, 1350, 1350,  699, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  697,  695,
     1350, 1350,  693,  691, 1350,  689, 1350, 1350,  687, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350,  685, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  683, 1350,
     1350, 1350, 1350,  681, 1350, 1350, 1350, 1350,  679,  677,
     1350, 1350,  675,  673,  671,  669, 1350, 1350,  667, 1350,

     1350, 1350, 1350, 1350, 1350,  665, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350,  663,  661, 1350,  659, 1350,  657, 1350,
     1350, 1350, 1350,  655, 1350,  653, 1350,  651,  649, 1350,
      647, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350,  645, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350,  643, 1350, 1350,  641, 1350,  639, 1350,
      637, 1350, 1350,  635, 1350, 1350, 1350,  633, 1350, 1350,
      631, 1350, 1350,  629, 1350, 1350,  627, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,

     1350, 1350, 1350,  625, 1350,  623,  621, 1350,  619, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350,  617, 1350, 1350,
      615,  613, 1350,  611, 1350, 1350,  609, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
      607, 1350, 1350,  605, 1350, 1350,  603, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350,  601,  599, 1350, 1350,
      597,  595, 1350,  585, 1350, 1350,  585, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350,  593, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350,  589, 1350, 1350, 1350,
     1350,  588, 1350, 1350, 1350, 1350,  587,  585, 1350, 1350,

      584,  583,  576,  582, 1350, 1350,  580, 1350, 1350, 1350,
     1350, 1350, 1350,  579, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350,  578,  575, 1350,  569, 1350,  568, 1350, 1350, 1350,
     1350,  564, 1350,  563, 1350,  561,  560, 1350,  559, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  557,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350,  556, 1350, 1350,  555, 1350,  553, 1350,  552, 1350,
     1350,  551, 1350, 1350, 1350,  549, 1350, 1350,  548, 1350,
     1350,  547, 1350, 1350,  545, 1350, 1350, 1350, 1350, 1350,

     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350,  544, 1350,  543,  542, 1350,  541, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350,  540, 1350, 1350,  539,  537,
     1350,  536, 1350, 1350,  535, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  534, 1350,
     1350,  533, 1350, 1350,  532, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350,  531,  529, 1350, 1350,  528,  527,
     1350,  526, 1350, 1350,  525, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350,  524, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350,  523, 1350, 1350, 1350, 1350,  522,

     1350, 1350, 1350, 1350,  521,  519, 1350, 1350,  518,  517,
      516,  515, 1350, 1350,  514, 1350, 1350, 1350, 1350, 1350,
     1350,  503, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  513,
      512, 1350,  509, 1350,  508, 1350, 1350, 1350, 1350,  506,
     1350,  505, 1350,  504,  503, 1350,  502, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350,  501, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  500,
     1350, 1350,  499, 1350,  498, 1350,  497, 1350, 1350,  496,
     1350, 1350, 1350,  495, 1350, 1350,  494, 1350, 1350,  493,

     1350, 1350,  492, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,  487,
     1350,  486,  484, 1350,  483, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350,  481, 1350, 1350,  480,  479, 1350,  478,
     1350, 1350,  477, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350,  476, 1350, 1350,  475,
     1350, 1350,  474, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350,  473,  472, 1350, 1350,  471,  470, 1350,  469,
     1350, 1350,  468, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350,  467, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,

     1350, 1350,  466, 1350, 1350, 1350, 1350,  465, 1350, 1350,
     1350, 1350,  464,  463, 1350, 1350,  460,  459,  458,  370,
     1350, 1350,  457, 1350, 1350, 1350, 1350, 1350, 1350,  454,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350,  453,  412, 1350,
      452, 1350,  450, 1350, 1350, 1350, 1350,  449, 1350,  448,
     1350,  447,  446, 1350,  445, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350,  444, 1350,  443, 1350, 1350,
     1350, 1350, 1350,  442, 1350, 1350, 1350,  441, 1350, 1350,
      440, 1350,  439,  438,  437,  436,  435,  434, 1350,  433,

      432,  431,  430, 1350,  429,  428,  374,  427, 1350, 1350,
      426,  425,  422, 1350,  421, 1350,   22,   22,   22,   22,
       22,   22,   22,   22,   22,   22,   22,   22,   83,   83,
       83,   83,   83,   83,   83,   83,   83,   83,   83,   83,
       97,   97,   97,   97,   97,   97,   97,   97,   97,   97,
       97,   97,   99,   99,   99,   99,   99,   99,   99,   99,
       99,   99,   99,   99,  105,  105,  105,  105,  105,  105,
      105,  105,  105,  105,  105,  105,  107,  107,  107,  107,
      107,  107,  107,  107,  107,  107,  370,  107,  113,  113,
      113,  113,  420,  113,  113,  113,  113,  113,  113,  113,

      121,  121,  121,  121,  121,  121,  121,  121,  121,  121,
      121,  121,  160,  416,  415,  160,  200,  200,  200,  411,
      200,  200,  200,  409,  200,  200,  206,  206,  206,  206,
      206,  206,  206,  206,  206,  206,  206,  206,  210,  408,
      407,  210,  213,  213,  213,  213,  213,  213,  406,  213,
      213,  213,  213,  213,  223,  405,  404,  403,  402,  401,
      223,  223,  400,  223,  225,  399,  398,  225,  226,  397,
      396,  226,  227,  227,  227,  227,  227,  227,  227,  395,
      227,  227,  227,  227,  229,  229,  394,  229,  229,  393,
      229,  229,  229,  229,  229,  229,  232,  232,  232,  232,

      232,  232,  232,  232,  232,  232,  232,  232,  238,  392,
      391,  238,  302,  302,  302,  302,  302,  302,  302,  302,
      302,  302,  302,  302,  317,  390,  389,  388,  387,  386,
      385,  384,  383,  382,  317,  358,  358,  358,  358,  358,
      358,  358,  358,  358,  358,  358,  358,  376,  381,  380,
      379,  378,  377,  376,  316,  373,  376,  410,  410,  410,
      410,  410,  410,  410,  410,  410,  410,  410,  410,  451,
      451,  451,  451,  451,  451,  451,  451,  451,  451,  451,
      451,  482,  482,  482,  482,  482,  482,  482,  482,  482,
      482,  482,  482,  507,  507,  507,  507,  507,  507,  507,

      507,  507,  507,  507,  507,  520,  520,  520,  520,  520,
      520,  520,  520,  520,  520,  520,  520,  530,  530,  530,
      530,  530,  530,  530,  530,  530,  530,  530,  530,  538,
      538,  538,  538,  538,  538,  538,  538,  538,  538,  538,
      538,  546,  546,  546,  546,  546,  546,  546,  546,  546,
      546,  546,  546,  550,  550,  550,  550,  550,  550,  550,
      550,  550,  550,  550,  550,  554,  554,  554,  554,  554,
      554,  554,  554,  554,  554,  554,  554,  558,  558,  558,
      558,  558,  558,  558,  558,  558,  558,  558,  558,  562,
      562,  562,  562,  562,  562,  562,  562,  562,  562,  562,

      562,  567,  567,  567,  567,  567,  567,  567,  567,  567,
      567,  567,  567,  574,  574,  574,  574,  574,  574,  574,
      574,  574,  574,  574,  574,  581,  581,  581,  581,  581,
      581,  581,  581,  581,  581,  581,  581,  586,  586,  586,
      586,  586,  586,  586,  586,  586,  586,  586,  586,  592,
      592,  592,  592,  592,  592,  592,  592,  592,  592,  592,
      592,  594,  594,  594,  594,  594,  594,  594,  594,  594,
      594,  594,  594,  596,  596,  596,  596,  596,  596,  596,
      596,  596,  596,  596,  596,  598,  598,  598,  598,  598,
      598,  598,  598,  598,  598,  598,  598,  600,  600,  600,

      600,  600,  600,  600,  600,  600,  600,  600,  600,  602,
      602,  602,  602,  602,  602,  602,  602,  602,  602,  602,
      602,  604,  604,  604,  604,  604,  604,  604,  604,  604,
      604,  604,  604,  606,  606,  606,  606,  606,  606,  606,
      606,  606,  606,  606,  606,  608,  608,  608,  608,  608,
      608,  608,  608,  608,  608,  608,  608,  610,  610,  610,
      610,  610,  610,  610,  610,  610,  610,  610,  610,  612,
      612,  612,  612,  612,  612,  612,  612,  612,  612,  612,
      612,  614,  614,  614,  614,  614,  614,  614,  614,  614,
      614,  614,  614,  616,  616,  616,  616,  616,  616,  616,

      616,  616,  616,  616,  616,  618,  618,  618,  618,  618,
      618,  618,  618,  618,  618,  618,  618,  620,  620,  620,
      620,  620,  620,  620,  620,  620,  620,  620,  620,  622,
      622,  622,  622,  622,  622,  622,  622,  622,  622,  622,
      622,  624,  624,  624,  624,  624,  624,  624,  624,  624,
      624,  624,  624,  626,  626,  626,  626,  626,  626,  626,
      626,  626,  626,  626,  626,  628,  628,  628,  628,  628,
      628,  628,  628,  628,  628,  628,  628,  630,  630,  630,
      630,  630,  630,  630,  630,  630,  630,  630,  630,  632,
      632,  632,  632,  632,  632,  632,  632,  632,  632,  632,

      632,  634,  634,  634,  634,  634,  634,  634,  634,  634,
      634,  634,  634,  636,  636,  636,  636,  636,  636,  636,
      636,  636,  636,  636,  636,  638,  638,  638,  638,  638,
      638,  638,  638,  638,  638,  638,  638,  640,  640,  640,
      640,  640,  640,  640,  640,  640,  640,  640,  640,  642,
      642,  642,  642,  642,  642,  642,  642,  642,  642,  642,
      642,  644,  644,  644,  644,  644,  644,  644,  644,  644,
      644,  644,  644,  646,  646,  646,  646,  646,  646,  646,
      646,  646,  646,  646,  646,  648,  648,  648,  648,  648,
      648,  648,  648,  648,  648,  648,  648,  650,  650,  650,

      650,  650,  650,  650,  650,  650,  650,  650,  650,  652,
      652,  652,  652,  652,  652,  652,  652,  652,  652,  652,
      652,  654,  654,  654,  654,  654,  654,  654,  654,  654,
      654,  654,  654,  656,  656,  656,  656,  656,  656,  656,
      656,  656,  656,  656,  656,  658,  658,  658,  658,  658,
      658,  658,  658,  658,  658,  658,  658,  660,  660,  660,
      660,  660,  660,  660,  660,  660,  660,  660,  660,  662,
      662,  662,  662,  662,  662,  662,  662,  662,  662,  662,
      662,  664,  664,  664,  664,  664,  664,  664,  664,  664,
      664,  664,  664,  666,  666,  666,  666,  666,  666,  666,

      666,  666,  666,  666,  666,  668,  668,  668,  668,  668,
      668,  668,  668,  668,  668,  668,  668,  670,  670,  670,
      670,  670,  670,  670,  670,  670,  670,  670,  670,  672,
      672,  672,  672,  672,  672,  672,  672,  672,  672,  672,
      672,  674,  674,  674,  674,  674,  674,  674,  674,  674,
      674,  674,  674,  676,  676,  676,  676,  676,  676,  676,
      676,  676,  676,  676,  676,  678,  678,  678,  678,  678,
      678,  678,  678,  678,  678,  678,  678,  680,  680,  680,
      680,  680,  680,  680,  680,  680,  680,  680,  680,  682,
      682,  682,  682,  682,  682,  682,  682,  682,  682,  682,

      682,  684,  684,  684,  684,  684,  684,  684,  684,  684,
      684,  684,  684,  686,  686,  686,  686,  686,  686,  686,
      686,  686,  686,  686,  686,  688,  688,  688,  688,  688,
      688,  688,  688,  688,  688,  688,  688,  690,  690,  690,
      690,  690,  690,  690,  690,  690,  690,  690,  690,  692,
      692,  692,  692,  692,  692,  692,  692,  692,  692,  692,
      692,  694,  694,  694,  694,  694,  694,  694,  694,  694,
      694,  694,  694,  696,  696,  696,  696,  696,  696,  696,
      696,  696,  696,  696,  696,  698,  698,  698,  698,  698,
      698,  698,  698,  698,  698,  698,  698,  700,  700,  700,

      700,  700,  700,  700,  700,  700,  700,  700,  700,  702,
      702,  702,  702,  702,  702,  702,  702,  702,  702,  702,
      702,  704,  704,  704,  704,  704,  704,  704,  704,  704,
      704,  704,  704,  706,  706,  706,  706,  706,  706,  706,
      706,  706,  706,  706,  706,  708,  708,  708,  708,  708,
      708,  708,  708,  708,  708,  708,  708,  710,  710,  710,
      710,  710,  710,  710,  710,  710,  710,  710,  710,  712,
      712,  712,  712,  712,  712,  712,  712,  712,  712,  712,
      712,  714,  714,  714,  714,  714,  714,  714,  714,  714,
      714,  714,  714,  716,  716,  716,  716,  716,  716,  716,

      716,  716,  716,  716,  716,  718,  718,  718,  718,  718,
      718,  718,  718,  718,  718,  718,  718,  720,  720,  720,
      720,  720,  720,  720,  720,  720,  720,  720,  720,  722,
      722,  722,  722,  722,  722,  722,  722,  722,  722,  722,
      722,  724,  724,  724,  724,  724,  724,  724,  724,  724,
      724,  724,  724,  726,  726,  726,  726,  726,  726,  726,
      726,  726,  726,  726,  726,  728,  728,  728,  728,  728,
      728,  728,  728,  728,  728,  728,  728,  730,  730,  730,
      730,  730,  730,  730,  730,  730,  730,  730,  730,  732,
      732,  732,  732,  732,  732,  732,  732,  732,  732,  732,

      732,  734,  734,  734,  734,  734,  734,  734,  734,  734,
      734,  734,  734,  736,  736,  736,  736,  736,  736,  736,
      736,  736,  736,  736,  736,  738,  738,  738,  738,  738,
      738,  738,  738,  738,  738,  738,  738,  740,  740,  740,
      740,  740,  740,  740,  740,  740,  740,  740,  740,  742,
      742,  742,  742,  742,  742,  742,  742,  742,  742,  742,
      742,  744,  744,  744,  744,  744,  744,  744,  744,  744,
      744,  744,  744,  746,  746,  746,  746,  746,  746,  746,
      746,  746,  746,  746,  746,  748,  748,  748,  748,  748,
      748,  748,  748,  748,  748,  748,  748,  750,  750,  750,

      750,  750,  750,  750,  750,  750,  750,  750,  750,  752,
      752,  752,  752,  752,  752,  752,  752,  752,  752,  752,
      752,  754,  754,  754,  754,  754,  754,  754,  754,  754,
      754,  754,  754,  756,  756,  756,  756,  756,  756,  756,
      756,  756,  756,  756,  756,  758,  758,  758,  758,  758,
      758,  758,  758,  758,  758,  758,  758,  760,  760,  760,
      760,  760,  760,  760,  760,  760,  760,  760,  760,  762,
      762,  762,  762,  762,  762,  762,  762,  762,  762,  762,
      762,  764,  764,  764,  764,  764,  764,  764,  764,  764,
      764,  764,  764,  766,  766,  766,  766,  766,  766,  766,

      766,  766,  766,  766,  766,  768,  768,  768,  768,  768,
      768,  768,  768,  768,  768,  768,  768,  770,  770,  770,
      770,  770,  770,  770,  770,  770,  770,  770,  770,  772,
      772,  772,  772,  772,  772,  772,  772,  772,  772,  772,
      772,  774,  774,  774,  774,  774,  774,  774,  774,  774,
      774,  774,  774,  776,  776,  776,  776,  776,  776,  776,
      776,  776,  776,  776,  776,  778,  778,  778,  778,  778,
      778,  778,  778,  778,  778,  778,  778,  780,  780,  780,
      780,  780,  780,  780,  780,  780,  780,  780,  780,  782,
      782,  782,  782,  782,  782,  782,  782,  782,  782,  782,

      782,  784,  784,  784,  784,  784,  784,  784,  784,  784,
      784,  784,  784,  786,  786,  786,  786,  786,  786,  786,
      786,  786,  786,  786,  786,  788,  788,  788,  788,  788,
      788,  788,  788,  788,  788,  788,  788,  790,  790,  790,
      790,  790,  790,  790,  790,  790,  790,  790,  790,  792,
      792,  792,  792,  792,  792,  792,  792,  792,  792,  792,
      792,  794,  794,  794,  794,  794,  794,  794,  794,  794,
      794,  794,  794,  796,  796,  796,  796,  796,  796,  796,
      796,  796,  796,  796,  796,  798,  798,  798,  798,  798,
      798,  798,  798,  798,  798,  798,  798,  800,  800,  800,

      800,  800,  800,  800,  800,  800,  800,  800,  800,  802,
      802,  802,  802,  802,  802,  802,  802,  802,  802,  802,
      802,  804,  804,  804,  804,  804,  804,  804,  804,  804,
      804,  804,  804,  806,  806,  806,  806,  806,  806,  806,
      806,  806,  806,  806,  806,  808,  808,  808,  808,  808,
      808,  808,  808,  808,  808,  808,  808,  810,  810,  810,
      810,  810,  810,  810,  810,  810,  810,  810,  810,  812,
      812,  812,  812,  812,  812,  812,  812,  812,  812,  812,
      812,  814,  814,  814,  814,  814,  814,  814,  814,  814,
      814,  814,  814,  816,  816,  816,  816,  816,  816,  816,

      816,  816,  816,  816,  816,  818,  818,  818,  818,  818,
      818,  818,  818,  818,  818,  818,  818,  820,  820,  820,
      820,  820,  820,  820,  820,  820,  820,  820,  820,  822,
      822,  822,  822,  822,  822,  822,  822,  822,  822,  822,
      822,  824,  824,  824,  824,  824,  824,  824,  824,  824,
      824,  824,  824,  826,  826,  826,  826,  826,  826,  826,
      826,  826,  826,  826,  826,  828,  828,  828,  828,  828,
      828,  828,  828,  828,  828,  828,  828,  830,  830,  830,
      830,  830,  830,  830,  830,  830,  830,  830,  830,  832,
      832,  832,  832,  832,  832,  832,  832,  832,  832,  832,

      832,  834,  834,  834,  834,  834,  834,  834,  834,  834,
      834,  834,  834,  836,  836,  836,  836,  836,  836,  836,
      836,  836,  836,  836,  836,  838,  838,  838,  838,  838,
      838,  838,  838,  838,  838,  838,  838,  840,  840,  840,
      840,  840,  840,  840,  840,  840,  840,  840,  840,  842,
      842,  842,  842,  842,  842,  842,  842,  842,  842,  842,
      842,  844,  844,  844,  844,  844,  844,  844,  844,  844,
      844,  844,  844,  846,  846,  846,  846,  846,  846,  846,
      846,  846,  846,  846,  846,  848,  848,  848,  848,  848,
      848,  848,  848,  848,  848,  848,  848,  850,  850,  850,

      850,  850,  850,  850,  850,  850,  850,  850,  850,  852,
      852,  852,  852,  852,  852,  852,  852,  852,  852,  852,
      852,  854,  854,  854,  854,  854,  854,  854,  854,  854,
      854,  854,  854,  856,  856,  856,  856,  856,  856,  856,
      856,  856,  856,  856,  856,  858,  858,  858,  858,  858,
      858,  858,  858,  858,  858,  858,  858,  860,  860,  860,
      860,  860,  860,  860,  860,  860,  860,  860,  860,  862,
      862,  862,  862,  862,  862,  862,  862,  862,  862,  862,
      862,  864,  864,  864,  864,  864,  864,  864,  864,  864,
      864,  864,  864,  866,  866,  866,  866,  866,  866,  866,

      866,  866,  866,  866,  866,  868,  868,  868,  868,  868,
      868,  868,  868,  868,  868,  868,  868,  870,  870,  870,
      870,  870,  870,  870,  870,  870,  870,  870,  870,  872,
      872,  872,  872,  872,  872,  872,  872,  872,  872,  872,
      872,  874,  874,  874,  874,  874,  874,  874,  874,  874,
      874,  874,  874,  876,  876,  876,  876,  876,  876,  876,
      876,  876,  876,  876,  876,  878,  878,  878,  878,  878,
      878,  878,  878,  878,  878,  878,  878,  880,  880,  880,
      880,  880,  880,  880,  880,  880,  880,  880,  880,  882,
      882,  882,  882,  882,  882,  882,  882,  882,  882,  882,

      882,  884,  884,  884,  884,  884,  884,  884,  884,  884,
      884,  884,  884,  886,  886,  886,  886,  886,  886,  886,
      886,  886,  886,  886,  886,  888,  888,  888,  888,  888,
      888,  888,  888,  888,  888,  888,  888,  890,  890,  890,
      890,  890,  890,  890,  890,  890,  890,  890,  890,  892,
      892,  892,  892,  892,  892,  892,  892,  892,  892,  892,
      892,  894,  894,  894,  894,  894,  894,  894,  894,  894,
      894,  894,  894,  896,  896,  896,  896,  896,  896,  896,
      896,  896,  896,  896,  896,  898,  898,  898,  898,  898,
      898,  898,  898,  898,  898,  898,  898,  900,  900,  900,

      900,  900,  900,  900,  900,  900,  900,  900,  900,  902,
      902,  902,  902,  902,  902,  902,  902,  902,  902,  902,
      902,  904,  904,  904,  904,  904,  904,  904,  904,  904,
      904,  904,  904,  906,  906,  906,  906,  906,  906,  906,
      906,  906,  906,  906,  906,  908,  908,  908,  908,  908,
      908,  908,  908,  908,  908,  908,  908,  910,  910,  910,
      910,  910,  910,  910,  910,  910,  910,  910,  910,  912,
      912,  912,  912,  912,  912,  912,  912,  912,  912,  912,
      912,  914,  914,  914,  914,  914,  914,  914,  914,  914,
      914,  914,  914,  916,  916,  916,  916,  916,  916,  916,

      916,  916,  916,  916,  916,  918,  918,  918,  918,  918,
      918,  918,  918,  918,  918,  918,  918,  920,  920,  920,
      920,  920,  920,  920,  920,  920,  920,  920,  920,  922,
      922,  922,  922,  922,  922,  922,  922,  922,  922,  922,
      922,  924,  924,  924,  924,  924,  924,  924,  924,  924,
      924,  924,  924,  926,  926,  926,  926,  926,  926,  926,
      926,  926,  926,  926,  926,  928,  928,  928,  928,  928,
      928,  928,  928,  928,  928,  928,  928,  930,  930,  930,
      930,  930,  930,  930,  930,  930,  930,  930,  930,  932,
      932,  932,  932,  932,  932,  932,  932,  932,  932,  932,

      932,  934,  934,  934,  934,  934,  934,  934,  934,  934,
      934,  934,  934,  936,  936,  936,  936,  936,  936,  936,
      936,  936,  936,  936,  936,  938,  938,  938,  938,  938,
      938,  938,  938,  938,  938,  938,  938,  940,  940,  940,
      940,  940,  940,  940,  940,  940,  940,  940,  940,  942,
      942,  942,  942,  942,  942,  942,  942,  942,  942,  942,
      942,  944,  944,  944,  944,  944,  944,  944,  944,  944,
      944,  944,  944,  946,  946,  946,  946,  946,  946,  946,
      946,  946,  946,  946,  946,  948,  948,  948,  948,  948,
      948,  948,  948,  948,  948,  948,  948,  950,  950,  950,

      950,  950,  950,  950,  950,  950,  950,  950,  950,  952,
      952,  952,  952,  952,  952,  952,  952,  952,  952,  952,
      952,  954,  954,  954,  954,  954,  954,  954,  954,  954,
      954,  954,  954,  956,  956,  956,  956,  956,  956,  956,
      956,  956,  956,  956,  956,  958,  958,  958,  958,  958,
      958,  958,  958,  958,  958,  958,  958,  960,  960,  960,
      960,  960,  960,  960,  960,  960,  960,  960,  960,  962,
      962,  962,  962,  962,  962,  962,  962,  962,  962,  962,
      962,  964,  964,  964,  964,  964,  964,  964,  964,  964,
      964,  964,  964,  966,  966,  966,  966,  966,  966,  966,

      966,  966,  966,  966,  966,  968,  968,  968,  968,  968,
      968,  968,  968,  968,  968,  968,  968,  970,  970,  970,
      970,  970,  970,  970,  970,  970,  970,  970,  970,  972,
      972,  972,  972,  972,  972,  972,  972,  972,  972,  972,
      972,  974,  974,  974,  974,  974,  974,  974,  974,  974,
      974,  974,  974,  976,  976,  976,  976,  976,  976,  976,
      976,  976,  976,  976,  976,  978,  978,  978,  978,  978,
      978,  978,  978,  978,  978,  978,  978,  980,  980,  980,
      980,  980,  980,  980,  980,  980,  980,  980,  980,  982,
      982,  982,  982,  982,  982,  982,  982,  982,  982,  982,

      982,  984,  984,  984,  984,  984,  984,  984,  984,  984,
      984,  984,  984,  986,  986,  986,  986,  986,  986,  986,
      986,  986,  986,  986,  986,  988,  988,  988,  988,  988,
      988,  988,  988,  988,  988,  988,  988,  990,  990,  990,
      990,  990,  990,  990,  990,  990,  990,  990,  990,  992,
      992,  992,  992,  992,  992,  992,  992,  992,  992,  992,
      992,  994,  994,  994,  994,  994,  994,  994,  994,  994,
      994,  994,  994,  996,  996,  996,  996,  996,  996,  996,
      996,  996,  996,  996,  996,  998,  998,  998,  998,  998,
      998,  998,  998,  998,  998,  998,  998, 1000, 1000, 1000,

     1000, 1000, 1000, 1000, 1000, 1000, 1000, 1000, 1000, 1002,
     1002, 1002, 1002, 1002, 1002, 1002, 1002, 1002, 1002, 1002,
     1002, 1004, 1004, 1004, 1004, 1004, 1004, 1004, 1004, 1004,
     1004, 1004, 1004, 1006, 1006, 1006, 1006, 1006, 1006, 1006,
     1006, 1006, 1006, 1006, 1006, 1008, 1008, 1008, 1008, 1008,
     1008, 1008, 1008, 1008, 1008, 1008, 1008, 1010, 1010, 1010,
     1010, 1010, 1010, 1010, 1010, 1010, 1010, 1010, 1010, 1012,
     1012, 1012, 1012, 1012, 1012, 1012, 1012, 1012, 1012, 1012,
     1012, 1014, 1014, 1014, 1014, 1014, 1014, 1014, 1014, 1014,
     1014, 1014, 1014, 1016, 1016, 1016, 1016, 1016, 1016, 1016,

     1016, 1016, 1016, 1016, 1016, 1018, 1018, 1018, 1018, 1018,
     1018, 1018, 1018, 1018, 1018, 1018, 1018, 1020, 1020, 1020,
     1020, 1020, 1020, 1020, 1020, 1020, 1020, 1020, 1020, 1022,
     1022, 1022, 1022, 1022, 1022, 1022, 1022, 1022, 1022, 1022,
     1022, 1024, 1024, 1024, 1024, 1024, 1024, 1024, 1024, 1024,
     1024, 1024, 1024, 1026, 1026, 1026, 1026, 1026, 1026, 1026,
     1026, 1026, 1026, 1026, 1026, 1028, 1028, 1028, 1028, 1028,
     1028, 1028, 1028, 1028, 1028, 1028, 1028, 1030, 1030, 1030,
     1030, 1030, 1030, 1030, 1030, 1030, 1030, 1030, 1030, 1032,
     1032, 1032, 1032, 1032, 1032, 1032, 1032, 1032, 1032, 1032,

     1032, 1034, 1034, 1034, 1034, 1034, 1034, 1034, 1034, 1034,
     1034, 1034, 1034, 1036, 1036, 1036, 1036, 1036, 1036, 1036,
     1036, 1036, 1036, 1036, 1036, 1038, 1038, 1038, 1038, 1038,
     1038, 1038, 1038, 1038, 1038, 1038, 1038, 1040, 1040, 1040,
     1040, 1040, 1040, 1040, 1040, 1040, 1040, 1040, 1040, 1042,
     1042, 1042, 1042, 1042, 1042, 1042, 1042, 1042, 1042, 1042,
     1042, 1044, 1044, 1044, 1044, 1044, 1044, 1044, 1044, 1044,
     1044, 1044, 1044, 1046, 1046, 1046, 1046, 1046, 1046, 1046,
     1046, 1046, 1046, 1046, 1046, 1048, 1048, 1048, 1048, 1048,
     1048, 1048, 1048, 1048, 1048, 1048, 1048, 1050, 1050, 1050,

     1050, 1050, 1050, 1050, 1050, 1050, 1050, 1050, 1050, 1052,
     1052, 1052, 1052, 1052, 1052, 1052, 1052, 1052, 1052, 1052,
     1052, 1054, 1054, 1054, 1054, 1054, 1054, 1054, 1054, 1054,
     1054, 1054, 1054, 1056, 1056, 1056, 1056, 1056, 1056, 1056,
     1056, 1056, 1056, 1056, 1056, 1058, 1058, 1058, 1058, 1058,
     1058, 1058, 1058, 1058, 1058, 1058, 1058, 1060, 1060, 1060,
     1060, 1060, 1060, 1060, 1060, 1060, 1060, 1060, 1060, 1062,
     1062, 1062, 1062, 1062, 1062, 1062, 1062, 1062, 1062, 1062,
     1062, 1064, 1064, 1064, 1064, 1064, 1064, 1064, 1064, 1064,
     1064, 1064, 1064, 1066, 1066, 1066, 1066, 1066, 1066, 1066,

     1066, 1066, 1066, 1066, 1066, 1068, 1068, 1068, 1068, 1068,
     1068, 1068, 1068, 1068, 1068, 1068, 1068, 1070, 1070, 1070,
     1070, 1070, 1070, 1070, 1070, 1070, 1070, 1070, 1070, 1072,
     1072, 1072, 1072, 1072, 1072, 1072, 1072, 1072, 1072, 1072,
     1072, 1074, 1074, 1074, 1074, 1074, 1074, 1074, 1074, 1074,
     1074, 1074, 1074, 1076, 1076, 1076, 1076, 1076, 1076, 1076,
     1076, 1076, 1076, 1076, 1076, 1078, 1078, 1078, 1078, 1078,
     1078, 1078, 1078, 1078, 1078, 1078, 1078, 1080, 1080, 1080,
     1080, 1080, 1080, 1080, 1080, 1080, 1080, 1080, 1080, 1082,
     1082, 1082, 1082, 1082, 1082, 1082, 1082, 1082, 1082, 1082,

     1082, 1084, 1084, 1084, 1084, 1084, 1084, 1084, 1084, 1084,
     1084, 1084, 1084, 1086, 1086, 1086, 1086, 1086, 1086, 1086,
     1086, 1086, 1086, 1086, 1086, 1088, 1088, 1088, 1088, 1088,
     1088, 1088, 1088, 1088, 1088, 1088, 1088, 1090, 1090, 1090,
     1090, 1090, 1090, 1090, 1090, 1090, 1090, 1090, 1090, 1092,
     1092, 1092, 1092, 1092, 1092, 1092, 1092, 1092, 1092, 1092,
     1092, 1094, 1094, 1094, 1094, 1094, 1094, 1094, 1094, 1094,
     1094, 1094, 1094, 1096, 1096, 1096, 1096, 1096, 1096, 1096,
     1096, 1096, 1096, 1096, 1096, 1098, 1098, 1098, 1098, 1098,
     1098, 1098, 1098, 1098, 1098, 1098, 1098, 1100, 1100, 1100,

     1100, 1100, 1100, 1100, 1100, 1100, 1100, 1100, 1100, 1102,
     1102, 1102, 1102, 1102, 1102, 1102, 1102, 1102, 1102, 1102,
     1102, 1104, 1104, 1104, 1104, 1104, 1104, 1104, 1104, 1104,
     1104, 1104, 1104, 1106, 1106, 1106, 1106, 1106, 1106, 1106,
     1106, 1106, 1106, 1106, 1106, 1108, 1108, 1108, 1108, 1108,
     1108, 1108, 1108, 1108, 1108, 1108, 1108, 1110, 1110, 1110,
     1110, 1110, 1110, 1110, 1110, 1110, 1110, 1110, 1110, 1112,
     1112, 1112, 1112, 1112, 1112, 1112, 1112, 1112, 1112, 1112,
     1112, 1114, 1114, 1114, 1114, 1114, 1114, 1114, 1114, 1114,
     1114, 1114, 1114, 1116, 1116, 1116, 1116, 1116, 1116, 1116,

     1116, 1116, 1116, 1116, 1116, 1118, 1118, 1118, 1118, 1118,
     1118, 1118, 1118, 1118, 1118, 1118, 1118, 1120, 1120, 1120,
     1120, 1120, 1120, 1120, 1120, 1120, 1120, 1120, 1120, 1122,
     1122, 1122, 1122, 1122, 1122, 1122, 1122, 1122, 1122, 1122,
     1122, 1124, 1124, 1124, 1124, 1124, 1124, 1124, 1124, 1124,
     1124, 1124, 1124, 1126, 1126, 1126, 1126, 1126, 1126, 1126,
     1126, 1126, 1126, 1126, 1126, 1128, 1128, 1128, 1128, 1128,
     1128, 1128, 1128, 1128, 1128, 1128, 1128, 1130, 1130, 1130,
     1130, 1130, 1130, 1130, 1130, 1130, 1130, 1130, 1130, 1132,
     1132, 1132, 1132, 1132, 1132, 1132, 1132, 1132, 1132, 1132,

     1132, 1134, 1134, 1134, 1134, 1134, 1134, 1134, 1134, 1134,
     1134, 1134, 1134, 1136, 1136, 1136, 1136, 1136, 1136, 1136,
     1136, 1136, 1136, 1136, 1136, 1138, 1138, 1138, 1138, 1138,
     1138, 1138, 1138, 1138, 1138, 1138, 1138, 1140, 1140, 1140,
     1140, 1140, 1140, 1140, 1140, 1140, 1140, 1140, 1140, 1142,
     1142, 1142, 1142, 1142, 1142, 1142, 1142, 1142, 1142, 1142,
     1142, 1144, 1144, 1144, 1144, 1144, 1144, 1144, 1144, 1144,
     1144, 1144, 1144, 1146, 1146, 1146, 1146, 1146, 1146, 1146,
     1146, 1146, 1146, 1146, 1146, 1148, 1148, 1148, 1148, 1148,
     1148, 1148, 1148, 1148, 1148, 1148, 1148, 1150, 1150, 1150,

     1150, 1150, 1150, 1150, 1150, 1150, 1150, 1150, 1150, 1152,
     1152, 1152, 1152, 1152, 1152, 1152, 1152, 1152, 1152, 1152,
     1152, 1154, 1154, 1154, 1154, 1154, 1154, 1154, 1154, 1154,
     1154, 1154, 1154, 1156, 1156, 1156, 1156, 1156, 1156, 1156,
     1156, 1156, 1156, 1156, 1156, 1158, 1158, 1158, 1158, 1158,
     1158, 1158, 1158, 1158, 1158, 1158, 1158, 1160, 1160, 1160,
     1160, 1160, 1160, 1160, 1160, 1160, 1160, 1160, 1160, 1162,
     1162, 1162, 1162, 1162, 1162, 1162, 1162, 1162, 1162, 1162,
     1162, 1164, 1164, 1164, 1164, 1164, 1164, 1164, 1164, 1164,
     1164, 1164, 1164, 1166, 1166, 1166, 1166, 1166, 1166, 1166,

     1166, 1166, 1166, 1166, 1166, 1168, 1168, 1168, 1168, 1168,
     1168, 1168, 1168, 1168, 1168, 1168, 1168, 1170, 1170, 1170,
     1170, 1170, 1170, 1170, 1170, 1170, 1170, 1170, 1170, 1172,
     1172, 1172, 1172, 1172, 1172, 1172, 1172, 1172, 1172, 1172,
     1172, 1174, 1174, 1174, 1174, 1174, 1174, 1174, 1174, 1174,
     1174, 1174, 1174, 1176, 1176, 1176, 1176, 1176, 1176, 1176,
     1176, 1176, 1176, 1176, 1176, 1178, 1178, 1178, 1178, 1178,
     1178, 1178, 1178, 1178, 1178, 1178, 1178, 1180, 1180, 1180,
     1180, 1180, 1180, 1180, 1180, 1180, 1180, 1180, 1180, 1182,
     1182, 1182, 1182, 1182, 1182, 1182, 1182, 1182, 1182, 1182,

     1182, 1184, 1184, 1184, 1184, 1184, 1184, 1184, 1184, 1184,
     1184, 1184, 1184, 1186, 1186, 1186, 1186, 1186, 1186, 1186,
     1186, 1186, 1186, 1186, 1186, 1188, 1188, 1188, 1188, 1188,
     1188, 1188, 1188, 1188, 1188, 1188, 1188, 1190, 1190, 1190,
     1190, 1190, 1190, 1190, 1190, 1190, 1190, 1190, 1190, 1192,
     1192, 1192, 1192, 1192, 1192, 1192, 1192, 1192, 1192, 1192,
     1192, 1194, 1194, 1194, 1194, 1194, 1194, 1194, 1194, 1194,
     1194, 1194, 1194, 1196, 1196, 1196, 1196, 1196, 1196, 1196,
     1196, 1196, 1196, 1196, 1196, 1198, 1198, 1198, 1198, 1198,
     1198, 1198, 1198, 1198, 1198, 1198, 1198, 1200, 1200, 1200,

     1200, 1200, 1200, 1200, 1200, 1200, 1200, 1200, 1200, 1202,
     1202, 1202, 1202, 1202, 1202, 1202, 1202, 1202, 1202, 1202,
     1202, 1204, 1204, 1204, 1204, 1204, 1204, 1204, 1204, 1204,
     1204, 1204, 1204, 1206, 1206, 1206, 1206, 1206, 1206, 1206,
     1206, 1206, 1206, 1206, 1206, 1208, 1208, 1208, 1208, 1208,
     1208, 1208, 1208, 1208, 1208, 1208, 1208, 1210, 1210, 1210,
     1210, 1210, 1210, 1210, 1210, 1210, 1210, 1210, 1210, 1212,
     1212, 1212, 1212, 1212, 1212, 1212, 1212, 1212, 1212, 1212,
     1212, 1214, 1214, 1214, 1214, 1214, 1214, 1214, 1214, 1214,
     1214, 1214, 1214, 1216, 1216, 1216, 1216, 1216, 1216, 1216,

     1216, 1216, 1216, 1216, 1216, 1218, 1218, 1218, 1218, 1218,
     1218, 1218, 1218, 1218, 1218, 1218, 1218, 1220, 1220, 1220,
     1220, 1220, 1220, 1220, 1220, 1220, 1220, 1220, 1220, 1222,
     1222, 1222, 1222, 1222, 1222, 1222, 1222, 1222, 1222, 1222,
     1222, 1224, 1224, 1224, 1224, 1224, 1224, 1224, 1224, 1224,
     1224, 1224, 1224, 1226, 1226, 1226, 1226, 1226, 1226, 1226,
     1226, 1226, 1226, 1226, 1226, 1228, 1228, 1228, 1228, 1228,
     1228, 1228, 1228, 1228, 1228, 1228, 1228, 1230, 1230, 1230,
     1230, 1230, 1230, 1230, 1230, 1230, 1230, 1230, 1230, 1232,
     1232, 1232, 1232, 1232, 1232, 1232, 1232, 1232, 1232, 1232,

     1232, 1234, 1234, 1234, 1234, 1234, 1234, 1234, 1234, 1234,
     1234, 1234, 1234, 1236, 1236, 1236, 1236, 1236, 1236, 1236,
     1236, 1236, 1236, 1236, 1236, 1238, 1238, 1238, 1238, 1238,
     1238, 1238, 1238, 1238, 1238, 1238, 1238, 1240, 1240, 1240,
     1240, 1240, 1240, 1240, 1240, 1240, 1240, 1240, 1240, 1242,
     1242, 1242, 1242, 1242, 1242, 1242, 1242, 1242, 1242, 1242,
     1242, 1244, 1244, 1244, 1244, 1244, 1244, 1244, 1244, 1244,
     1244, 1244, 1244, 1246, 1246, 1246, 1246, 1246, 1246, 1246,
     1246, 1246, 1246, 1246, 1246, 1248, 1248, 1248, 1248, 1248,
     1248, 1248, 1248, 1248, 1248, 1248, 1248, 1250, 1250, 1250,

     1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1250, 1252,
     1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252, 1252,
     1252, 1254, 1254, 1254, 1254, 1254, 1254, 1254, 1254, 1254,
     1254, 1254, 1254, 1256, 1256, 1256, 1256, 1256, 1256, 1256,
     1256, 1256, 1256, 1256, 1256, 1258, 1258, 1258, 1258, 1258,
     1258, 1258, 1258, 1258, 1258, 1258, 1258, 1260, 1260, 1260,
     1260, 1260, 1260, 1260, 1260, 1260, 1260, 1260, 1260, 1262,
     1262, 1262, 1262, 1262, 1262, 1262, 1262, 1262, 1262, 1262,
     1262, 1264, 1264, 1264, 1264, 1264, 1264, 1264, 1264, 1264,
     1264, 1264, 1264, 1266, 1266, 1266, 1266, 1266, 1266, 1266,

     1266, 1266, 1266, 1266, 1266, 1268, 1268, 1268, 1268, 1268,
     1268, 1268, 1268, 1268, 1268, 1268, 1268, 1270, 1270, 1270,
     1270, 1270, 1270, 1270, 1270, 1270, 1270, 1270, 1270, 1272,
     1272, 1272, 1272, 1272, 1272, 1272, 1272, 1272, 1272, 1272,
     1272, 1274, 1274, 1274, 1274, 1274, 1274, 1274, 1274, 1274,
     1274, 1274, 1274, 1276, 1276, 1276, 1276, 1276, 1276, 1276,
     1276, 1276, 1276, 1276, 1276, 1278, 1278, 1278, 1278, 1278,
     1278, 1278, 1278, 1278, 1278, 1278, 1278, 1280, 1280, 1280,
     1280, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1280, 1282,
     1282, 1282, 1282, 1282, 1282, 1282, 1282, 1282, 1282, 1282,

     1282, 1284, 1284, 1284, 1284, 1284, 1284, 1284, 1284, 1284,
     1284, 1284, 1284, 1286, 1286, 1286, 1286, 1286, 1286, 1286,
     1286, 1286, 1286, 1286, 1286, 1288, 1288, 1288, 1288, 1288,
     1288, 1288, 1288, 1288, 1288, 1288, 1288, 1290, 1290, 1290,
     1290, 1290, 1290, 1290, 1290, 1290, 1290, 1290, 1290, 1292,
     1292, 1292, 1292, 1292, 1292, 1292, 1292, 1292, 1292, 1292,
     1292, 1294, 1294, 1294, 1294, 1294, 1294, 1294, 1294, 1294,
     1294, 1294, 1294, 1296, 1296, 1296, 1296, 1296, 1296, 1296,
     1296, 1296, 1296, 1296, 1296, 1298, 1298, 1298, 1298, 1298,
     1298, 1298, 1298, 1298, 1298, 1298, 1298, 1300, 1300, 1300,

     1300, 1300, 1300, 1300, 1300, 1300, 1300, 1300, 1300, 1302,
     1302, 1302, 1302, 1302, 1302, 1302, 1302, 1302, 1302, 1302,
     1302, 1304, 1304, 1304, 1304, 1304, 1304, 1304, 1304, 1304,
     1304, 1304, 1304, 1306, 1306, 1306, 1306, 1306, 1306, 1306,
     1306, 1306, 1306, 1306, 1306, 1308, 1308, 1308, 1308, 1308,
     1308, 1308, 1308, 1308, 1308, 1308, 1308, 1310, 1310, 1310,
     1310, 1310, 1310, 1310, 1310, 1310, 1310, 1310, 1310, 1312,
     1312, 1312, 1312, 1312, 1312, 1312, 1312, 1312, 1312, 1312,
     1312, 1314, 1314, 1314, 1314, 1314, 1314, 1314, 1314, 1314,
     1314, 1314, 1314, 1316, 1316, 1316, 1316, 1316, 1316, 1316,

     1316, 1316, 1316, 1316, 1316, 1318, 1318, 1318, 1318, 1318,
     1318, 1318, 1318, 1318, 1318, 1318, 1318, 1320, 1320, 1320,
     1320, 1320, 1320, 1320, 1320, 1320, 1320, 1320, 1320, 1322,
     1322, 1322, 1322, 1322, 1322, 1322, 1322, 1322, 1322, 1322,
     1322, 1324, 1324, 1324, 1324, 1324, 1324, 1324, 1324, 1324,
     1324, 1324, 1324, 1326, 1326, 1326, 1326, 1326, 1326, 1326,
     1326, 1326, 1326, 1326, 1326, 1328, 1328, 1328, 1328, 1328,
     1328, 1328, 1328, 1328, 1328, 1328, 1328, 1330, 1330, 1330,
     1330, 1330, 1330, 1330, 1330, 1330, 1330, 1330, 1330, 1332,
     1332, 1332, 1332, 1332, 1332, 1332, 1332, 1332, 1332, 1332,

     1332, 1334, 1334, 1334, 1334, 1334, 1334, 1334, 1334, 1334,
     1334, 1334, 1334, 1336, 1336, 1336, 1336, 1336, 1336, 1336,
     1336, 1336, 1336, 1336, 1336, 1338, 1338, 1338, 1338, 1338,
     1338, 1338, 1338, 1338, 1338, 1338, 1338, 1340, 1340, 1340,
     1340, 1340, 1340, 1340, 1340, 1340, 1340, 1340, 1340, 1342,
     1342, 1342, 1342, 1342, 1342, 1342, 1342, 1342, 1342, 1342,
     1342, 1344, 1344, 1344, 1344, 1344, 1344, 1344, 1344, 1344,
     1344, 1344, 1344, 1346, 1346, 1346, 1346, 1346, 1346, 1346,
     1346, 1346, 1346, 1346, 1346, 1348, 1348, 1348, 1348, 1348,
     1348, 1348, 1348, 1348, 1348, 1348, 1348,  372,  371,  370,

      369,  365,  364,  363,  362,  361,  360,  359,  355,  354,
      353,  352,  351,  350,  349,  348,  347,  346,  345,  344,
      343,  342,  341,  340,  339,  333,  332,  331,  330,  329,
      326,  325,  324,  323,  322,  321,  318,  259,  316,  315,
      314,  313,  312,  311,  310,  309,  308,  307,  306,  239,
      305,  304,  303,  221,  217, 1350,  214,  211,  298,  297,
      296,  295,  294,  293,  292,  289,  288,  287,  286,  285,
      284,  283,  282,  281,  278,  277,  276,  275,  274,  273,
      270,  269,  268,  267,  266,  265,  264,  258,  257,  254,
      249,  248,  247,  246,  245,  244,  243,  242,  241, 1350,

      237,  236,  234,  106,  233,  231,  231,  230,  228,  217,
      214,  212,  211,  203,  197,  196,  195,  190,  189,  186,
      185,  181,  165,  161,  159,  158,  149,  134,  112,  106,
     1350,   98,   98,   23,   23,   21, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350

    } ;

static yyconst short int yy_chk[7999] =
    {   0,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    3,    3,    3,    3,    3,    3,    3,    3,
        3,    3,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,

        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    7,    8,    9,   10,   11,   23,
       25,   25,   25,   11,   19,   19,   27,   30,   30,  113,
       19,   20,   20,    7,    8,   32,   31,   20,   23,  952,
        9,   10,   11,    9,   10,   11,   12,   36,   19,   19,
       27,   12,   31,  113,   32,   20,   20,   37,   36,   38,
       38,   38,   23,   44,   44,   38,   37,   37,   45,   45,
       12,  954,   12,   12,   12,   12,   12,   12,   12,   12,
       12,   12,   12,   12,   12,   12,   12,   12,   12,   12,

       12,   12,   12,   12,   12,   12,   12,   12,   12,   12,
       13,   13,   13,   13,   13,   13,   13,   13,   13,   13,
       13,   13,   13,   13,   13,   13,   13,   13,   13,   13,
       13,   13,   13,   13,   13,   13,   13,   13,   13,   13,
       13,   13,   13,   13,   13,   13,   13,   13,   13,   13,
       13,   13,   13,   13,   13,   13,   13,   13,   13,   13,
       13,   13,   13,   13,   13,   13,   13,   13,   13,   13,
       13,   13,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,

       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   15,   15,   15,   15,   15,   15,
       15,   15,   15,   15,   33,   39,  956,   70,   43,   40,
       39,   40,   40,   40,   43,   43,   43,   39,   41,   50,
       41,   41,   41,   50,   50,   55,   61,   64,   65,   40,
       64,   55,   61,   65,  958,   52,   33,   33,   41,   33,
       52,   33,   70,  960,   33,  109,   52,   53,   40,   52,
       33,   53,   54,   33,   33,  115,   33,   53,  962,   58,
      115,   54,   54,   54,   77,   77,   77,   58,  109,  118,

      118,   54,   58,   54,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   74,   74,   74,   74,
       74,   74,   74,   74,   74,   74,   76,   76,   76,   79,
       85,   89,   87,   87,   90,  106,   89,   91,   91,   90,
      121,   92,   92,   79,   79,   87,  111,  111,  111,   85,
      964,  106,  151,  151,  106,  140,  140,  140,   89,  121,

      966,   90,   92,   76,  145,  145,  145,  968,  146,   87,
      146,  146,  146,  140,   91,  148,  148,  148,  106,  147,
       79,  147,  145,  970,  147,  147,  147,  972,  146,  148,
      148,  148,  148,  148,  148,  158,  158,  161,  170,  178,
      161,  170,  190,  208,  208,  190,  161,  204,  204,  204,
      178,  205,  205,  205,  974,  219,  220,  209,  209,  209,
      219,  220,  976,  223,  223,  205,  205,  205,  205,  205,
      205,  209,  209,  209,  209,  209,  209,  224,  224,  233,
      270,  270,  219,  220,  223,  250,  250,  250,  251,  251,
      251,  252,  252,  252,  262,  233,  300,  300,  233,  253,

      253,  253,  978,  250,  980,  277,  262,  277,  317,  317,
      277,  376,  376,  253,  253,  253,  253,  253,  253,  303,
      277,  982,  233,  310,  277,  299,  299,  299,  360,  360,
      360,  301,  301,  301,  310,  303,  359,  984,  303,  299,
      299,  299,  299,  299,  299,  301,  301,  301,  301,  301,
      301,  986,  359,  363,  366,  359,  370,  411,  360,  310,
      416,  417,  303,  423,  363,  366,  426,  370,  452,  569,
      569,  416,  417,  411,  423,  455,  411,  426,  988,  359,
      454,  454,  454,  459,  452,  460,  455,  452,  461,  363,
      483,  485,  485,  485,  459,  990,  460,  486,  992,  461,

      411,  487,  488,  490,  508,  994,  483,  996,  486,  483,
      998,  452,  487,  488,  490,  492,  492,  492, 1000,  521,
      508, 1002, 1004,  508,  511,  511,  511,  531, 1006,  539,
      561,  561,  561,  483,  485,  521,  547,  551,  521, 1008,
      492,  555,  559,  531, 1010,  539,  531,  508,  539,  511,
      563, 1012,  547,  551,  561,  547,  551,  555,  559, 1014,
      555,  559,  521,  565,  565,  565,  563,  568, 1016,  563,
      531, 1018,  539,  566,  566,  566, 1020,  566, 1022,  547,
      551, 1024,  566,  568,  555,  559,  568,  565,  570,  570,
      570, 1026,  570,  563, 1028,  575,  582,  570,  585,  585,

      585, 1030,  587,  590,  590,  590,  593, 1032,  595, 1034,
      568,  575,  582,  597,  575,  582, 1036,  599,  587, 1038,
      566,  587,  593,  585,  595,  593, 1040,  595,  590,  597,
     1042,  601,  597,  599, 1044,  570,  599, 1046,  575,  582,
     1048, 1050,  603,  605, 1052,  587, 1054,  601,  607,  593,
      601,  595,  609,  611,  613, 1056,  597, 1058,  603,  605,
      599,  603,  605,  615,  607,  617, 1060,  607,  609,  611,
      613,  609,  611,  613,  601, 1062, 1064, 1066, 1068,  615,
     1070,  617,  615,  619,  617,  603,  605, 1072,  621, 1074,
     1076,  607, 1078,  623,  625,  609,  611,  613,  627,  619,

      629, 1080,  619, 1082,  621,  631,  615,  621,  617,  623,
      625,  633,  623,  625,  627, 1084,  629,  627, 1086,  629,
     1088,  631, 1090,  635,  631, 1092,  619,  633,  637, 1094,
      633,  621, 1096,  639,  641, 1098,  623,  625, 1100,  635,
      643,  627,  635,  629,  637,  645,  647,  637,  631,  639,
      641,  649,  639,  641,  633, 1102,  643, 1104, 1106,  643,
     1108,  645,  647,  651,  645,  647,  635,  649,  653, 1110,
      649,  637, 1112, 1114,  655, 1116,  639,  641, 1118,  651,
      657,  659,  651,  643,  653,  661,  663,  653,  645,  647,
      655,  665, 1120,  655,  649, 1122,  657,  659, 1124,  657,

      659,  661,  663,  667,  661,  663,  651,  665, 1126, 1128,
      665,  653, 1130, 1132,  669, 1134,  671,  655, 1136,  667,
      673,  675,  667,  657,  659,  677,  679, 1138,  661,  663,
      669,  681,  671,  669,  665,  671,  673,  675, 1140,  673,
      675,  677,  679, 1142,  677,  679,  667,  681, 1144, 1146,
      681,  683, 1148, 1150, 1152, 1154,  685,  669, 1156,  671,
      687,  689,  691,  673,  675, 1158,  693,  683,  677,  679,
      683,  695,  685,  697,  681,  685,  687,  689,  691,  687,
      689,  691,  693, 1160, 1162,  693, 1164,  695, 1166,  697,
      695,  699,  697, 1168,  683, 1170,  701, 1172, 1174,  685,

     1176,  703,  705,  687,  689,  691,  707,  699,  709,  693,
      699, 1178,  701,  711,  695,  701,  697,  703,  705,  713,
      703,  705,  707, 1180,  709,  707, 1182,  709, 1184,  711,
     1186,  715,  711, 1188,  699,  713,  717, 1190,  713,  701,
     1192,  719,  721, 1194,  703,  705, 1196,  715,  723,  707,
      715,  709,  717,  725,  727,  717,  711,  719,  721,  729,
      719,  721,  713, 1198,  723, 1200, 1202,  723, 1204,  725,
      727,  731,  725,  727,  715,  729,  733, 1206,  729,  717,
     1208, 1210,  735, 1212,  719,  721, 1214,  731,  737,  739,
      731,  723,  733,  741,  743,  733,  725,  727,  735,  745,

     1216,  735,  729, 1218,  737,  739, 1220,  737,  739,  741,
      743,  747,  741,  743,  731,  745, 1222, 1224,  745,  733,
     1226, 1228,  749, 1230,  751,  735, 1232,  747,  753,  755,
      747,  737,  739,  757,  759, 1234,  741,  743,  749,  761,
      751,  749,  745,  751,  753,  755, 1236,  753,  755,  757,
      759, 1238,  757,  759,  747,  761, 1240, 1242,  761,  763,
     1244, 1246, 1248, 1250,  765,  749, 1252,  751,  767,  769,
      771,  753,  755, 1254,  773,  763,  757,  759,  763,  775,
      765,  777,  761,  765,  767,  769,  771,  767,  769,  771,
      773, 1256, 1258,  773, 1260,  775, 1262,  777,  775,  779,

      777, 1264,  763, 1266,  781, 1268, 1270,  765, 1272,  783,
      785,  767,  769,  771,  787,  779,  789,  773,  779, 1274,
      781,  791,  775,  781,  777,  783,  785,  793,  783,  785,
      787, 1276,  789,  787, 1278,  789, 1280,  791, 1282,  795,
      791, 1284,  779,  793,  797, 1286,  793,  781, 1288,  799,
      801, 1290,  783,  785, 1292,  795,  803,  787,  795,  789,
      797,  805,  807,  797,  791,  799,  801,  809,  799,  801,
      793, 1294,  803, 1296, 1298,  803, 1300,  805,  807,  811,
      805,  807,  795,  809,  813, 1302,  809,  797, 1304, 1306,
      815, 1308,  799,  801, 1310,  811,  817,  819,  811,  803,

      813,  821,  823,  813,  805,  807,  815,  825, 1312,  815,
      809, 1314,  817,  819, 1316,  817,  819,  821,  823,  827,
      821,  823,  811,  825, 1318, 1320,  825,  813, 1322, 1324,
      829, 1326,  831,  815, 1328,  827,  833,  835,  827,  817,
      819,  837,  839, 1330,  821,  823,  829,  841,  831,  829,
      825,  831,  833,  835, 1332,  833,  835,  837,  839, 1334,
      837,  839,  827,  841, 1336, 1338,  841,  843, 1340, 1342,
     1344, 1346,  845,  829, 1358,  831,  847,  849,  851,  833,
      835,  950,  853,  843,  837,  839,  843,  855,  845,  857,
      841,  845,  847,  849,  851,  847,  849,  851,  853,  948,

      946,  853,  944,  855,  942,  857,  855,  859,  857,  940,
      843,  938,  861,  936,  934,  845,  932,  863,  865,  847,
      849,  851,  867,  859,  869,  853,  859,  930,  861,  871,
      855,  861,  857,  863,  865,  873,  863,  865,  867,  928,
      869,  867,  926,  869,  924,  871,  922,  875,  871,  920,
      859,  873,  877,  918,  873,  861,  916,  879,  881,  914,
      863,  865,  912,  875,  883,  867,  875,  869,  877,  885,
      887,  877,  871,  879,  881,  889,  879,  881,  873,  910,
      883,  908,  906,  883,  904,  885,  887,  891,  885,  887,
      875,  889,  893,  902,  889,  877,  900,  898,  895,  896,

      879,  881,  894,  891,  897,  899,  891,  883,  893,  901,
      903,  893,  885,  887,  895,  905,  892,  895,  889,  890,
      897,  899,  888,  897,  899,  901,  903,  907,  901,  903,
      891,  905,  886,  884,  905,  893,  882,  880,  909,  878,
      911,  895,  876,  907,  913,  915,  907,  897,  899,  917,
      919,  874,  901,  903,  909,  921,  911,  909,  905,  911,
      913,  915,  872,  913,  915,  917,  919,  870,  917,  919,
      907,  921,  868,  866,  921,  923,  864,  862,  860,  858,
      925,  909,  856,  911,  927,  929,  931,  913,  915,  854,
      933,  923,  917,  919,  923,  935,  925,  937,  921,  925,

      927,  929,  931,  927,  929,  931,  933,  852,  850,  933,
      848,  935,  846,  937,  935,  939,  937,  844,  923,  842,
      941,  840,  838,  925,  836,  943,  945,  927,  929,  931,
      947,  939,  949,  933,  939,  834,  941,  951,  935,  941,
      937,  943,  945,  953,  943,  945,  947,  832,  949,  947,
      830,  949,  828,  951,  826,  955,  951,  824,  939,  953,
      957,  822,  953,  941,  820,  959,  961,  818,  943,  945,
      816,  955,  963,  947,  955,  949,  957,  965,  967,  957,
      951,  959,  961,  969,  959,  961,  953,  814,  963,  812,
      810,  963,  808,  965,  967,  971,  965,  967,  955,  969,

      973,  806,  969,  957,  804,  802,  975,  800,  959,  961,
      798,  971,  977,  979,  971,  963,  973,  981,  983,  973,
      965,  967,  975,  985,  796,  975,  969,  794,  977,  979,
      792,  977,  979,  981,  983,  987,  981,  983,  971,  985,
      790,  788,  985,  973,  786,  784,  989,  782,  991,  975,
      780,  987,  993,  995,  987,  977,  979,  997,  999,  778,
      981,  983,  989, 1001,  991,  989,  985,  991,  993,  995,
      776,  993,  995,  997,  999,  774,  997,  999,  987, 1001,
      772,  770, 1001, 1003,  768,  766,  764,  762, 1005,  989,
      760,  991, 1007, 1009, 1011,  993,  995,  758, 1013, 1003,

      997,  999, 1003, 1015, 1005, 1017, 1001, 1005, 1007, 1009,
     1011, 1007, 1009, 1011, 1013,  756,  754, 1013,  752, 1015,
      750, 1017, 1015, 1019, 1017,  748, 1003,  746, 1021,  744,
      742, 1005,  740, 1023, 1025, 1007, 1009, 1011, 1027, 1019,
     1029, 1013, 1019,  738, 1021, 1031, 1015, 1021, 1017, 1023,
     1025, 1033, 1023, 1025, 1027,  736, 1029, 1027,  734, 1029,
      732, 1031,  730, 1035, 1031,  728, 1019, 1033, 1037,  726,
     1033, 1021,  724, 1039, 1041,  722, 1023, 1025,  720, 1035,
     1043, 1027, 1035, 1029, 1037, 1045, 1047, 1037, 1031, 1039,
     1041, 1049, 1039, 1041, 1033,  718, 1043,  716,  714, 1043,

      712, 1045, 1047, 1051, 1045, 1047, 1035, 1049, 1053,  710,
     1049, 1037,  708,  706, 1055,  704, 1039, 1041,  702, 1051,
     1057, 1059, 1051, 1043, 1053, 1061, 1063, 1053, 1045, 1047,
     1055, 1065,  700, 1055, 1049,  698, 1057, 1059,  696, 1057,
     1059, 1061, 1063, 1067, 1061, 1063, 1051, 1065,  694,  692,
     1065, 1053,  690,  688, 1069,  686, 1071, 1055,  684, 1067,
     1073, 1075, 1067, 1057, 1059, 1077, 1079,  682, 1061, 1063,
     1069, 1081, 1071, 1069, 1065, 1071, 1073, 1075,  680, 1073,
     1075, 1077, 1079,  678, 1077, 1079, 1067, 1081,  676,  674,
     1081, 1083,  672,  670,  668,  666, 1085, 1069,  664, 1071,

     1087, 1089, 1091, 1073, 1075,  662, 1093, 1083, 1077, 1079,
     1083, 1095, 1085, 1097, 1081, 1085, 1087, 1089, 1091, 1087,
     1089, 1091, 1093,  660,  658, 1093,  656, 1095,  654, 1097,
     1095, 1099, 1097,  652, 1083,  650, 1101,  648,  646, 1085,
      644, 1103, 1105, 1087, 1089, 1091, 1107, 1099, 1109, 1093,
     1099,  642, 1101, 1111, 1095, 1101, 1097, 1103, 1105, 1113,
     1103, 1105, 1107,  640, 1109, 1107,  638, 1109,  636, 1111,
      634, 1115, 1111,  632, 1099, 1113, 1117,  630, 1113, 1101,
      628, 1119, 1121,  626, 1103, 1105,  624, 1115, 1123, 1107,
     1115, 1109, 1117, 1125, 1127, 1117, 1111, 1119, 1121, 1129,

     1119, 1121, 1113,  622, 1123,  620,  618, 1123,  616, 1125,
     1127, 1131, 1125, 1127, 1115, 1129, 1133,  614, 1129, 1117,
      612,  610, 1135,  608, 1119, 1121,  606, 1131, 1137, 1139,
     1131, 1123, 1133, 1141, 1143, 1133, 1125, 1127, 1135, 1145,
      604, 1135, 1129,  602, 1137, 1139,  600, 1137, 1139, 1141,
     1143, 1147, 1141, 1143, 1131, 1145,  598,  596, 1145, 1133,
      594,  592, 1149,  589, 1151, 1135,  588, 1147, 1153, 1155,
     1147, 1137, 1139, 1157, 1159,  586, 1141, 1143, 1149, 1161,
     1151, 1149, 1145, 1151, 1153, 1155,  584, 1153, 1155, 1157,
     1159,  583, 1157, 1159, 1147, 1161,  581,  580, 1161, 1163,

      579,  578,  577,  574, 1165, 1149,  573, 1151, 1167, 1169,
     1171, 1153, 1155,  572, 1173, 1163, 1157, 1159, 1163, 1175,
     1165, 1177, 1161, 1165, 1167, 1169, 1171, 1167, 1169, 1171,
     1173,  571,  567, 1173,  564, 1175,  562, 1177, 1175, 1179,
     1177,  560, 1163,  558, 1181,  557,  556, 1165,  554, 1183,
     1185, 1167, 1169, 1171, 1187, 1179, 1189, 1173, 1179,  553,
     1181, 1191, 1175, 1181, 1177, 1183, 1185, 1193, 1183, 1185,
     1187,  552, 1189, 1187,  550, 1189,  549, 1191,  548, 1195,
     1191,  546, 1179, 1193, 1197,  541, 1193, 1181,  540, 1199,
     1201,  538, 1183, 1185,  537, 1195, 1203, 1187, 1195, 1189,

     1197, 1205, 1207, 1197, 1191, 1199, 1201, 1209, 1199, 1201,
     1193,  536, 1203,  535,  534, 1203,  533, 1205, 1207, 1211,
     1205, 1207, 1195, 1209, 1213,  532, 1209, 1197,  530,  529,
     1215,  528, 1199, 1201,  527, 1211, 1217, 1219, 1211, 1203,
     1213, 1221, 1223, 1213, 1205, 1207, 1215, 1225,  524, 1215,
     1209,  523, 1217, 1219,  522, 1217, 1219, 1221, 1223, 1227,
     1221, 1223, 1211, 1225,  520,  519, 1225, 1213,  518,  517,
     1229,  515, 1231, 1215,  514, 1227, 1233, 1235, 1227, 1217,
     1219, 1237, 1239,  513, 1221, 1223, 1229, 1241, 1231, 1229,
     1225, 1231, 1233, 1235,  510, 1233, 1235, 1237, 1239,  509,

     1237, 1239, 1227, 1241,  507,  506, 1241, 1243,  505,  504,
      501,  500, 1245, 1229,  499, 1231, 1247, 1249, 1251, 1233,
     1235,  497, 1253, 1243, 1237, 1239, 1243, 1255, 1245, 1257,
     1241, 1245, 1247, 1249, 1251, 1247, 1249, 1251, 1253,  495,
      493, 1253,  484, 1255,  482, 1257, 1255, 1259, 1257,  481,
     1243,  480, 1261,  479,  478, 1245,  475, 1263, 1265, 1247,
     1249, 1251, 1267, 1259, 1269, 1253, 1259,  474, 1261, 1271,
     1255, 1261, 1257, 1263, 1265, 1273, 1263, 1265, 1267,  473,
     1269, 1267,  472, 1269,  469, 1271,  468, 1275, 1271,  467,
     1259, 1273, 1277,  466, 1273, 1261,  465, 1279, 1281,  464,

     1263, 1265,  463, 1275, 1283, 1267, 1275, 1269, 1277, 1285,
     1287, 1277, 1271, 1279, 1281, 1289, 1279, 1281, 1273,  458,
     1283,  457,  453, 1283,  451, 1285, 1287, 1291, 1285, 1287,
     1275, 1289, 1293,  447, 1289, 1277,  446,  445, 1295,  443,
     1279, 1281,  442, 1291, 1297, 1299, 1291, 1283, 1293, 1301,
     1303, 1293, 1285, 1287, 1295, 1305,  441, 1295, 1289,  440,
     1297, 1299,  439, 1297, 1299, 1301, 1303, 1307, 1301, 1303,
     1291, 1305,  438,  437, 1305, 1293,  435,  434, 1309,  433,
     1311, 1295,  432, 1307, 1313, 1315, 1307, 1297, 1299, 1317,
     1319,  431, 1301, 1303, 1309, 1321, 1311, 1309, 1305, 1311,

     1313, 1315,  430, 1313, 1315, 1317, 1319,  429, 1317, 1319,
     1307, 1321,  428,  427, 1321, 1323,  425,  422,  421,  420,
     1325, 1309,  419, 1311, 1327, 1329, 1331, 1313, 1315,  415,
     1333, 1323, 1317, 1319, 1323, 1335, 1325, 1337, 1321, 1325,
     1327, 1329, 1331, 1327, 1329, 1331, 1333,  414,  413, 1333,
      410, 1335,  407, 1337, 1335, 1339, 1337,  406, 1323,  405,
     1341,  404,  402, 1325,  400, 1343, 1345, 1327, 1329, 1331,
     1347, 1339, 1349, 1333, 1339,  399, 1341,  398, 1335, 1341,
     1337, 1343, 1345,  397, 1343, 1345, 1347,  396, 1349, 1347,
      395, 1349,  394,  392,  391,  389,  388,  387, 1339,  386,

      383,  380,  379, 1341,  378,  377,  375,  373, 1343, 1345,
      372,  371,  369, 1347,  368, 1349, 1351, 1351, 1351, 1351,
     1351, 1351, 1351, 1351, 1351, 1351, 1351, 1351, 1352, 1352,
     1352, 1352, 1352, 1352, 1352, 1352, 1352, 1352, 1352, 1352,
     1353, 1353, 1353, 1353, 1353, 1353, 1353, 1353, 1353, 1353,
     1353, 1353, 1354, 1354, 1354, 1354, 1354, 1354, 1354, 1354,
     1354, 1354, 1354, 1354, 1355, 1355, 1355, 1355, 1355, 1355,
     1355, 1355, 1355, 1355, 1355, 1355, 1356, 1356, 1356, 1356,
     1356, 1356, 1356, 1356, 1356, 1356,  365, 1356, 1357, 1357,
     1357, 1357,  364, 1357, 1357, 1357, 1357, 1357, 1357, 1357,

     1359, 1359, 1359, 1359, 1359, 1359, 1359, 1359, 1359, 1359,
     1359, 1359, 1360,  362,  361, 1360, 1361, 1361, 1361,  358,
     1361, 1361, 1361,  355, 1361, 1361, 1362, 1362, 1362, 1362,
     1362, 1362, 1362, 1362, 1362, 1362, 1362, 1362, 1363,  354,
      353, 1363, 1364, 1364, 1364, 1364, 1364, 1364,  352, 1364,
     1364, 1364, 1364, 1364, 1365,  351,  350,  349,  348,  346,
     1365, 1365,  345, 1365, 1366,  344,  343, 1366, 1367,  342,
      341, 1367, 1368, 1368, 1368, 1368, 1368, 1368, 1368,  338,
     1368, 1368, 1368, 1368, 1369, 1369,  337, 1369, 1369,  336,
     1369, 1369, 1369, 1369, 1369, 1369, 1370, 1370, 1370, 1370,

     1370, 1370, 1370, 1370, 1370, 1370, 1370, 1370, 1371,  335,
      334, 1371, 1372, 1372, 1372, 1372, 1372, 1372, 1372, 1372,
     1372, 1372, 1372, 1372, 1373,  333,  332,  330,  329,  328,
      327,  326,  325,  323, 1373, 1374, 1374, 1374, 1374, 1374,
     1374, 1374, 1374, 1374, 1374, 1374, 1374, 1375,  322,  321,
      320,  319,  318, 1375,  316,  315, 1375, 1376, 1376, 1376,
     1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1376, 1377,
     1377, 1377, 1377, 1377, 1377, 1377, 1377, 1377, 1377, 1377,
     1377, 1378, 1378, 1378, 1378, 1378, 1378, 1378, 1378, 1378,
     1378, 1378, 1378, 1379, 1379, 1379, 1379, 1379, 1379, 1379,

     1379, 1379, 1379, 1379, 1379, 1380, 1380, 1380, 1380, 1380,
     1380, 1380, 1380, 1380, 1380, 1380, 1380, 1381, 1381, 1381,
     1381, 1381, 1381, 1381, 1381, 1381, 1381, 1381, 1381, 1382,
     1382, 1382, 1382, 1382, 1382, 1382, 1382, 1382, 1382, 1382,
     1382, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383, 1383,
     1383, 1383, 1383, 1384, 1384, 1384, 1384, 1384, 1384, 1384,
     1384, 1384, 1384, 1384, 1384, 1385, 1385, 1385, 1385, 1385,
     1385, 1385, 1385, 1385, 1385, 1385, 1385, 1386, 1386, 1386,
     1386, 1386, 1386, 1386, 1386, 1386, 1386, 1386, 1386, 1387,
     1387, 1387, 1387, 1387, 1387, 1387, 1387, 1387, 1387, 1387,

     1387, 1388, 1388, 1388, 1388, 1388, 1388, 1388, 1388, 1388,
     1388, 1388, 1388, 1389, 1389, 1389, 1389, 1389, 1389, 1389,
     1389, 1389, 1389, 1389, 1389, 1390, 1390, 1390, 1390, 1390,
     1390, 1390, 1390, 1390, 1390, 1390, 1390, 1391, 1391, 1391,
     1391, 1391, 1391, 1391, 1391, 1391, 1391, 1391, 1391, 1392,
     1392, 1392, 1392, 1392, 1392, 1392, 1392, 1392, 1392, 1392,
     1392, 1393, 1393, 1393, 1393, 1393, 1393, 1393, 1393, 1393,
     1393, 1393, 1393, 1394, 1394, 1394, 1394, 1394, 1394, 1394,
     1394, 1394, 1394, 1394, 1394, 1395, 1395, 1395, 1395, 1395,
     1395, 1395, 1395, 1395, 1395, 1395, 1395, 1396, 1396, 1396,

     1396, 1396, 1396, 1396, 1396, 1396, 1396, 1396, 1396, 1397,
     1397, 1397, 1397, 1397, 1397, 1397, 1397, 1397, 1397, 1397,
     1397, 1398, 1398, 1398, 1398, 1398, 1398, 1398, 1398, 1398,
     1398, 1398, 1398, 1399, 1399, 1399, 1399, 1399, 1399, 1399,
     1399, 1399, 1399, 1399, 1399, 1400, 1400, 1400, 1400, 1400,
     1400, 1400, 1400, 1400, 1400, 1400, 1400, 1401, 1401, 1401,
     1401, 1401, 1401, 1401, 1401, 1401, 1401, 1401, 1401, 1402,
     1402, 1402, 1402, 1402, 1402, 1402, 1402, 1402, 1402, 1402,
     1402, 1403, 1403, 1403, 1403, 1403, 1403, 1403, 1403, 1403,
     1403, 1403, 1403, 1404, 1404, 1404, 1404, 1404, 1404, 1404,

     1404, 1404, 1404, 1404, 1404, 1405, 1405, 1405, 1405, 1405,
     1405, 1405, 1405, 1405, 1405, 1405, 1405, 1406, 1406, 1406,
     1406, 1406, 1406, 1406, 1406, 1406, 1406, 1406, 1406, 1407,
     1407, 1407, 1407, 1407, 1407, 1407, 1407, 1407, 1407, 1407,
     1407, 1408, 1408, 1408, 1408, 1408, 1408, 1408, 1408, 1408,
     1408, 1408, 1408, 1409, 1409, 1409, 1409, 1409, 1409, 1409,
     1409, 1409, 1409, 1409, 1409, 1410, 1410, 1410, 1410, 1410,
     1410, 1410, 1410, 1410, 1410, 1410, 1410, 1411, 1411, 1411,
     1411, 1411, 1411, 1411, 1411, 1411, 1411, 1411, 1411, 1412,
     1412, 1412, 1412, 1412, 1412, 1412, 1412, 1412, 1412, 1412,

     1412, 1413, 1413, 1413, 1413, 1413, 1413, 1413, 1413, 1413,
     1413, 1413, 1413, 1414, 1414, 1414, 1414, 1414, 1414, 1414,
     1414, 1414, 1414, 1414, 1414, 1415, 1415, 1415, 1415, 1415,
     1415, 1415, 1415, 1415, 1415, 1415, 1415, 1416, 1416, 1416,
     1416, 1416, 1416, 1416, 1416, 1416, 1416, 1416, 1416, 1417,
     1417, 1417, 1417, 1417, 1417, 1417, 1417, 1417, 1417, 1417,
     1417, 1418, 1418, 1418, 1418, 1418, 1418, 1418, 1418, 1418,
     1418, 1418, 1418, 1419, 1419, 1419, 1419, 1419, 1419, 1419,
     1419, 1419, 1419, 1419, 1419, 1420, 1420, 1420, 1420, 1420,
     1420, 1420, 1420, 1420, 1420, 1420, 1420, 1421, 1421, 1421,

     1421, 1421, 1421, 1421, 1421, 1421, 1421, 1421, 1421, 1422,
     1422, 1422, 1422, 1422, 1422, 1422, 1422, 1422, 1422, 1422,
     1422, 1423, 1423, 1423, 1423, 1423, 1423, 1423, 1423, 1423,
     1423, 1423, 1423, 1424, 1424, 1424, 1424, 1424, 1424, 1424,
     1424, 1424, 1424, 1424, 1424, 1425, 1425, 1425, 1425, 1425,
     1425, 1425, 1425, 1425, 1425, 1425, 1425, 1426, 1426, 1426,
     1426, 1426, 1426, 1426, 1426, 1426, 1426, 1426, 1426, 1427,
     1427, 1427, 1427, 1427, 1427, 1427, 1427, 1427, 1427, 1427,
     1427, 1428, 1428, 1428, 1428, 1428, 1428, 1428, 1428, 1428,
     1428, 1428, 1428, 1429, 1429, 1429, 1429, 1429, 1429, 1429,

     1429, 1429, 1429, 1429, 1429, 1430, 1430, 1430, 1430, 1430,
     1430, 1430, 1430, 1430, 1430, 1430, 1430, 1431, 1431, 1431,
     1431, 1431, 1431, 1431, 1431, 1431, 1431, 1431, 1431, 1432,
     1432, 1432, 1432, 1432, 1432, 1432, 1432, 1432, 1432, 1432,
     1432, 1433, 1433, 1433, 1433, 1433, 1433, 1433, 1433, 1433,
     1433, 1433, 1433, 1434, 1434, 1434, 1434, 1434, 1434, 1434,
     1434, 1434, 1434, 1434, 1434, 1435, 1435, 1435, 1435, 1435,
     1435, 1435, 1435, 1435, 1435, 1435, 1435, 1436, 1436, 1436,
     1436, 1436, 1436, 1436, 1436, 1436, 1436, 1436, 1436, 1437,
     1437, 1437, 1437, 1437, 1437, 1437, 1437, 1437, 1437, 1437,

     1437, 1438, 1438, 1438, 1438, 1438, 1438, 1438, 1438, 1438,
     1438, 1438, 1438, 1439, 1439, 1439, 1439, 1439, 1439, 1439,
     1439, 1439, 1439, 1439, 1439, 1440, 1440, 1440, 1440, 1440,
     1440, 1440, 1440, 1440, 1440, 1440, 1440, 1441, 1441, 1441,
     1441, 1441, 1441, 1441, 1441, 1441, 1441, 1441, 1441, 1442,
     1442, 1442, 1442, 1442, 1442, 1442, 1442, 1442, 1442, 1442,
     1442, 1443, 1443, 1443, 1443, 1443, 1443, 1443, 1443, 1443,
     1443, 1443, 1443, 1444, 1444, 1444, 1444, 1444, 1444, 1444,
     1444, 1444, 1444, 1444, 1444, 1445, 1445, 1445, 1445, 1445,
     1445, 1445, 1445, 1445, 1445, 1445, 1445, 1446, 1446, 1446,

     1446, 1446, 1446, 1446, 1446, 1446, 1446, 1446, 1446, 1447,
     1447, 1447, 1447, 1447, 1447, 1447, 1447, 1447, 1447, 1447,
     1447, 1448, 1448, 1448, 1448, 1448, 1448, 1448, 1448, 1448,
     1448, 1448, 1448, 1449, 1449, 1449, 1449, 1449, 1449, 1449,
     1449, 1449, 1449, 1449, 1449, 1450, 1450, 1450, 1450, 1450,
     1450, 1450, 1450, 1450, 1450, 1450, 1450, 1451, 1451, 1451,
     1451, 1451, 1451, 1451, 1451, 1451, 1451, 1451, 1451, 1452,
     1452, 1452, 1452, 1452, 1452, 1452, 1452, 1452, 1452, 1452,
     1452, 1453, 1453, 1453, 1453, 1453, 1453, 1453, 1453, 1453,
     1453, 1453, 1453, 1454, 1454, 1454, 1454, 1454, 1454, 1454,

     1454, 1454, 1454, 1454, 1454, 1455, 1455, 1455, 1455, 1455,
     1455, 1455, 1455, 1455, 1455, 1455, 1455, 1456, 1456, 1456,
     1456, 1456, 1456, 1456, 1456, 1456, 1456, 1456, 1456, 1457,
     1457, 1457, 1457, 1457, 1457, 1457, 1457, 1457, 1457, 1457,
     1457, 1458, 1458, 1458, 1458, 1458, 1458, 1458, 1458, 1458,
     1458, 1458, 1458, 1459, 1459, 1459, 1459, 1459, 1459, 1459,
     1459, 1459, 1459, 1459, 1459, 1460, 1460, 1460, 1460, 1460,
     1460, 1460, 1460, 1460, 1460, 1460, 1460, 1461, 1461, 1461,
     1461, 1461, 1461, 1461, 1461, 1461, 1461, 1461, 1461, 1462,
     1462, 1462, 1462, 1462, 1462, 1462, 1462, 1462, 1462, 1462,

     1462, 1463, 1463, 1463, 1463, 1463, 1463, 1463, 1463, 1463,
     1463, 1463, 1463, 1464, 1464, 1464, 1464, 1464, 1464, 1464,
     1464, 1464, 1464, 1464, 1464, 1465, 1465, 1465, 1465, 1465,
     1465, 1465, 1465, 1465, 1465, 1465, 1465, 1466, 1466, 1466,
     1466, 1466, 1466, 1466, 1466, 1466, 1466, 1466, 1466, 1467,
     1467, 1467, 1467, 1467, 1467, 1467, 1467, 1467, 1467, 1467,
     1467, 1468, 1468, 1468, 1468, 1468, 1468, 1468, 1468, 1468,
     1468, 1468, 1468, 1469, 1469, 1469, 1469, 1469, 1469, 1469,
     1469, 1469, 1469, 1469, 1469, 1470, 1470, 1470, 1470, 1470,
     1470, 1470, 1470, 1470, 1470, 1470, 1470, 1471, 1471, 1471,

     1471, 1471, 1471, 1471, 1471, 1471, 1471, 1471, 1471, 1472,
     1472, 1472, 1472, 1472, 1472, 1472, 1472, 1472, 1472, 1472,
     1472, 1473, 1473, 1473, 1473, 1473, 1473, 1473, 1473, 1473,
     1473, 1473, 1473, 1474, 1474, 1474, 1474, 1474, 1474, 1474,
     1474, 1474, 1474, 1474, 1474, 1475, 1475, 1475, 1475, 1475,
     1475, 1475, 1475, 1475, 1475, 1475, 1475, 1476, 1476, 1476,
     1476, 1476, 1476, 1476, 1476, 1476, 1476, 1476, 1476, 1477,
     1477, 1477, 1477, 1477, 1477, 1477, 1477, 1477, 1477, 1477,
     1477, 1478, 1478, 1478, 1478, 1478, 1478, 1478, 1478, 1478,
     1478, 1478, 1478, 1479, 1479, 1479, 1479, 1479, 1479, 1479,

     1479, 1479, 1479, 1479, 1479, 1480, 1480, 1480, 1480, 1480,
     1480, 1480, 1480, 1480, 1480, 1480, 1480, 1481, 1481, 1481,
     1481, 1481, 1481, 1481, 1481, 1481, 1481, 1481, 1481, 1482,
     1482, 1482, 1482, 1482, 1482, 1482, 1482, 1482, 1482, 1482,
     1482, 1483, 1483, 1483, 1483, 1483, 1483, 1483, 1483, 1483,
     1483, 1483, 1483, 1484, 1484, 1484, 1484, 1484, 1484, 1484,
     1484, 1484, 1484, 1484, 1484, 1485, 1485, 1485, 1485, 1485,
     1485, 1485, 1485, 1485, 1485, 1485, 1485, 1486, 1486, 1486,
     1486, 1486, 1486, 1486, 1486, 1486, 1486, 1486, 1486, 1487,
     1487, 1487, 1487, 1487, 1487, 1487, 1487, 1487, 1487, 1487,

     1487, 1488, 1488, 1488, 1488, 1488, 1488, 1488, 1488, 1488,
     1488, 1488, 1488, 1489, 1489, 1489, 1489, 1489, 1489, 1489,
     1489, 1489, 1489, 1489, 1489, 1490, 1490, 1490, 1490, 1490,
     1490, 1490, 1490, 1490, 1490, 1490, 1490, 1491, 1491, 1491,
     1491, 1491, 1491, 1491, 1491, 1491, 1491, 1491, 1491, 1492,
     1492, 1492, 1492, 1492, 1492, 1492, 1492, 1492, 1492, 1492,
     1492, 1493, 1493, 1493, 1493, 1493, 1493, 1493, 1493, 1493,
     1493, 1493, 1493, 1494, 1494, 1494, 1494, 1494, 1494, 1494,
     1494, 1494, 1494, 1494, 1494, 1495, 1495, 1495, 1495, 1495,
     1495, 1495, 1495, 1495, 1495, 1495, 1495, 1496, 1496, 1496,

     1496, 1496, 1496, 1496, 1496, 1496, 1496, 1496, 1496, 1497,
     1497, 1497, 1497, 1497, 1497, 1497, 1497, 1497, 1497, 1497,
     1497, 1498, 1498, 1498, 1498, 1498, 1498, 1498, 1498, 1498,
     1498, 1498, 1498, 1499, 1499, 1499, 1499, 1499, 1499, 1499,
     1499, 1499, 1499, 1499, 1499, 1500, 1500, 1500, 1500, 1500,
     1500, 1500, 1500, 1500, 1500, 1500, 1500, 1501, 1501, 1501,
     1501, 1501, 1501, 1501, 1501, 1501, 1501, 1501, 1501, 1502,
     1502, 1502, 1502, 1502, 1502, 1502, 1502, 1502, 1502, 1502,
     1502, 1503, 1503, 1503, 1503, 1503, 1503, 1503, 1503, 1503,
     1503, 1503, 1503, 1504, 1504, 1504, 1504, 1504, 1504, 1504,

     1504, 1504, 1504, 1504, 1504, 1505, 1505, 1505, 1505, 1505,
     1505, 1505, 1505, 1505, 1505, 1505, 1505, 1506, 1506, 1506,
     1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1506, 1507,
     1507, 1507, 1507, 1507, 1507, 1507, 1507, 1507, 1507, 1507,
     1507, 1508, 1508, 1508, 1508, 1508, 1508, 1508, 1508, 1508,
     1508, 1508, 1508, 1509, 1509, 1509, 1509, 1509, 1509, 1509,
     1509, 1509, 1509, 1509, 1509, 1510, 1510, 1510, 1510, 1510,
     1510, 1510, 1510, 1510, 1510, 1510, 1510, 1511, 1511, 1511,
     1511, 1511, 1511, 1511, 1511, 1511, 1511, 1511, 1511, 1512,
     1512, 1512, 1512, 1512, 1512, 1512, 1512, 1512, 1512, 1512,

     1512, 1513, 1513, 1513, 1513, 1513, 1513, 1513, 1513, 1513,
     1513, 1513, 1513, 1514, 1514, 1514, 1514, 1514, 1514, 1514,
     1514, 1514, 1514, 1514, 1514, 1515, 1515, 1515, 1515, 1515,
     1515, 1515, 1515, 1515, 1515, 1515, 1515, 1516, 1516, 1516,
     1516, 1516, 1516, 1516, 1516, 1516, 1516, 1516, 1516, 1517,
     1517, 1517, 1517, 1517, 1517, 1517, 1517, 1517, 1517, 1517,
     1517, 1518, 1518, 1518, 1518, 1518, 1518, 1518, 1518, 1518,
     1518, 1518, 1518, 1519, 1519, 1519, 1519, 1519, 1519, 1519,
     1519, 1519, 1519, 1519, 1519, 1520, 1520, 1520, 1520, 1520,
     1520, 1520, 1520, 1520, 1520, 1520, 1520, 1521, 1521, 1521,

     1521, 1521, 1521, 1521, 1521, 1521, 1521, 1521, 1521, 1522,
     1522, 1522, 1522, 1522, 1522, 1522, 1522, 1522, 1522, 1522,
     1522, 1523, 1523, 1523, 1523, 1523, 1523, 1523, 1523, 1523,
     1523, 1523, 1523, 1524, 1524, 1524, 1524, 1524, 1524, 1524,
     1524, 1524, 1524, 1524, 1524, 1525, 1525, 1525, 1525, 1525,
     1525, 1525, 1525, 1525, 1525, 1525, 1525, 1526, 1526, 1526,
     1526, 1526, 1526, 1526, 1526, 1526, 1526, 1526, 1526, 1527,
     1527, 1527, 1527, 1527, 1527, 1527, 1527, 1527, 1527, 1527,
     1527, 1528, 1528, 1528, 1528, 1528, 1528, 1528, 1528, 1528,
     1528, 1528, 1528, 1529, 1529, 1529, 1529, 1529, 1529, 1529,

     1529, 1529, 1529, 1529, 1529, 1530, 1530, 1530, 1530, 1530,
     1530, 1530, 1530, 1530, 1530, 1530, 1530, 1531, 1531, 1531,
     1531, 1531, 1531, 1531, 1531, 1531, 1531, 1531, 1531, 1532,
     1532, 1532, 1532, 1532, 1532, 1532, 1532, 1532, 1532, 1532,
     1532, 1533, 1533, 1533, 1533, 1533, 1533, 1533, 1533, 1533,
     1533, 1533, 1533, 1534, 1534, 1534, 1534, 1534, 1534, 1534,
     1534, 1534, 1534, 1534, 1534, 1535, 1535, 1535, 1535, 1535,
     1535, 1535, 1535, 1535, 1535, 1535, 1535, 1536, 1536, 1536,
     1536, 1536, 1536, 1536, 1536, 1536, 1536, 1536, 1536, 1537,
     1537, 1537, 1537, 1537, 1537, 1537, 1537, 1537, 1537, 1537,

     1537, 1538, 1538, 1538, 1538, 1538, 1538, 1538, 1538, 1538,
     1538, 1538, 1538, 1539, 1539, 1539, 1539, 1539, 1539, 1539,
     1539, 1539, 1539, 1539, 1539, 1540, 1540, 1540, 1540, 1540,
     1540, 1540, 1540, 1540, 1540, 1540, 1540, 1541, 1541, 1541,
     1541, 1541, 1541, 1541, 1541, 1541, 1541, 1541, 1541, 1542,
     1542, 1542, 1542, 1542, 1542, 1542, 1542, 1542, 1542, 1542,
     1542, 1543, 1543, 1543, 1543, 1543, 1543, 1543, 1543, 1543,
     1543, 1543, 1543, 1544, 1544, 1544, 1544, 1544, 1544, 1544,
     1544, 1544, 1544, 1544, 1544, 1545, 1545, 1545, 1545, 1545,
     1545, 1545, 1545, 1545, 1545, 1545, 1545, 1546, 1546, 1546,

     1546, 1546, 1546, 1546, 1546, 1546, 1546, 1546, 1546, 1547,
     1547, 1547, 1547, 1547, 1547, 1547, 1547, 1547, 1547, 1547,
     1547, 1548, 1548, 1548, 1548, 1548, 1548, 1548, 1548, 1548,
     1548, 1548, 1548, 1549, 1549, 1549, 1549, 1549, 1549, 1549,
     1549, 1549, 1549, 1549, 1549, 1550, 1550, 1550, 1550, 1550,
     1550, 1550, 1550, 1550, 1550, 1550, 1550, 1551, 1551, 1551,
     1551, 1551, 1551, 1551, 1551, 1551, 1551, 1551, 1551, 1552,
     1552, 1552, 1552, 1552, 1552, 1552, 1552, 1552, 1552, 1552,
     1552, 1553, 1553, 1553, 1553, 1553, 1553, 1553, 1553, 1553,
     1553, 1553, 1553, 1554, 1554, 1554, 1554, 1554, 1554, 1554,

     1554, 1554, 1554, 1554, 1554, 1555, 1555, 1555, 1555, 1555,
     1555, 1555, 1555, 1555, 1555, 1555, 1555, 1556, 1556, 1556,
     1556, 1556, 1556, 1556, 1556, 1556, 1556, 1556, 1556, 1557,
     1557, 1557, 1557, 1557, 1557, 1557, 1557, 1557, 1557, 1557,
     1557, 1558, 1558, 1558, 1558, 1558, 1558, 1558, 1558, 1558,
     1558, 1558, 1558, 1559, 1559, 1559, 1559, 1559, 1559, 1559,
     1559, 1559, 1559, 1559, 1559, 1560, 1560, 1560, 1560, 1560,
     1560, 1560, 1560, 1560, 1560, 1560, 1560, 1561, 1561, 1561,
     1561, 1561, 1561, 1561, 1561, 1561, 1561, 1561, 1561, 1562,
     1562, 1562, 1562, 1562, 1562, 1562, 1562, 1562, 1562, 1562,

     1562, 1563, 1563, 1563, 1563, 1563, 1563, 1563, 1563, 1563,
     1563, 1563, 1563, 1564, 1564, 1564, 1564, 1564, 1564, 1564,
     1564, 1564, 1564, 1564, 1564, 1565, 1565, 1565, 1565, 1565,
     1565, 1565, 1565, 1565, 1565, 1565, 1565, 1566, 1566, 1566,
     1566, 1566, 1566, 1566, 1566, 1566, 1566, 1566, 1566, 1567,
     1567, 1567, 1567, 1567, 1567, 1567, 1567, 1567, 1567, 1567,
     1567, 1568, 1568, 1568, 1568, 1568, 1568, 1568, 1568, 1568,
     1568, 1568, 1568, 1569, 1569, 1569, 1569, 1569, 1569, 1569,
     1569, 1569, 1569, 1569, 1569, 1570, 1570, 1570, 1570, 1570,
     1570, 1570, 1570, 1570, 1570, 1570, 1570, 1571, 1571, 1571,

     1571, 1571, 1571, 1571, 1571, 1571, 1571, 1571, 1571, 1572,
     1572, 1572, 1572, 1572, 1572, 1572, 1572, 1572, 1572, 1572,
     1572, 1573, 1573, 1573, 1573, 1573, 1573, 1573, 1573, 1573,
     1573, 1573, 1573, 1574, 1574, 1574, 1574, 1574, 1574, 1574,
     1574, 1574, 1574, 1574, 1574, 1575, 1575, 1575, 1575, 1575,
     1575, 1575, 1575, 1575, 1575, 1575, 1575, 1576, 1576, 1576,
     1576, 1576, 1576, 1576, 1576, 1576, 1576, 1576, 1576, 1577,
     1577, 1577, 1577, 1577, 1577, 1577, 1577, 1577, 1577, 1577,
     1577, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578, 1578,
     1578, 1578, 1578, 1579, 1579, 1579, 1579, 1579, 1579, 1579,

     1579, 1579, 1579, 1579, 1579, 1580, 1580, 1580, 1580, 1580,
     1580, 1580, 1580, 1580, 1580, 1580, 1580, 1581, 1581, 1581,
     1581, 1581, 1581, 1581, 1581, 1581, 1581, 1581, 1581, 1582,
     1582, 1582, 1582, 1582, 1582, 1582, 1582, 1582, 1582, 1582,
     1582, 1583, 1583, 1583, 1583, 1583, 1583, 1583, 1583, 1583,
     1583, 1583, 1583, 1584, 1584, 1584, 1584, 1584, 1584, 1584,
     1584, 1584, 1584, 1584, 1584, 1585, 1585, 1585, 1585, 1585,
     1585, 1585, 1585, 1585, 1585, 1585, 1585, 1586, 1586, 1586,
     1586, 1586, 1586, 1586, 1586, 1586, 1586, 1586, 1586, 1587,
     1587, 1587, 1587, 1587, 1587, 1587, 1587, 1587, 1587, 1587,

     1587, 1588, 1588, 1588, 1588, 1588, 1588, 1588, 1588, 1588,
     1588, 1588, 1588, 1589, 1589, 1589, 1589, 1589, 1589, 1589,
     1589, 1589, 1589, 1589, 1589, 1590, 1590, 1590, 1590, 1590,
     1590, 1590, 1590, 1590, 1590, 1590, 1590, 1591, 1591, 1591,
     1591, 1591, 1591, 1591, 1591, 1591, 1591, 1591, 1591, 1592,
     1592, 1592, 1592, 1592, 1592, 1592, 1592, 1592, 1592, 1592,
     1592, 1593, 1593, 1593, 1593, 1593, 1593, 1593, 1593, 1593,
     1593, 1593, 1593, 1594, 1594, 1594, 1594, 1594, 1594, 1594,
     1594, 1594, 1594, 1594, 1594, 1595, 1595, 1595, 1595, 1595,
     1595, 1595, 1595, 1595, 1595, 1595, 1595, 1596, 1596, 1596,

     1596, 1596, 1596, 1596, 1596, 1596, 1596, 1596, 1596, 1597,
     1597, 1597, 1597, 1597, 1597, 1597, 1597, 1597, 1597, 1597,
     1597, 1598, 1598, 1598, 1598, 1598, 1598, 1598, 1598, 1598,
     1598, 1598, 1598, 1599, 1599, 1599, 1599, 1599, 1599, 1599,
     1599, 1599, 1599, 1599, 1599, 1600, 1600, 1600, 1600, 1600,
     1600, 1600, 1600, 1600, 1600, 1600, 1600, 1601, 1601, 1601,
     1601, 1601, 1601, 1601, 1601, 1601, 1601, 1601, 1601, 1602,
     1602, 1602, 1602, 1602, 1602, 1602, 1602, 1602, 1602, 1602,
     1602, 1603, 1603, 1603, 1603, 1603, 1603, 1603, 1603, 1603,
     1603, 1603, 1603, 1604, 1604, 1604, 1604, 1604, 1604, 1604,

     1604, 1604, 1604, 1604, 1604, 1605, 1605, 1605, 1605, 1605,
     1605, 1605, 1605, 1605, 1605, 1605, 1605, 1606, 1606, 1606,
     1606, 1606, 1606, 1606, 1606, 1606, 1606, 1606, 1606, 1607,
     1607, 1607, 1607, 1607, 1607, 1607, 1607, 1607, 1607, 1607,
     1607, 1608, 1608, 1608, 1608, 1608, 1608, 1608, 1608, 1608,
     1608, 1608, 1608, 1609, 1609, 1609, 1609, 1609, 1609, 1609,
     1609, 1609, 1609, 1609, 1609, 1610, 1610, 1610, 1610, 1610,
     1610, 1610, 1610, 1610, 1610, 1610, 1610, 1611, 1611, 1611,
     1611, 1611, 1611, 1611, 1611, 1611, 1611, 1611, 1611, 1612,
     1612, 1612, 1612, 1612, 1612, 1612, 1612, 1612, 1612, 1612,

     1612, 1613, 1613, 1613, 1613, 1613, 1613, 1613, 1613, 1613,
     1613, 1613, 1613, 1614, 1614, 1614, 1614, 1614, 1614, 1614,
     1614, 1614, 1614, 1614, 1614, 1615, 1615, 1615, 1615, 1615,
     1615, 1615, 1615, 1615, 1615, 1615, 1615, 1616, 1616, 1616,
     1616, 1616, 1616, 1616, 1616, 1616, 1616, 1616, 1616, 1617,
     1617, 1617, 1617, 1617, 1617, 1617, 1617, 1617, 1617, 1617,
     1617, 1618, 1618, 1618, 1618, 1618, 1618, 1618, 1618, 1618,
     1618, 1618, 1618, 1619, 1619, 1619, 1619, 1619, 1619, 1619,
     1619, 1619, 1619, 1619, 1619, 1620, 1620, 1620, 1620, 1620,
     1620, 1620, 1620, 1620, 1620, 1620, 1620, 1621, 1621, 1621,

     1621, 1621, 1621, 1621, 1621, 1621, 1621, 1621, 1621, 1622,
     1622, 1622, 1622, 1622, 1622, 1622, 1622, 1622, 1622, 1622,
     1622, 1623, 1623, 1623, 1623, 1623, 1623, 1623, 1623, 1623,
     1623, 1623, 1623, 1624, 1624, 1624, 1624, 1624, 1624, 1624,
     1624, 1624, 1624, 1624, 1624, 1625, 1625, 1625, 1625, 1625,
     1625, 1625, 1625, 1625, 1625, 1625, 1625, 1626, 1626, 1626,
     1626, 1626, 1626, 1626, 1626, 1626, 1626, 1626, 1626, 1627,
     1627, 1627, 1627, 1627, 1627, 1627, 1627, 1627, 1627, 1627,
     1627, 1628, 1628, 1628, 1628, 1628, 1628, 1628, 1628, 1628,
     1628, 1628, 1628, 1629, 1629, 1629, 1629, 1629, 1629, 1629,

     1629, 1629, 1629, 1629, 1629, 1630, 1630, 1630, 1630, 1630,
     1630, 1630, 1630, 1630, 1630, 1630, 1630, 1631, 1631, 1631,
     1631, 1631, 1631, 1631, 1631, 1631, 1631, 1631, 1631, 1632,
     1632, 1632, 1632, 1632, 1632, 1632, 1632, 1632, 1632, 1632,
     1632, 1633, 1633, 1633, 1633, 1633, 1633, 1633, 1633, 1633,
     1633, 1633, 1633, 1634, 1634, 1634, 1634, 1634, 1634, 1634,
     1634, 1634, 1634, 1634, 1634, 1635, 1635, 1635, 1635, 1635,
     1635, 1635, 1635, 1635, 1635, 1635, 1635, 1636, 1636, 1636,
     1636, 1636, 1636, 1636, 1636, 1636, 1636, 1636, 1636, 1637,
     1637, 1637, 1637, 1637, 1637, 1637, 1637, 1637, 1637, 1637,

     1637, 1638, 1638, 1638, 1638, 1638, 1638, 1638, 1638, 1638,
     1638, 1638, 1638, 1639, 1639, 1639, 1639, 1639, 1639, 1639,
     1639, 1639, 1639, 1639, 1639, 1640, 1640, 1640, 1640, 1640,
     1640, 1640, 1640, 1640, 1640, 1640, 1640, 1641, 1641, 1641,
     1641, 1641, 1641, 1641, 1641, 1641, 1641, 1641, 1641, 1642,
     1642, 1642, 1642, 1642, 1642, 1642, 1642, 1642, 1642, 1642,
     1642, 1643, 1643, 1643, 1643, 1643, 1643, 1643, 1643, 1643,
     1643, 1643, 1643, 1644, 1644, 1644, 1644, 1644, 1644, 1644,
     1644, 1644, 1644, 1644, 1644, 1645, 1645, 1645, 1645, 1645,
     1645, 1645, 1645, 1645, 1645, 1645, 1645, 1646, 1646, 1646,

     1646, 1646, 1646, 1646, 1646, 1646, 1646, 1646, 1646, 1647,
     1647, 1647, 1647, 1647, 1647, 1647, 1647, 1647, 1647, 1647,
     1647, 1648, 1648, 1648, 1648, 1648, 1648, 1648, 1648, 1648,
     1648, 1648, 1648, 1649, 1649, 1649, 1649, 1649, 1649, 1649,
     1649, 1649, 1649, 1649, 1649, 1650, 1650, 1650, 1650, 1650,
     1650, 1650, 1650, 1650, 1650, 1650, 1650, 1651, 1651, 1651,
     1651, 1651, 1651, 1651, 1651, 1651, 1651, 1651, 1651, 1652,
     1652, 1652, 1652, 1652, 1652, 1652, 1652, 1652, 1652, 1652,
     1652, 1653, 1653, 1653, 1653, 1653, 1653, 1653, 1653, 1653,
     1653, 1653, 1653, 1654, 1654, 1654, 1654, 1654, 1654, 1654,

     1654, 1654, 1654, 1654, 1654, 1655, 1655, 1655, 1655, 1655,
     1655, 1655, 1655, 1655, 1655, 1655, 1655, 1656, 1656, 1656,
     1656, 1656, 1656, 1656, 1656, 1656, 1656, 1656, 1656, 1657,
     1657, 1657, 1657, 1657, 1657, 1657, 1657, 1657, 1657, 1657,
     1657, 1658, 1658, 1658, 1658, 1658, 1658, 1658, 1658, 1658,
     1658, 1658, 1658, 1659, 1659, 1659, 1659, 1659, 1659, 1659,
     1659, 1659, 1659, 1659, 1659, 1660, 1660, 1660, 1660, 1660,
     1660, 1660, 1660, 1660, 1660, 1660, 1660, 1661, 1661, 1661,
     1661, 1661, 1661, 1661, 1661, 1661, 1661, 1661, 1661, 1662,
     1662, 1662, 1662, 1662, 1662, 1662, 1662, 1662, 1662, 1662,

     1662, 1663, 1663, 1663, 1663, 1663, 1663, 1663, 1663, 1663,
     1663, 1663, 1663, 1664, 1664, 1664, 1664, 1664, 1664, 1664,
     1664, 1664, 1664, 1664, 1664, 1665, 1665, 1665, 1665, 1665,
     1665, 1665, 1665, 1665, 1665, 1665, 1665, 1666, 1666, 1666,
     1666, 1666, 1666, 1666, 1666, 1666, 1666, 1666, 1666, 1667,
     1667, 1667, 1667, 1667, 1667, 1667, 1667, 1667, 1667, 1667,
     1667, 1668, 1668, 1668, 1668, 1668, 1668, 1668, 1668, 1668,
     1668, 1668, 1668, 1669, 1669, 1669, 1669, 1669, 1669, 1669,
     1669, 1669, 1669, 1669, 1669, 1670, 1670, 1670, 1670, 1670,
     1670, 1670, 1670, 1670, 1670, 1670, 1670, 1671, 1671, 1671,

     1671, 1671, 1671, 1671, 1671, 1671, 1671, 1671, 1671, 1672,
     1672, 1672, 1672, 1672, 1672, 1672, 1672, 1672, 1672, 1672,
     1672, 1673, 1673, 1673, 1673, 1673, 1673, 1673, 1673, 1673,
     1673, 1673, 1673, 1674, 1674, 1674, 1674, 1674, 1674, 1674,
     1674, 1674, 1674, 1674, 1674, 1675, 1675, 1675, 1675, 1675,
     1675, 1675, 1675, 1675, 1675, 1675, 1675, 1676, 1676, 1676,
     1676, 1676, 1676, 1676, 1676, 1676, 1676, 1676, 1676, 1677,
     1677, 1677, 1677, 1677, 1677, 1677, 1677, 1677, 1677, 1677,
     1677, 1678, 1678, 1678, 1678, 1678, 1678, 1678, 1678, 1678,
     1678, 1678, 1678, 1679, 1679, 1679, 1679, 1679, 1679, 1679,

     1679, 1679, 1679, 1679, 1679, 1680, 1680, 1680, 1680, 1680,
     1680, 1680, 1680, 1680, 1680, 1680, 1680, 1681, 1681, 1681,
     1681, 1681, 1681, 1681, 1681, 1681, 1681, 1681, 1681, 1682,
     1682, 1682, 1682, 1682, 1682, 1682, 1682, 1682, 1682, 1682,
     1682, 1683, 1683, 1683, 1683, 1683, 1683, 1683, 1683, 1683,
     1683, 1683, 1683, 1684, 1684, 1684, 1684, 1684, 1684, 1684,
     1684, 1684, 1684, 1684, 1684, 1685, 1685, 1685, 1685, 1685,
     1685, 1685, 1685, 1685, 1685, 1685, 1685, 1686, 1686, 1686,
     1686, 1686, 1686, 1686, 1686, 1686, 1686, 1686, 1686, 1687,
     1687, 1687, 1687, 1687, 1687, 1687, 1687, 1687, 1687, 1687,

     1687, 1688, 1688, 1688, 1688, 1688, 1688, 1688, 1688, 1688,
     1688, 1688, 1688, 1689, 1689, 1689, 1689, 1689, 1689, 1689,
     1689, 1689, 1689, 1689, 1689, 1690, 1690, 1690, 1690, 1690,
     1690, 1690, 1690, 1690, 1690, 1690, 1690, 1691, 1691, 1691,
     1691, 1691, 1691, 1691, 1691, 1691, 1691, 1691, 1691, 1692,
     1692, 1692, 1692, 1692, 1692, 1692, 1692, 1692, 1692, 1692,
     1692, 1693, 1693, 1693, 1693, 1693, 1693, 1693, 1693, 1693,
     1693, 1693, 1693, 1694, 1694, 1694, 1694, 1694, 1694, 1694,
     1694, 1694, 1694, 1694, 1694, 1695, 1695, 1695, 1695, 1695,
     1695, 1695, 1695, 1695, 1695, 1695, 1695, 1696, 1696, 1696,

     1696, 1696, 1696, 1696, 1696, 1696, 1696, 1696, 1696, 1697,
     1697, 1697, 1697, 1697, 1697, 1697, 1697, 1697, 1697, 1697,
     1697, 1698, 1698, 1698, 1698, 1698, 1698, 1698, 1698, 1698,
     1698, 1698, 1698, 1699, 1699, 1699, 1699, 1699, 1699, 1699,
     1699, 1699, 1699, 1699, 1699, 1700, 1700, 1700, 1700, 1700,
     1700, 1700, 1700, 1700, 1700, 1700, 1700, 1701, 1701, 1701,
     1701, 1701, 1701, 1701, 1701, 1701, 1701, 1701, 1701, 1702,
     1702, 1702, 1702, 1702, 1702, 1702, 1702, 1702, 1702, 1702,
     1702, 1703, 1703, 1703, 1703, 1703, 1703, 1703, 1703, 1703,
     1703, 1703, 1703, 1704, 1704, 1704, 1704, 1704, 1704, 1704,

     1704, 1704, 1704, 1704, 1704, 1705, 1705, 1705, 1705, 1705,
     1705, 1705, 1705, 1705, 1705, 1705, 1705, 1706, 1706, 1706,
     1706, 1706, 1706, 1706, 1706, 1706, 1706, 1706, 1706, 1707,
     1707, 1707, 1707, 1707, 1707, 1707, 1707, 1707, 1707, 1707,
     1707, 1708, 1708, 1708, 1708, 1708, 1708, 1708, 1708, 1708,
     1708, 1708, 1708, 1709, 1709, 1709, 1709, 1709, 1709, 1709,
     1709, 1709, 1709, 1709, 1709, 1710, 1710, 1710, 1710, 1710,
     1710, 1710, 1710, 1710, 1710, 1710, 1710, 1711, 1711, 1711,
     1711, 1711, 1711, 1711, 1711, 1711, 1711, 1711, 1711, 1712,
     1712, 1712, 1712, 1712, 1712, 1712, 1712, 1712, 1712, 1712,

     1712, 1713, 1713, 1713, 1713, 1713, 1713, 1713, 1713, 1713,
     1713, 1713, 1713, 1714, 1714, 1714, 1714, 1714, 1714, 1714,
     1714, 1714, 1714, 1714, 1714, 1715, 1715, 1715, 1715, 1715,
     1715, 1715, 1715, 1715, 1715, 1715, 1715, 1716, 1716, 1716,
     1716, 1716, 1716, 1716, 1716, 1716, 1716, 1716, 1716, 1717,
     1717, 1717, 1717, 1717, 1717, 1717, 1717, 1717, 1717, 1717,
     1717, 1718, 1718, 1718, 1718, 1718, 1718, 1718, 1718, 1718,
     1718, 1718, 1718, 1719, 1719, 1719, 1719, 1719, 1719, 1719,
     1719, 1719, 1719, 1719, 1719, 1720, 1720, 1720, 1720, 1720,
     1720, 1720, 1720, 1720, 1720, 1720, 1720, 1721, 1721, 1721,

     1721, 1721, 1721, 1721, 1721, 1721, 1721, 1721, 1721, 1722,
     1722, 1722, 1722, 1722, 1722, 1722, 1722, 1722, 1722, 1722,
     1722, 1723, 1723, 1723, 1723, 1723, 1723, 1723, 1723, 1723,
     1723, 1723, 1723, 1724, 1724, 1724, 1724, 1724, 1724, 1724,
     1724, 1724, 1724, 1724, 1724, 1725, 1725, 1725, 1725, 1725,
     1725, 1725, 1725, 1725, 1725, 1725, 1725, 1726, 1726, 1726,
     1726, 1726, 1726, 1726, 1726, 1726, 1726, 1726, 1726, 1727,
     1727, 1727, 1727, 1727, 1727, 1727, 1727, 1727, 1727, 1727,
     1727, 1728, 1728, 1728, 1728, 1728, 1728, 1728, 1728, 1728,
     1728, 1728, 1728, 1729, 1729, 1729, 1729, 1729, 1729, 1729,

     1729, 1729, 1729, 1729, 1729, 1730, 1730, 1730, 1730, 1730,
     1730, 1730, 1730, 1730, 1730, 1730, 1730, 1731, 1731, 1731,
     1731, 1731, 1731, 1731, 1731, 1731, 1731, 1731, 1731, 1732,
     1732, 1732, 1732, 1732, 1732, 1732, 1732, 1732, 1732, 1732,
     1732, 1733, 1733, 1733, 1733, 1733, 1733, 1733, 1733, 1733,
     1733, 1733, 1733, 1734, 1734, 1734, 1734, 1734, 1734, 1734,
     1734, 1734, 1734, 1734, 1734, 1735, 1735, 1735, 1735, 1735,
     1735, 1735, 1735, 1735, 1735, 1735, 1735, 1736, 1736, 1736,
     1736, 1736, 1736, 1736, 1736, 1736, 1736, 1736, 1736, 1737,
     1737, 1737, 1737, 1737, 1737, 1737, 1737, 1737, 1737, 1737,

     1737, 1738, 1738, 1738, 1738, 1738, 1738, 1738, 1738, 1738,
     1738, 1738, 1738, 1739, 1739, 1739, 1739, 1739, 1739, 1739,
     1739, 1739, 1739, 1739, 1739, 1740, 1740, 1740, 1740, 1740,
     1740, 1740, 1740, 1740, 1740, 1740, 1740, 1741, 1741, 1741,
     1741, 1741, 1741, 1741, 1741, 1741, 1741, 1741, 1741, 1742,
     1742, 1742, 1742, 1742, 1742, 1742, 1742, 1742, 1742, 1742,
     1742, 1743, 1743, 1743, 1743, 1743, 1743, 1743, 1743, 1743,
     1743, 1743, 1743, 1744, 1744, 1744, 1744, 1744, 1744, 1744,
     1744, 1744, 1744, 1744, 1744, 1745, 1745, 1745, 1745, 1745,
     1745, 1745, 1745, 1745, 1745, 1745, 1745, 1746, 1746, 1746,

     1746, 1746, 1746, 1746, 1746, 1746, 1746, 1746, 1746, 1747,
     1747, 1747, 1747, 1747, 1747, 1747, 1747, 1747, 1747, 1747,
     1747, 1748, 1748, 1748, 1748, 1748, 1748, 1748, 1748, 1748,
     1748, 1748, 1748, 1749, 1749, 1749, 1749, 1749, 1749, 1749,
     1749, 1749, 1749, 1749, 1749, 1750, 1750, 1750, 1750, 1750,
     1750, 1750, 1750, 1750, 1750, 1750, 1750, 1751, 1751, 1751,
     1751, 1751, 1751, 1751, 1751, 1751, 1751, 1751, 1751, 1752,
     1752, 1752, 1752, 1752, 1752, 1752, 1752, 1752, 1752, 1752,
     1752, 1753, 1753, 1753, 1753, 1753, 1753, 1753, 1753, 1753,
     1753, 1753, 1753, 1754, 1754, 1754, 1754, 1754, 1754, 1754,

     1754, 1754, 1754, 1754, 1754, 1755, 1755, 1755, 1755, 1755,
     1755, 1755, 1755, 1755, 1755, 1755, 1755, 1756, 1756, 1756,
     1756, 1756, 1756, 1756, 1756, 1756, 1756, 1756, 1756, 1757,
     1757, 1757, 1757, 1757, 1757, 1757, 1757, 1757, 1757, 1757,
     1757, 1758, 1758, 1758, 1758, 1758, 1758, 1758, 1758, 1758,
     1758, 1758, 1758, 1759, 1759, 1759, 1759, 1759, 1759, 1759,
     1759, 1759, 1759, 1759, 1759, 1760, 1760, 1760, 1760, 1760,
     1760, 1760, 1760, 1760, 1760, 1760, 1760, 1761, 1761, 1761,
     1761, 1761, 1761, 1761, 1761, 1761, 1761, 1761, 1761, 1762,
     1762, 1762, 1762, 1762, 1762, 1762, 1762, 1762, 1762, 1762,

     1762, 1763, 1763, 1763, 1763, 1763, 1763, 1763, 1763, 1763,
     1763, 1763, 1763, 1764, 1764, 1764, 1764, 1764, 1764, 1764,
     1764, 1764, 1764, 1764, 1764, 1765, 1765, 1765, 1765, 1765,
     1765, 1765, 1765, 1765, 1765, 1765, 1765, 1766, 1766, 1766,
     1766, 1766, 1766, 1766, 1766, 1766, 1766, 1766, 1766, 1767,
     1767, 1767, 1767, 1767, 1767, 1767, 1767, 1767, 1767, 1767,
     1767, 1768, 1768, 1768, 1768, 1768, 1768, 1768, 1768, 1768,
     1768, 1768, 1768, 1769, 1769, 1769, 1769, 1769, 1769, 1769,
     1769, 1769, 1769, 1769, 1769, 1770, 1770, 1770, 1770, 1770,
     1770, 1770, 1770, 1770, 1770, 1770, 1770,  314,  313,  312,

      311,  309,  308,  307,  306,  305,  304,  302,  297,  294,
      293,  292,  291,  290,  289,  288,  286,  285,  284,  283,
      282,  281,  280,  279,  278,  276,  275,  274,  272,  271,
      269,  268,  267,  266,  265,  263,  261,  260,  255,  254,
      249,  248,  247,  246,  245,  244,  243,  242,  241,  240,
      236,  235,  232,  222,  217,  214,  213,  211,  197,  196,
      195,  194,  193,  192,  191,  189,  187,  186,  185,  184,
      183,  181,  180,  179,  177,  176,  175,  174,  173,  171,
      169,  168,  167,  166,  165,  163,  162,  157,  154,  150,
      133,  132,  131,  130,  129,  128,  127,  126,  125,  123,

      112,  110,  108,  107,  105,  104,  102,  101,   98,   86,
       83,   82,   81,   75,   68,   67,   66,   63,   62,   60,
       59,   56,   51,   48,   47,   46,   42,   35,   26,   22,
       21,   18,   17,    2,    1, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350,
     1350, 1350, 1350, 1350, 1350, 1350, 1350, 1350

    } ;

static yy_state_type yy_last_accepting_state;
static char *yy_last_accepting_cpos;

/* The intent behind this definition is that it'll catch
 * any uses of REJECT which flex missed.
 */
#define REJECT reject_used_but_not_detected
static int yy_more_flag = 0;
static int yy_more_len = 0;
#define yymore() (yy_more_flag = 1)
#define YY_MORE_ADJ yy_more_len
#define YY_RESTORE_YY_MORE_OFFSET
char *yytext;
#define INITIAL 0

/*
   +----------------------------------------------------------------------+
   | Zend Engine                                                          |
   +----------------------------------------------------------------------+
   | Copyright (c) 1998-2002 Zend Technologies Ltd. (http://www.zend.com) |
   +----------------------------------------------------------------------+
   | This source file is subject to version 2.00 of the Zend license,     |
   | that is bundled with this package in the file LICENSE, and is        | 
   | available at through the world-wide-web at                           |
   | http://www.zend.com/license/2_00.txt.                                |
   | If you did not receive a copy of the Zend license and are unable to  |
   | obtain it through the world-wide-web, please send a note to          |
   | license@zend.com so we can mail you a copy immediately.              |
   +----------------------------------------------------------------------+
   | Authors: Andi Gutmans <andi@zend.com>                                |
   |          Zeev Suraski <zeev@zend.com>                                |
   +----------------------------------------------------------------------+
*/

#define yyleng SCNG(yy_leng)
#define yytext SCNG(yy_text)
#define yytext_ptr SCNG(yy_text)
#define yyin SCNG(yy_in)
#define yyout SCNG(yy_out)
#define yy_last_accepting_state SCNG(_yy_last_accepting_state)
#define yy_last_accepting_cpos SCNG(_yy_last_accepting_cpos)
#define yy_more_flag SCNG(_yy_more_flag)
#define yy_more_len SCNG(_yy_more_len)

#define ST_IN_SCRIPTING 1

#define ST_DOUBLE_QUOTES 2

#define ST_SINGLE_QUOTE 3

#define ST_BACKQUOTE 4

#define ST_HEREDOC 5

#define ST_LOOKING_FOR_PROPERTY 6

#define ST_LOOKING_FOR_VARNAME 7

#define ST_COMMENT 8

#define ST_ONE_LINE_COMMENT 9

#define YY_STACK_USED 1

#include <errno.h>
#include "zend.h"
#include "zend_alloc.h"
#include <zend_language_parser.h>
#include "zend_compile.h"
#include "zend_language_scanner.h"
#include "zend_highlight.h"
#include "zend_constants.h"
#include "zend_variables.h"
#include "zend_operators.h"
#include "zend_strtod.h"

#ifdef HAVE_STDARG_H
# include <stdarg.h>
#endif

#ifdef HAVE_UNISTD_H
# include <unistd.h>
#endif

#ifdef ZEND_WIN32
#include <io.h>
#endif

#define YY_DECL int lex_scan(zval *zendlval TSRMLS_DC)

#define ECHO { ZEND_WRITE( yytext, yyleng ); }

#ifdef ZTS
#  define MY_INPUT yyinput
#else
#  define MY_INPUT input
#endif


#ifndef STDIN_FILENO
# define STDIN_FILENO 0
#endif


/* Globals Macros */
#define SCNG	LANG_SCNG
#ifdef ZTS
ZEND_API ts_rsrc_id language_scanner_globals_id;
#else
ZEND_API zend_scanner_globals language_scanner_globals;
#endif


#define YY_FATAL_ERROR zend_fatal_scanner_error

#define HANDLE_NEWLINES(s, l)													\
do {																			\
	char *p = (s), *boundary = p+(l);											\
																				\
	while (p<boundary) {														\
		if (*p == '\n') {														\
			CG(zend_lineno)++;													\
		} else if ((*p == '\r') && (p+1 < boundary) && (*(p+1) != '\n')) {		\
			CG(zend_lineno)++;													\
		}																		\
		p++;																	\
	}																			\
} while (0)

#define HANDLE_NEWLINE(c) \
{ \
	if (c == '\n' || c == '\r') { \
		CG(zend_lineno)++; \
	} \
}
		

#define ZEND_IS_OCT(c)  ((c)>='0' && (c)<='7')
#define ZEND_IS_HEX(c)  (((c)>='0' && (c)<='9') || ((c)>='a' && (c)<='f') || ((c)>='A' && (c)<='F'))


void zend_fatal_scanner_error(char *message)
{
	zend_error(E_COMPILE_ERROR, "%s", message);
}

BEGIN_EXTERN_C()
void startup_scanner(TSRMLS_D)
{
	CG(heredoc) = NULL;
	CG(heredoc_len)=0;
	SCNG(yy_start_stack_ptr) = 0;
	SCNG(yy_start_stack_depth) = 0;
	SCNG(current_buffer) = NULL;
#ifdef ZEND_MULTIBYTE
	SCNG(code) = NULL;
	SCNG(code_size) = 0;
	SCNG(current_code) = NULL;
	SCNG(current_code_size) = 0;
	SCNG(input_filter) = NULL;
	SCNG(output_filter) = NULL;
	SCNG(script_encoding) = NULL;
	SCNG(internal_encoding) = NULL;
#endif /* ZEND_MULTIBYTE */
}


void shutdown_scanner(TSRMLS_D)
{
	if (CG(heredoc)) {
		efree(CG(heredoc));
		CG(heredoc_len)=0;
	}
	if (SCNG(yy_start_stack)) {
		yy_flex_free(SCNG(yy_start_stack));
		SCNG(yy_start_stack) = NULL;
	}
#ifdef ZEND_MULTIBYTE
	if (SCNG(code)) {
		efree(SCNG(code));
		SCNG(code) = NULL;
	}
	if (SCNG(current_code)) {
		efree(SCNG(current_code));
		SCNG(current_code) = NULL;
	}
	SCNG(code_size) = 0;
	SCNG(current_code_size) = 0;
	SCNG(input_filter) = NULL;
	SCNG(output_filter) = NULL;
	SCNG(script_encoding) = NULL;
	SCNG(internal_encoding) = NULL;
#endif /* ZEND_MULTIBYTE */
}
END_EXTERN_C()


ZEND_API void zend_save_lexical_state(zend_lex_state *lex_state TSRMLS_DC)
{
	memcpy(&lex_state->buffer_state, &YY_CURRENT_BUFFER, sizeof(YY_BUFFER_STATE));
	lex_state->in = SCNG(yy_in);
	lex_state->state = YYSTATE;
	lex_state->filename = zend_get_compiled_filename(TSRMLS_C);
	lex_state->lineno = CG(zend_lineno);
#ifdef ZEND_MULTIBYTE
	lex_state->code = SCNG(code);
	lex_state->code_size = SCNG(code_size);
	lex_state->current_code = SCNG(current_code);
	lex_state->current_code_size = SCNG(current_code_size);
	lex_state->input_filter = SCNG(input_filter);
	lex_state->output_filter = SCNG(output_filter);
	lex_state->script_encoding = SCNG(script_encoding);
	lex_state->internal_encoding = SCNG(internal_encoding);
#endif /* ZEND_MULTIBYTE */
}


ZEND_API void zend_restore_lexical_state(zend_lex_state *lex_state TSRMLS_DC)
{
	YY_BUFFER_STATE original_buffer_state = YY_CURRENT_BUFFER;

	if (lex_state->buffer_state) {
		yy_switch_to_buffer(lex_state->buffer_state TSRMLS_CC);
	} else {
		YY_CURRENT_BUFFER = NULL;
	}
		
	yy_delete_buffer(original_buffer_state TSRMLS_CC);
	SCNG(yy_in) = lex_state->in;
	BEGIN(lex_state->state);
	CG(zend_lineno) = lex_state->lineno;
	zend_restore_compiled_filename(lex_state->filename TSRMLS_CC);
#ifdef ZEND_MULTIBYTE
	SCNG(code) = lex_state->code;
	SCNG(code_size) = lex_state->code_size;
	SCNG(current_code) = lex_state->current_code;
	SCNG(current_code_size) = lex_state->current_code_size;
	SCNG(input_filter) = lex_state->input_filter;
	SCNG(output_filter) = lex_state->output_filter;
	SCNG(script_encoding) = lex_state->script_encoding;
	SCNG(internal_encoding) = lex_state->internal_encoding;
#endif /* ZEND_MULTIBYTE */
}


BEGIN_EXTERN_C()


ZEND_API void zend_file_handle_dtor(zend_file_handle *fh)
{
	switch (fh->type) {
		case ZEND_HANDLE_SOCKET_FD:
#ifdef ZEND_WIN32
			closesocket(fh->handle.fd);
			break;
#endif
		/* fall-through */ 
		case ZEND_HANDLE_FD:
			close(fh->handle.fd);
			break;
		case ZEND_HANDLE_FP:
			fclose(fh->handle.fp);
			break;
		case ZEND_HANDLE_FILENAME:
			/* We're only supposed to get here when destructing the used_files hash,
			 * which doesn't really contain open files, but references to their names/paths
			 */
			break;
	}
	if (fh->opened_path) {
		efree(fh->opened_path);
		fh->opened_path = NULL;
	}
	if (fh->free_filename && fh->filename) {
		efree(fh->filename);
		fh->filename = NULL;
	}
}


int zend_compare_file_handles(zend_file_handle *fh1, zend_file_handle *fh2)
{
	if (fh1->type != fh2->type) {
		return 0;
	}
	switch (fh1->type) {
		case ZEND_HANDLE_FP:
			return fh1->handle.fp==fh2->handle.fp;
			break;
		case ZEND_HANDLE_SOCKET_FD:
		case ZEND_HANDLE_FD:
			return fh1->handle.fd==fh2->handle.fd;
			break;
	}
	return 0;
}


ZEND_API void zend_destroy_file_handle(zend_file_handle *file_handle TSRMLS_DC)
{
	zend_llist_del_element(&CG(open_files), file_handle, (int (*)(void *, void *)) zend_compare_file_handles);
}


ZEND_API int open_file_for_scanning(zend_file_handle *file_handle TSRMLS_DC)
{
	char *file_path=NULL;
	int do_add = 1;

	switch (file_handle->type) {
		case ZEND_HANDLE_FILENAME:
			if (zend_open(file_handle->filename, file_handle) != SUCCESS)
				return FAILURE;
			break;
	}

	if (!ZEND_IS_VALID_FILE_HANDLE(file_handle))
			return FAILURE;
	
	if (file_handle->type == ZEND_HANDLE_FP && file_handle->handle.fp == stdin)
		do_add = 0;
	else if (file_handle->type == ZEND_HANDLE_FD && file_handle->handle.fd == STDIN_FILENO)
		do_add = 0;
	
	if (do_add) {
		zend_llist_add_element(&CG(open_files), file_handle);
	}
	/* Reset the scanner for scanning the new file */
	SCNG(yy_in) = file_handle;
#ifdef ZEND_MULTIBYTE
	if (zend_read_file(TSRMLS_C) != 0) {
		return FAILURE;
	}
	
	/* force flex to use buffer only */
	SCNG(yy_in) = NULL;
	SCNG(init) = 0;
	SCNG(start) = 1;

	zend_multibyte_set_filter(NULL TSRMLS_CC);

	if (!SCNG(input_filter)) {
		SCNG(current_code) = (char*)emalloc(SCNG(code_size)+1);
		memcpy(SCNG(current_code), SCNG(code), SCNG(code_size)+1);
		SCNG(current_code_size) = SCNG(code_size);
	} else {
		SCNG(input_filter)(&SCNG(current_code), &SCNG(current_code_size), SCNG(code), SCNG(code_size) TSRMLS_CC);
		if (!SCNG(current_code) || !SCNG(current_code_size)) {
			return FAILURE;
		}
	}
	
	/* we need two nulls so that ralloc... */
	SCNG(current_code) = (char*)erealloc(SCNG(current_code), SCNG(current_code_size)+2);
	*(SCNG(current_code)+SCNG(current_code_size)) = (char)NULL;
	*(SCNG(current_code)+SCNG(current_code_size)+1) = (char)NULL;
	yy_scan_buffer(SCNG(current_code), SCNG(current_code_size)+2 TSRMLS_CC);
#else /* ZEND_MULTIBYTE */
	yy_switch_to_buffer(yy_create_buffer(SCNG(yy_in), YY_BUF_SIZE TSRMLS_CC) TSRMLS_CC);
#endif /* ZEND_MULTIBYTE */
	BEGIN(INITIAL);

	if (file_handle->opened_path) {
		file_path = file_handle->opened_path; 
	} else {
		file_path = file_handle->filename;
	}

	zend_set_compiled_filename(file_path TSRMLS_CC);
	
	if (CG(zend_lineno) < 0) { /* position is (n_lines * -1), position was changed by an external app */
		CG(zend_lineno) = CG(zend_lineno) * -1;
	} else {
		CG(zend_lineno) = 1;
	}
	
	CG(increment_lineno) = 0;
	return SUCCESS;
}
END_EXTERN_C()


ZEND_API zend_op_array *compile_file(zend_file_handle *file_handle, int type TSRMLS_DC)
{
	zend_lex_state original_lex_state;
	zend_op_array *op_array = (zend_op_array *) emalloc(sizeof(zend_op_array));
	zend_op_array *original_active_op_array = CG(active_op_array);
	zend_op_array *retval=NULL;
	int compiler_result;
	zend_bool compilation_successful=0;
	znode retval_znode;
	zend_bool original_in_compilation = CG(in_compilation);

	retval_znode.op_type = IS_CONST;
	retval_znode.u.constant.type = IS_LONG;
	retval_znode.u.constant.value.lval = 1;
	retval_znode.u.constant.is_ref = 0;
	retval_znode.u.constant.refcount = 1;

	zend_save_lexical_state(&original_lex_state TSRMLS_CC);

	retval = op_array; /* success oriented */

	if (open_file_for_scanning(file_handle TSRMLS_CC)==FAILURE) {
		if (type==ZEND_REQUIRE) {
			zend_message_dispatcher(ZMSG_FAILED_REQUIRE_FOPEN, file_handle->filename);
			zend_bailout();		
		} else {
			zend_message_dispatcher(ZMSG_FAILED_INCLUDE_FOPEN, file_handle->filename);
		}
		compilation_successful=0;
	} else {
		init_op_array(op_array, ZEND_USER_FUNCTION, INITIAL_OP_ARRAY_SIZE TSRMLS_CC);
		CG(in_compilation) = 1;
		CG(active_op_array) = op_array;
		compiler_result = zendparse(TSRMLS_C);
		zend_do_return(&retval_znode, 0 TSRMLS_CC);
		CG(in_compilation) = original_in_compilation;
		if (compiler_result==1) { /* parser error */
			zend_bailout();
		}
		compilation_successful=1;
#ifdef ZEND_MULTIBYTE
		if (SCNG(code)) {
			efree(SCNG(code));
			SCNG(code) = NULL;
		}
		if (SCNG(current_code)) {
			efree(SCNG(current_code));
			SCNG(current_code) = NULL;
		}
#endif /* ZEND_MULTIBYTE */
	}

	if (retval) {
		CG(active_op_array) = original_active_op_array;
		if (compilation_successful) {
			pass_two(op_array TSRMLS_CC);
		} else {
			efree(op_array);
			retval = NULL;
		}
	}
	if (compilation_successful) {
		zend_restore_lexical_state(&original_lex_state TSRMLS_CC);
	}
	return retval;
}


zend_op_array *compile_filename(int type, zval *filename TSRMLS_DC)
{
	zend_file_handle file_handle = {0};
	zval tmp;
	zend_op_array *retval;
	char *opened_path = NULL;

	if (filename->type != IS_STRING) {
		tmp = *filename;
		zval_copy_ctor(&tmp);
		convert_to_string(&tmp);
		filename = &tmp;
	}
	file_handle.filename = filename->value.str.val;
	file_handle.free_filename = 0;
	file_handle.type = ZEND_HANDLE_FILENAME;
	file_handle.opened_path = NULL;

	retval = zend_compile_file(&file_handle, type TSRMLS_CC);
	if (retval && ZEND_IS_VALID_FILE_HANDLE(&file_handle)) {
		int dummy = 1;
	
		if (!file_handle.opened_path) {
			file_handle.opened_path = opened_path = estrndup(filename->value.str.val, filename->value.str.len);
		}
		
		zend_hash_add(&EG(included_files), file_handle.opened_path, strlen(file_handle.opened_path)+1, (void *)&dummy, sizeof(int), NULL);
		
		if (opened_path) {
			efree(opened_path);
		}
	}
	zend_destroy_file_handle(&file_handle TSRMLS_CC);

	if (filename==&tmp) {
		zval_dtor(&tmp);
	}
	return retval;
}

ZEND_API int zend_prepare_string_for_scanning(zval *str, char *filename TSRMLS_DC)
{
	/* enforce two trailing NULLs for flex... */
	STR_REALLOC(str->value.str.val, str->value.str.len+2);

	str->value.str.val[str->value.str.len+1]=0;

	SCNG(yy_in)=NULL;
#ifdef ZEND_MULTIBYTE
	/* instead of zend_readfile() */
	SCNG(code) = estrdup(str->value.str.val);
	SCNG(code_size) = str->value.str.len;

	zend_multibyte_set_filter(CG(internal_encoding) TSRMLS_CC);

	if (!SCNG(input_filter)) {
		SCNG(current_code) = (char*)emalloc(SCNG(code_size)+1);
		memcpy(SCNG(current_code), SCNG(code), SCNG(code_size)+1);
		SCNG(current_code_size) = SCNG(code_size);
	} else {
		SCNG(input_filter)(&SCNG(current_code), &SCNG(current_code_size), SCNG(code), SCNG(code_size) TSRMLS_CC);
		if (!SCNG(current_code) || !SCNG(current_code_size)) {
			return FAILURE;
		}
	}

	SCNG(current_code) = (char*)erealloc(SCNG(current_code), SCNG(current_code_size)+2);
	*(SCNG(current_code)+SCNG(current_code_size)) = (char)NULL;
	*(SCNG(current_code)+SCNG(current_code_size)+1) = (char)NULL;
	yy_scan_buffer(SCNG(current_code), SCNG(current_code_size)+2 TSRMLS_CC);
#else /* ZEND_MULTIBYTE */
	yy_scan_buffer(str->value.str.val, str->value.str.len+2 TSRMLS_CC);
#endif /* ZEND_MULTIBYTE */

	zend_set_compiled_filename(filename TSRMLS_CC);
	CG(zend_lineno) = 1;
	CG(increment_lineno) = 0;
	return SUCCESS;
}


zend_op_array *compile_string(zval *source_string, char *filename TSRMLS_DC)
{
	zend_lex_state original_lex_state;
	zend_op_array *op_array = (zend_op_array *) emalloc(sizeof(zend_op_array));
	zend_op_array *original_active_op_array = CG(active_op_array);
	zend_op_array *retval;
	zval tmp;
	int compiler_result;
	zend_bool original_in_compilation = CG(in_compilation);

	if (source_string->value.str.len==0) {
		efree(op_array);
		return NULL;
	}

	CG(in_compilation) = 1;

	tmp = *source_string;
	zval_copy_ctor(&tmp);
	convert_to_string(&tmp);
	source_string = &tmp;

	zend_save_lexical_state(&original_lex_state TSRMLS_CC);
	if (zend_prepare_string_for_scanning(source_string, filename TSRMLS_CC)==FAILURE) {
		efree(op_array);
		retval = NULL;
	} else {
		init_op_array(op_array, ZEND_EVAL_CODE, INITIAL_OP_ARRAY_SIZE TSRMLS_CC);
		CG(active_op_array) = op_array;
		BEGIN(ST_IN_SCRIPTING);
		compiler_result = zendparse(TSRMLS_C);
#ifdef ZEND_MULTIBYTE
		if (SCNG(code)) {
			efree(SCNG(code));
			SCNG(code) = NULL;
		}
		if (SCNG(current_code)) {
			efree(SCNG(current_code));
			SCNG(current_code) = NULL;
		}
#endif /* ZEND_MULTIBYTE */
		
		if (compiler_result==1) {
			CG(active_op_array) = original_active_op_array;
			CG(unclean_shutdown)=1;
			retval = NULL;
		} else {
			zend_do_return(NULL, 0 TSRMLS_CC);
			CG(active_op_array) = original_active_op_array;
			pass_two(op_array TSRMLS_CC);
			retval = op_array;
		}
		zend_restore_lexical_state(&original_lex_state TSRMLS_CC);
	}
	zval_dtor(&tmp);
	CG(in_compilation) = original_in_compilation;
	return retval;
}


BEGIN_EXTERN_C()
int highlight_file(char *filename, zend_syntax_highlighter_ini *syntax_highlighter_ini TSRMLS_DC)
{
	zend_lex_state original_lex_state;
	zend_file_handle file_handle = {0};

	file_handle.type = ZEND_HANDLE_FILENAME;
	file_handle.filename = filename;
	file_handle.free_filename = 0;
	file_handle.opened_path = NULL;
	zend_save_lexical_state(&original_lex_state TSRMLS_CC);
	if (open_file_for_scanning(&file_handle TSRMLS_CC)==FAILURE) {
		zend_message_dispatcher(ZMSG_FAILED_HIGHLIGHT_FOPEN, filename);
		return FAILURE;
	}
	zend_highlight(syntax_highlighter_ini TSRMLS_CC);
#ifdef ZEND_MULTIBYTE
	if (SCNG(code)) {
		efree(SCNG(code));
		SCNG(code) = NULL;
	}
	if (SCNG(current_code)) {
		efree(SCNG(current_code));
		SCNG(current_code) = NULL;
	}
#endif /* ZEND_MULTIBYTE */
	zend_destroy_file_handle(&file_handle TSRMLS_CC);
	zend_restore_lexical_state(&original_lex_state TSRMLS_CC);
	return SUCCESS;
}

int highlight_string(zval *str, zend_syntax_highlighter_ini *syntax_highlighter_ini, char *str_name TSRMLS_DC)
{
	zend_lex_state original_lex_state;
	zval tmp = *str;

	str = &tmp;
	zval_copy_ctor(str);
	zend_save_lexical_state(&original_lex_state TSRMLS_CC);
	if (zend_prepare_string_for_scanning(str, str_name TSRMLS_CC)==FAILURE) {
		return FAILURE;
	}
	zend_highlight(syntax_highlighter_ini TSRMLS_CC);
#ifdef ZEND_MULTIBYTE
	if (SCNG(code)) {
		efree(SCNG(code));
		SCNG(code) = NULL;
	}
	if (SCNG(current_code)) {
		efree(SCNG(current_code));
		SCNG(current_code) = NULL;
	}
#endif /* ZEND_MULTIBYTE */
	zend_restore_lexical_state(&original_lex_state TSRMLS_CC);
	zval_dtor(str);
	return SUCCESS;
}
END_EXTERN_C()

#ifdef ZEND_MULTIBYTE
BEGIN_EXTERN_C()
ZEND_API void zend_yyinput_again(zend_multibyte_filter old_input_filter, zend_encoding *old_encoding TSRMLS_DC)
{
	YY_BUFFER_STATE b = YY_CURRENT_BUFFER;
	int offset, original_offset, length, free_flag;
	char *p;
	zend_encoding *new_encoding;

	/* calculate current position */
	offset = original_offset = yy_c_buf_p - b->yy_ch_buf;
	if (old_input_filter && original_offset > 0) {
		/* we need to adjust offset ? (i've gotta improve this...) */
		new_encoding = SCNG(script_encoding);
		SCNG(script_encoding) = old_encoding;
		do {
			(old_input_filter)(&p, &length, SCNG(code), offset TSRMLS_CC);
			if (!p) {
				SCNG(script_encoding) = new_encoding;
				return;
			}
			efree(p);
			if (length > original_offset) {
				offset--;
			} else if (length < original_offset) {
				offset++;
			}
		} while (original_offset != length);
		SCNG(script_encoding) = new_encoding;
	}

	/* convert and set */
	if (!SCNG(input_filter)) {
		length = SCNG(code_size)-offset-1;
		p = SCNG(code)+offset+1;
		free_flag = 0;
	} else {
		SCNG(input_filter)(&p, &length, SCNG(code)+offset+1, SCNG(code_size)-offset-1 TSRMLS_CC);
		free_flag = 1;
	}
	if (original_offset+length+1 > (int)b->yy_buf_size) {
		b->yy_buf_size = original_offset+length+1;
		b->yy_ch_buf = (char*)erealloc(b->yy_ch_buf, b->yy_buf_size+2);
		SCNG(current_code) = b->yy_ch_buf;
		SCNG(current_code_size) = b->yy_buf_size;
	}
	yy_c_buf_p = b->yy_ch_buf + original_offset;
	strncpy(yy_c_buf_p+1, p, length);
 	b->yy_n_chars = original_offset + length + 1;
	SCNG(yy_n_chars) = b->yy_n_chars;
	b->yy_ch_buf[SCNG(yy_n_chars)] = YY_END_OF_BUFFER_CHAR;
	b->yy_ch_buf[SCNG(yy_n_chars)+1] = YY_END_OF_BUFFER_CHAR;

	if (free_flag) {
		efree(p);
	}
}


ZEND_API int zend_read_file(TSRMLS_D)
{
	char buf[8192];
	int n;

	SCNG(code) = NULL;
	SCNG(code_size) = 0;

	for (;;) {
		switch (SCNG(yy_in)->type) {
			case ZEND_HANDLE_FD:
				n = read(SCNG(yy_in)->handle.fd, buf, sizeof(buf));
				break;
			case ZEND_HANDLE_FP:
				n = fread(buf, sizeof(buf[0]), sizeof(buf) / sizeof(buf[0]), SCNG(yy_in)->handle.fp);
				break;
			case ZEND_HANDLE_SOCKET_FD:
				n =	recv(SCNG(yy_in)->handle.fd, buf, sizeof(buf), 0);
		}

		if (n <= 0) {
			break;
		}

		SCNG(code_size) += n;
		if (SCNG(code)) {
			SCNG(code) = (char*)erealloc(SCNG(code), SCNG(code_size)+1);
		} else {
			SCNG(code) = (char*)emalloc(SCNG(code_size)+1);
		}
		memcpy(SCNG(code)+SCNG(code_size)-n, buf, n);
	}

	if (n < 0) {
		return -1;
	}

	if (!SCNG(code)) {
		SCNG(code) = emalloc(SCNG(code_size)+1);
	}
	*(SCNG(code)+SCNG(code_size)) = (char)NULL;

	return 0;
}


/*
 *	macros for yytext -> zval
 */
# define zend_copy_value(zendlval, yytext, yyleng) \
	if (SCNG(output_filter)) { \
		SCNG(output_filter)(&(zendlval->value.str.val), &(zendlval->value.str.len), yytext, yyleng TSRMLS_CC); \
	} else { \
		zendlval->value.str.val = (char *) estrndup(yytext, yyleng); \
		zendlval->value.str.len = yyleng; \
	}
#else /* ZEND_MULTIBYTE */
# define zend_copy_value(zendlval, yytext, yyleng) \
	zendlval->value.str.val = (char *)estrndup(yytext, yyleng); \
	zendlval->value.str.len = yyleng;
#endif /* ZEND_MULTIBYTE */

/* Macros after this point can all be overridden by user definitions in
 * section 1.
 */

#ifndef YY_SKIP_YYWRAP
#ifdef __cplusplus
extern "C" int yywrap YY_PROTO(( void ));
#else
extern int yywrap YY_PROTO(( void ));
#endif
#endif

#ifndef YY_NO_UNPUT
static void yyunput YY_PROTO(( int c, char *buf_ptr TSRMLS_DC ));
#endif

#ifndef yytext_ptr
static void yy_flex_strncpy YY_PROTO(( char *, yyconst char *, int ));
#endif

#ifdef YY_NEED_STRLEN
static int yy_flex_strlen YY_PROTO(( yyconst char * ));
#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
static int 3 YY_PROTO(( TSRMLS_D ));
#else
static int input YY_PROTO(( TSRMLS_D ));
#endif
#endif

#if YY_STACK_USED
#define yy_start_stack_ptr SCNG(yy_start_stack_ptr)
#define yy_start_stack_depth SCNG(yy_start_stack_depth)
#define yy_start_stack SCNG(yy_start_stack)
/*
static int yy_start_stack_ptr = 0;
static int yy_start_stack_depth = 0;
static int *yy_start_stack = 0;
*/
#ifndef YY_NO_PUSH_STATE
static void yy_push_state YY_PROTO(( int new_state TSRMLS_DC ));
#endif
#ifndef YY_NO_POP_STATE
static void yy_pop_state YY_PROTO(( TSRMLS_D ));
#endif
#ifndef YY_NO_TOP_STATE
static int yy_top_state YY_PROTO(( TSRMLS_D ));
#endif

#else
#define YY_NO_PUSH_STATE 1
#define YY_NO_POP_STATE 1
#define YY_NO_TOP_STATE 1
#endif

#ifdef YY_MALLOC_DECL
YY_MALLOC_DECL
#else
#if __STDC__
#ifndef __cplusplus
#include <stdlib.h>
#endif
#else
/* Just try to get by without declaring the routines.  This will fail
 * miserably on non-ANSI systems for which sizeof(size_t) != sizeof(int)
 * or sizeof(void*) != sizeof(int).
 */
#endif
#endif

/* Amount of stuff to slurp up with each read. */
#ifndef YY_READ_BUF_SIZE
#define YY_READ_BUF_SIZE 8192
#endif

/* Copy whatever the last rule matched to the standard output. */

#ifndef ECHO
#define ECHO
#endif

/* Gets input and stuffs it into "buf".  number of characters read, or YY_NULL,
 * is returned in "result".
 */

#define YY_INPUT(buf,result,max_size) do {				\
	result = yyin->type == ZEND_HANDLE_FD ? 			\
			read(yyin->handle.fd, buf, max_size)		\
			: yyin->type == ZEND_HANDLE_FP ? 			\
			fread(buf, 1, max_size, yyin->handle.fp)	\
			: yyin->type == ZEND_HANDLE_SOCKET_FD ?		\
			recv(yyin->handle.fd, buf, max_size, 0)		\
			: -1;										\
	if (result < 0)										\
		YY_FATAL_ERROR("input in flex scanner failed");	\
} while (0)

#ifndef YY_INPUT
#define YY_INPUT(buf,result,max_size) \
	if ( yy_current_buffer->yy_is_interactive ) \
		{ \
		int c = '*', n; \
		for ( n = 0; n < max_size && \
			     (c = getc( yyin )) != EOF && c != '\n'; ++n ) \
			buf[n] = (char) c; \
		if ( c == '\n' ) \
			buf[n++] = (char) c; \
		if ( c == EOF && ferror( yyin ) ) \
			YY_FATAL_ERROR( "input in flex scanner failed" ); \
		result = n; \
		} \
	else \
		{ \
		errno=0; \
		while ( (result = fread(buf, 1, max_size, yyin))==0 && ferror(yyin)) \
			{ \
			if( errno != EINTR) \
				{ \
				YY_FATAL_ERROR( "input in flex scanner failed" ); \
				break; \
				} \
			errno=0; \
			clearerr(yyin); \
			} \
		}
#endif

/* No semi-colon after return; correct usage is to write "yyterminate();" -
 * we don't want an extra ';' after the "return" because that will cause
 * some compilers to complain about unreachable statements.
 */
#ifndef yyterminate
#define yyterminate() return YY_NULL
#endif

/* Number of entries by which start-condition stack grows. */
#ifndef YY_START_STACK_INCR
#define YY_START_STACK_INCR 25
#endif

/* Report a fatal error. */
#ifndef YY_FATAL_ERROR
#define YY_FATAL_ERROR(msg) yy_fatal_error( msg )
#endif


/* Default declaration of generated scanner - a define so the user can
 * easily add parameters.
 */
#ifndef YY_DECL
#define YY_DECL int yylex YY_PROTO(( void ))
#endif

/* Code executed at the beginning of each rule, after yytext and yyleng
 * have been set up.
 */
#ifndef YY_USER_ACTION
#define YY_USER_ACTION
#endif

/* Code executed at the end of each rule. */
#ifndef YY_BREAK
#define YY_BREAK break;
#endif

#define YY_RULE_SETUP \
	if ( yyleng > 0 ) \
		yy_current_buffer->yy_at_bol = \
				(yytext[yyleng - 1] == '\n'); \
	YY_USER_ACTION

YY_DECL
	{
	register yy_state_type yy_current_state;
	register char *yy_cp, *yy_bp;
	register int yy_act;




	if ( yy_init )
		{
		yy_init = 0;

#ifdef YY_USER_INIT
		YY_USER_INIT;
#endif

		if ( ! yy_start )
			yy_start = 1;	/* first start state */

#if 0
		if ( ! SCNG(yy_in) )
			SCNG(yy_in) = stdin;

		if ( ! SCNG(yy_out) )
			SCNG(yy_out) = stdout;
#endif

		if ( ! yy_current_buffer )
			yy_current_buffer =
				yy_create_buffer( SCNG(yy_in), YY_BUF_SIZE TSRMLS_CC );

		yy_load_buffer_state(TSRMLS_C);
		}

	while ( 1 )		/* loops until end-of-file is reached */
		{
		yy_more_len = 0;
		if ( yy_more_flag )
			{
			yy_more_len = yy_c_buf_p - yytext_ptr;
			yy_more_flag = 0;
			}
		yy_cp = yy_c_buf_p;

		/* Support of yytext. */
		*yy_cp = yy_hold_char;

		/* yy_bp points to the position in yy_ch_buf of the start of
		 * the current run.
		 */
		yy_bp = yy_cp;

		yy_current_state = yy_start;
		yy_current_state += YY_AT_BOL();
yy_match:
		do
			{
			register YY_CHAR yy_c = yy_ec[YY_SC_TO_UI(*yy_cp)];
			if ( yy_accept[yy_current_state] )
				{
				yy_last_accepting_state = yy_current_state;
				yy_last_accepting_cpos = yy_cp;
				}
			while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
				{
				yy_current_state = (int) yy_def[yy_current_state];
				if ( yy_current_state >= 1351 )
					yy_c = yy_meta[(unsigned int) yy_c];
				}
			yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
			++yy_cp;
			}
		while ( yy_base[yy_current_state] != 7936 );

yy_find_action:
		yy_act = yy_accept[yy_current_state];
		if ( yy_act == 0 )
			{ /* have to back up */
			yy_cp = yy_last_accepting_cpos;
			yy_current_state = yy_last_accepting_state;
			yy_act = yy_accept[yy_current_state];
			}

		YY_DO_BEFORE_ACTION;


do_action:	/* This label is used only to access EOF actions. */


		switch ( yy_act )
	{ /* beginning of action switch */
			case 0: /* must back up */
			/* undo the effects of YY_DO_BEFORE_ACTION */
			*yy_cp = yy_hold_char;
			yy_cp = yy_last_accepting_cpos;
			yy_current_state = yy_last_accepting_state;
			goto yy_find_action;

case 1:
YY_RULE_SETUP
{
	return T_EXIT;
}
	YY_BREAK
case 2:
YY_RULE_SETUP
{
	return T_EXIT;
}
	YY_BREAK
case 3:
YY_RULE_SETUP
{
	return T_OLD_FUNCTION;
}
	YY_BREAK
case 4:
YY_RULE_SETUP
{
	return T_FUNCTION;
}
	YY_BREAK
case 5:
YY_RULE_SETUP
{
	return T_CONST;
}
	YY_BREAK
case 6:
YY_RULE_SETUP
{
	return T_RETURN;
}
	YY_BREAK
case 7:
YY_RULE_SETUP
{
	return T_IF;
}
	YY_BREAK
case 8:
YY_RULE_SETUP
{
	return T_ELSEIF;
}
	YY_BREAK
case 9:
YY_RULE_SETUP
{
	return T_ENDIF;
}
	YY_BREAK
case 10:
YY_RULE_SETUP
{
	return T_ELSE;
}
	YY_BREAK
case 11:
YY_RULE_SETUP
{
	return T_WHILE;
}
	YY_BREAK
case 12:
YY_RULE_SETUP
{
	return T_ENDWHILE;
}
	YY_BREAK
case 13:
YY_RULE_SETUP
{
	return T_DO;
}
	YY_BREAK
case 14:
YY_RULE_SETUP
{
	return T_FOR;
}
	YY_BREAK
case 15:
YY_RULE_SETUP
{
	return T_ENDFOR;
}
	YY_BREAK
case 16:
YY_RULE_SETUP
{
	return T_FOREACH;
}
	YY_BREAK
case 17:
YY_RULE_SETUP
{
	return T_ENDFOREACH;
}
	YY_BREAK
case 18:
YY_RULE_SETUP
{
	return T_DECLARE;
}
	YY_BREAK
case 19:
YY_RULE_SETUP
{
	return T_ENDDECLARE;
}
	YY_BREAK
case 20:
YY_RULE_SETUP
{
	return T_AS;
}
	YY_BREAK
case 21:
YY_RULE_SETUP
{
	return T_SWITCH;
}
	YY_BREAK
case 22:
YY_RULE_SETUP
{
	return T_ENDSWITCH;
}
	YY_BREAK
case 23:
YY_RULE_SETUP
{
	return T_CASE;
}
	YY_BREAK
case 24:
YY_RULE_SETUP
{
	return T_DEFAULT;
}
	YY_BREAK
case 25:
YY_RULE_SETUP
{
	return T_BREAK;
}
	YY_BREAK
case 26:
YY_RULE_SETUP
{
	return T_CONTINUE;
}
	YY_BREAK
case 27:
YY_RULE_SETUP
{
	return T_ECHO;
}
	YY_BREAK
case 28:
YY_RULE_SETUP
{
	return T_PRINT;
}
	YY_BREAK
case 29:
YY_RULE_SETUP
{
	return T_CLASS;
}
	YY_BREAK
case 30:
YY_RULE_SETUP
{
	return T_EXTENDS;
}
	YY_BREAK
case 31:
YY_RULE_SETUP
{
	yy_push_state(ST_LOOKING_FOR_PROPERTY TSRMLS_CC);
	return T_OBJECT_OPERATOR;
}
	YY_BREAK
case 32:
YY_RULE_SETUP
{
	yy_pop_state(TSRMLS_C);
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	return T_STRING;
}
	YY_BREAK
case 33:
YY_RULE_SETUP
{
	yyless(0);
	yy_pop_state(TSRMLS_C);
}
	YY_BREAK
case 34:
YY_RULE_SETUP
{
	return T_PAAMAYIM_NEKUDOTAYIM;
}
	YY_BREAK
case 35:
YY_RULE_SETUP
{
	return T_NEW;
}
	YY_BREAK
case 36:
YY_RULE_SETUP
{
	return T_VAR;
}
	YY_BREAK
case 37:
YY_RULE_SETUP
{
	return T_INT_CAST;
}
	YY_BREAK
case 38:
YY_RULE_SETUP
{
	return T_DOUBLE_CAST;
}
	YY_BREAK
case 39:
YY_RULE_SETUP
{
	return T_STRING_CAST;
}
	YY_BREAK
case 40:
YY_RULE_SETUP
{
	return T_ARRAY_CAST;
}
	YY_BREAK
case 41:
YY_RULE_SETUP
{
	return T_OBJECT_CAST;
}
	YY_BREAK
case 42:
YY_RULE_SETUP
{
	return T_BOOL_CAST;
}
	YY_BREAK
case 43:
YY_RULE_SETUP
{
	return T_UNSET_CAST;
}
	YY_BREAK
case 44:
YY_RULE_SETUP
{
	return T_EVAL;
}
	YY_BREAK
case 45:
YY_RULE_SETUP
{
	return T_INCLUDE;
}
	YY_BREAK
case 46:
YY_RULE_SETUP
{
	return T_INCLUDE_ONCE;
}
	YY_BREAK
case 47:
YY_RULE_SETUP
{
	return T_REQUIRE;
}
	YY_BREAK
case 48:
YY_RULE_SETUP
{
	return T_REQUIRE_ONCE;
}
	YY_BREAK
case 49:
YY_RULE_SETUP
{
	return T_USE;
}
	YY_BREAK
case 50:
YY_RULE_SETUP
{
	return T_GLOBAL;
}
	YY_BREAK
case 51:
YY_RULE_SETUP
{
	return T_ISSET;
}
	YY_BREAK
case 52:
YY_RULE_SETUP
{
	return T_EMPTY;
}
	YY_BREAK
case 53:
YY_RULE_SETUP
{
	return T_STATIC;
}
	YY_BREAK
case 54:
YY_RULE_SETUP
{
	return T_UNSET;
}
	YY_BREAK
case 55:
YY_RULE_SETUP
{
	return T_DOUBLE_ARROW;
}
	YY_BREAK
case 56:
YY_RULE_SETUP
{
	return T_LIST;
}
	YY_BREAK
case 57:
YY_RULE_SETUP
{
	return T_ARRAY;
}
	YY_BREAK
case 58:
YY_RULE_SETUP
{
	return T_INC;
}
	YY_BREAK
case 59:
YY_RULE_SETUP
{
	return T_DEC;
}
	YY_BREAK
case 60:
YY_RULE_SETUP
{
	return T_IS_IDENTICAL;
}
	YY_BREAK
case 61:
YY_RULE_SETUP
{
	return T_IS_NOT_IDENTICAL;
}
	YY_BREAK
case 62:
YY_RULE_SETUP
{
	return T_IS_EQUAL;
}
	YY_BREAK
case 63:
YY_RULE_SETUP
{
	return T_IS_NOT_EQUAL;
}
	YY_BREAK
case 64:
YY_RULE_SETUP
{
	return T_IS_SMALLER_OR_EQUAL;
}
	YY_BREAK
case 65:
YY_RULE_SETUP
{
	return T_IS_GREATER_OR_EQUAL;
}
	YY_BREAK
case 66:
YY_RULE_SETUP
{
	return T_PLUS_EQUAL;
}
	YY_BREAK
case 67:
YY_RULE_SETUP
{
	return T_MINUS_EQUAL;
}
	YY_BREAK
case 68:
YY_RULE_SETUP
{
	return T_MUL_EQUAL;
}
	YY_BREAK
case 69:
YY_RULE_SETUP
{
	return T_DIV_EQUAL;
}
	YY_BREAK
case 70:
YY_RULE_SETUP
{
	return T_CONCAT_EQUAL;
}
	YY_BREAK
case 71:
YY_RULE_SETUP
{
	return T_MOD_EQUAL;
}
	YY_BREAK
case 72:
YY_RULE_SETUP
{
	return T_SL_EQUAL;
}
	YY_BREAK
case 73:
YY_RULE_SETUP
{
	return T_SR_EQUAL;
}
	YY_BREAK
case 74:
YY_RULE_SETUP
{
	return T_AND_EQUAL;
}
	YY_BREAK
case 75:
YY_RULE_SETUP
{
	return T_OR_EQUAL;
}
	YY_BREAK
case 76:
YY_RULE_SETUP
{
	return T_XOR_EQUAL;
}
	YY_BREAK
case 77:
YY_RULE_SETUP
{
	return T_BOOLEAN_OR;
}
	YY_BREAK
case 78:
YY_RULE_SETUP
{
	return T_BOOLEAN_AND;
}
	YY_BREAK
case 79:
YY_RULE_SETUP
{
	return T_LOGICAL_OR;
}
	YY_BREAK
case 80:
YY_RULE_SETUP
{
	return T_LOGICAL_AND;
}
	YY_BREAK
case 81:
YY_RULE_SETUP
{
	return T_LOGICAL_XOR;
}
	YY_BREAK
case 82:
YY_RULE_SETUP
{
	return T_SL;
}
	YY_BREAK
case 83:
YY_RULE_SETUP
{
	return T_SR;
}
	YY_BREAK
case 84:
YY_RULE_SETUP
{
	return yytext[0];
}
	YY_BREAK
case 85:
YY_RULE_SETUP
{
	yy_push_state(ST_IN_SCRIPTING TSRMLS_CC);
	return '{';
}
	YY_BREAK
case 86:
YY_RULE_SETUP
{
	yy_push_state(ST_LOOKING_FOR_VARNAME TSRMLS_CC);
	return T_DOLLAR_OPEN_CURLY_BRACES;
}
	YY_BREAK
case 87:
YY_RULE_SETUP
{
	/* This is a temporary fix which is dependant on flex and it's implementation */
	if (yy_start_stack_ptr) {
		yy_pop_state(TSRMLS_C);
	}
	return '}';
}
	YY_BREAK
case 88:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	yy_pop_state(TSRMLS_C);
	yy_push_state(ST_IN_SCRIPTING TSRMLS_CC);
	return T_STRING_VARNAME;
}
	YY_BREAK
case 89:
YY_RULE_SETUP
{
	yyless(0);
	yy_pop_state(TSRMLS_C);
	yy_push_state(ST_IN_SCRIPTING TSRMLS_CC);
}
	YY_BREAK
case 90:
YY_RULE_SETUP
{
	errno = 0;
	zendlval->value.lval = strtol(yytext, NULL, 0);
	if (errno == ERANGE) { /* overflow */
		zendlval->value.dval = zend_strtod(yytext, NULL);
		zendlval->type = IS_DOUBLE;
		return T_DNUMBER;
	} else {
		zendlval->type = IS_LONG;
		return T_LNUMBER;
	}
}
	YY_BREAK
case 91:
YY_RULE_SETUP
{
	errno = 0;
	zendlval->value.lval = strtoul(yytext, NULL, 16);
	if (errno == ERANGE) { /* overflow */
		/* not trying strtod - it returns trash on 0x-es */
		zendlval->value.lval = LONG_MAX; /* maximal long */
		zend_error(E_NOTICE,"Hex number is too big: %s", yytext);
	} else {
		if (zendlval->value.lval < 0) {
			/* maintain consistency with the old way */
			zendlval->value.dval = (unsigned long) zendlval->value.lval;
			zendlval->type = IS_DOUBLE;
			return T_DNUMBER;
		}
		zendlval->type = IS_LONG;
	}
	zendlval->type = IS_LONG;
	return T_LNUMBER;
}
	YY_BREAK
case 92:
YY_RULE_SETUP
{ /* treat numbers (almost) as strings inside encapsulated strings */
	zendlval->value.str.val = (char *)estrndup(yytext, yyleng);
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	return T_NUM_STRING;
}
	YY_BREAK
case 93:
YY_RULE_SETUP
{
	zendlval->value.dval = zend_strtod(yytext, NULL);
	zendlval->type = IS_DOUBLE;
	return T_DNUMBER;
}
	YY_BREAK
case 94:
YY_RULE_SETUP
{
	char *class_name = NULL;

	if (CG(active_class_entry)) {
		class_name = CG(active_class_entry)->name;
	}
	
	if (!class_name) {
		class_name = "";
	}
	zendlval->value.str.len = strlen(class_name);
	zendlval->value.str.val = estrndup(class_name, zendlval->value.str.len);
	zendlval->type = IS_STRING;
	return T_CLASS_C;
}
	YY_BREAK
case 95:
YY_RULE_SETUP
{
	char *func_name = NULL;
	
	if (CG(active_op_array)) {
		func_name = CG(active_op_array)->function_name;
	}

	if (!func_name) {
		func_name = "";
	}
	zendlval->value.str.len = strlen(func_name);
	zendlval->value.str.val = estrndup(func_name, zendlval->value.str.len);
	zendlval->type = IS_STRING;
	return T_FUNC_C;
}
	YY_BREAK
case 96:
YY_RULE_SETUP
{
	zendlval->value.lval = CG(zend_lineno);
	zendlval->type = IS_LONG;
	return T_LINE;
}
	YY_BREAK
case 97:
YY_RULE_SETUP
{
	char *filename = zend_get_compiled_filename(TSRMLS_C);
	
	if (!filename) {
		filename = "";
	}
	zendlval->value.str.len = strlen(filename);
	zendlval->value.str.val = estrndup(filename, zendlval->value.str.len);
	zendlval->type = IS_STRING;
	return T_FILE;
}
	YY_BREAK
case 98:
YY_RULE_SETUP
{
#ifdef ZEND_MULTIBYTE
	if (SCNG(output_filter)) {
		int readsize;
		readsize = SCNG(output_filter)(&(zendlval->value.str.val), &(zendlval->value.str.len), yytext, yyleng TSRMLS_CC);
		if (readsize < yyleng) {
			yyless(readsize);
		}
	} else {
		zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
		zendlval->value.str.len = yyleng;
	}
#else /* ZEND_MULTIBYTE */
	zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
	zendlval->value.str.len = yyleng;
#endif /* ZEND_MULTIBYTE */
	zendlval->type = IS_STRING;
	HANDLE_NEWLINES(yytext, yyleng);
	return T_INLINE_HTML;
}
	YY_BREAK
case 99:
YY_RULE_SETUP
{
	HANDLE_NEWLINES(yytext, yyleng);
	if (CG(short_tags) || yyleng>2) { /* yyleng>2 means it's not <? but <script> */
		zendlval->value.str.val = yytext; /* no copying - intentional */
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		BEGIN(ST_IN_SCRIPTING);
		return T_OPEN_TAG;
	} else {
		zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		return T_INLINE_HTML;
	}
}
	YY_BREAK
case 100:
YY_RULE_SETUP
{
	if ((yytext[1]=='%' && CG(asp_tags)) || (yytext[1]=='?' && CG(short_tags))) {
		zendlval->value.str.val = yytext; /* no copying - intentional */
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		BEGIN(ST_IN_SCRIPTING);
		return T_OPEN_TAG_WITH_ECHO;
	} else {
		zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		return T_INLINE_HTML;
	}
}
	YY_BREAK
case 101:
YY_RULE_SETUP
{
	if (CG(asp_tags)) {
		zendlval->value.str.val = yytext; /* no copying - intentional */
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		BEGIN(ST_IN_SCRIPTING);
		return T_OPEN_TAG;
	} else {
		zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		return T_INLINE_HTML;
	}
}
	YY_BREAK
case 102:
YY_RULE_SETUP
{
	zendlval->value.str.val = yytext; /* no copying - intentional */
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	HANDLE_NEWLINE(yytext[yyleng-1]);
	BEGIN(ST_IN_SCRIPTING);
	return T_OPEN_TAG;
}
	YY_BREAK
case 103:
YY_RULE_SETUP
{
	zend_error(E_WARNING, "&lt;?php_track_vars?&gt; is no longer supported - please use the track_vars INI directive instead");
	HANDLE_NEWLINE(yytext[yyleng-1]);
	zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	return T_INLINE_HTML;
}
	YY_BREAK
case 104:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, (yytext+1), (yyleng-1));
	zendlval->type = IS_STRING;
	return T_VARIABLE;
}
	YY_BREAK
case 105:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	return T_STRING;
}
	YY_BREAK
case 106:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	return T_STRING;
}
	YY_BREAK
case 107:
YY_RULE_SETUP
{
	zendlval->value.str.val = yytext; /* no copying - intentional */
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	HANDLE_NEWLINES(yytext, yyleng);
	return T_WHITESPACE;
}
	YY_BREAK
case 108:
YY_RULE_SETUP
{
	BEGIN(ST_ONE_LINE_COMMENT);
	yymore();
}
	YY_BREAK
case 109:
YY_RULE_SETUP
{
	yymore();
}
	YY_BREAK
case 110:
YY_RULE_SETUP
{
	yymore();
}
	YY_BREAK
case 111:
YY_RULE_SETUP
{
	zendlval->value.str.val = yytext; /* no copying - intentional */
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	BEGIN(ST_IN_SCRIPTING);
	CG(zend_lineno)++;
	return T_COMMENT;
}
	YY_BREAK
case 112:
YY_RULE_SETUP
{
    if (CG(asp_tags) || yytext[yyleng-2] != '%') { /* asp comment? */
		zendlval->value.str.val = yytext; /* no copying - intentional */
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		yyless(yyleng-2);
		BEGIN(ST_IN_SCRIPTING);
		return T_COMMENT;
	} else {
		yymore();
	}
}
	YY_BREAK
case 113:
YY_RULE_SETUP
{
	CG(comment_start_line) = CG(zend_lineno);
	BEGIN(ST_COMMENT);
	yymore();
}
	YY_BREAK
case 114:
YY_RULE_SETUP
{
	yymore();
}
	YY_BREAK
case 115:
YY_RULE_SETUP
{
	HANDLE_NEWLINES(yytext, yyleng);
	BEGIN(ST_IN_SCRIPTING);
	return T_COMMENT;
}
	YY_BREAK
case 116:
YY_RULE_SETUP
{
	yymore();
}
	YY_BREAK
case 117:
YY_RULE_SETUP
{
	zendlval->value.str.val = yytext; /* no copying - intentional */
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	BEGIN(INITIAL);
	return T_CLOSE_TAG;  /* implicit ';' at php-end tag */
}
	YY_BREAK
case 118:
YY_RULE_SETUP
{
	if (CG(asp_tags)) {
		BEGIN(INITIAL);
		zendlval->value.str.len = yyleng;
		zendlval->type = IS_STRING;
		zendlval->value.str.val = yytext; /* no copying - intentional */
		return T_CLOSE_TAG;  /* implicit ';' at php-end tag */
	} else {
		yyless(1);
		return yytext[0];
	}
}
	YY_BREAK
case 119:
YY_RULE_SETUP
{
	register char *s, *t;
	char *end;
	
	zendlval->value.str.val = estrndup(yytext+1, yyleng-2);
	zendlval->value.str.len = yyleng-2;
	zendlval->type = IS_STRING;
	HANDLE_NEWLINES(yytext, yyleng);
	
	/* convert escape sequences */
	s = t = zendlval->value.str.val;
	end = s+zendlval->value.str.len;
	while (s<end) {
		if (*s=='\\') {
			s++;
			if (s>=end) {
				continue;
			}
			switch(*s) {
				case 'n':
					*t++ = '\n';
					zendlval->value.str.len--;
					break;
				case 'r':
					*t++ = '\r';
					zendlval->value.str.len--;
					break;
				case 't':
					*t++ = '\t';
					zendlval->value.str.len--;
					break;
				case '\\':
				case '$':
				case '"':
					*t++ = *s;
					zendlval->value.str.len--;
					break;
				default:
					/* check for an octal */
					if (ZEND_IS_OCT(*s)) {
						char octal_buf[4] = { 0, 0, 0, 0 };

						octal_buf[0] = *s;
						zendlval->value.str.len--;
						if ((s+1)<end && ZEND_IS_OCT(*(s+1))) {
							octal_buf[1] = *(++s);
							zendlval->value.str.len--;
							if ((s+1)<end && ZEND_IS_OCT(*(s+1))) {
								octal_buf[2] = *(++s);
								zendlval->value.str.len--;
							}
						}
						*t++ = (char) strtol(octal_buf, NULL, 8);
					} else if (*s=='x' && (s+1)<end && ZEND_IS_HEX(*(s+1))) {
						char hex_buf[3] = { 0, 0, 0};

						zendlval->value.str.len--; /* for the 'x' */

						hex_buf[0] = *(++s);
						zendlval->value.str.len--;
						if ((s+1)<end && ZEND_IS_HEX(*(s+1))) {
							hex_buf[1] = *(++s);
							zendlval->value.str.len--;
						}
						*t++ = (char) strtol(hex_buf, NULL, 16);
					} else {
						*t++ = '\\';
						*t++ = *s;
					}
					break;
			}
			s++;
		} else {
			*t++ = *s++;
		}
	}
	*t = 0;

#ifdef ZEND_MULTIBYTE
	if (SCNG(output_filter)) {
		s = zendlval->value.str.val;
		SCNG(output_filter)(&(zendlval->value.str.val), &(zendlval->value.str.len), s, zendlval->value.str.len TSRMLS_CC);
		efree(s);
	}
#endif /* ZEND_MULTIBYTE */

	return T_CONSTANT_ENCAPSED_STRING;
}
	YY_BREAK
case 120:
YY_RULE_SETUP
{
	register char *s, *t;
	char *end;
	
	zendlval->value.str.val = estrndup(yytext+1, yyleng-2);
	zendlval->value.str.len = yyleng-2;
	zendlval->type = IS_STRING;
	HANDLE_NEWLINES(yytext, yyleng);
	
	/* convert escape sequences */
	s = t = zendlval->value.str.val;
	end = s+zendlval->value.str.len;
	while (s<end) {
		if (*s=='\\') {
			s++;
			if (s>=end) {
				continue;
			}
			switch(*s) {
				case '\\':
				case '\'':
					*t++ = *s;
					zendlval->value.str.len--;
					break;
				default:
					*t++ = '\\';
					*t++ = *s;
					break;
			}
			s++;
		} else {
			*t++ = *s++;
		}
	}
	*t = 0;

#ifdef ZEND_MULTIBYTE
	if (SCNG(output_filter)) {
		s = zendlval->value.str.val;
		SCNG(output_filter)(&(zendlval->value.str.val), &(zendlval->value.str.len), s, zendlval->value.str.len TSRMLS_CC);
		efree(s);
	}
#endif /* ZEND_MULTIBYTE */

	return T_CONSTANT_ENCAPSED_STRING;
}
	YY_BREAK
case 121:
YY_RULE_SETUP
{
	BEGIN(ST_DOUBLE_QUOTES);
	return '\"';
}
	YY_BREAK
case 122:
YY_RULE_SETUP
{
	char *s;
	CG(zend_lineno)++;
	CG(heredoc_len) = yyleng-3-1-(yytext[yyleng-2]=='\r'?1:0);
	s = yytext+3;
	while ((*s == ' ') || (*s == '\t')) {
		s++;
		CG(heredoc_len)--;
	}
	CG(heredoc) = estrndup(s, CG(heredoc_len));
	BEGIN(ST_HEREDOC);
	return T_START_HEREDOC;
}
	YY_BREAK
case 123:
YY_RULE_SETUP
{
	BEGIN(ST_BACKQUOTE);
	return '`';
}
	YY_BREAK
case 124:
YY_RULE_SETUP
{
	BEGIN(ST_SINGLE_QUOTE);
	return '\'';
}
	YY_BREAK
case 125:
YY_RULE_SETUP
{
	int label_len;
	unsigned char unput_semicolon;

	CG(zend_lineno)++;
	if (yytext[yyleng-2]=='\r') {
		label_len = yyleng-2;
	} else {
		label_len = yyleng-1;
	}
	
	if (yytext[label_len-1]==';') {
		label_len--;
		unput_semicolon=1;
	} else{
		unput_semicolon=0;
	}

	if (label_len==CG(heredoc_len) && !memcmp(yytext, CG(heredoc), label_len)) {
		zendlval->value.str.val = estrndup(yytext, label_len); /* unput destroys yytext */
		zendlval->value.str.len = label_len;
		if (unput_semicolon) {
			unput(';');
		}
		efree(CG(heredoc));
		CG(heredoc)=NULL;
		CG(heredoc_len)=0;
		BEGIN(ST_IN_SCRIPTING);
		return T_END_HEREDOC;
	} else {
 		zend_copy_value(zendlval, yytext, yyleng);
		zendlval->type = IS_STRING;
		return T_STRING;
	}
}
	YY_BREAK
case 126:
YY_RULE_SETUP
{
	HANDLE_NEWLINES(yytext, yyleng);
	zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	return T_ENCAPSED_AND_WHITESPACE;
}
	YY_BREAK
case 127:
YY_RULE_SETUP
{
	HANDLE_NEWLINES(yytext, yyleng);
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	return T_ENCAPSED_AND_WHITESPACE;
}
	YY_BREAK
case 128:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	return T_ENCAPSED_AND_WHITESPACE;
}
	YY_BREAK
case 129:
YY_RULE_SETUP
{
 	zend_copy_value(zendlval, yytext, yyleng);
	zendlval->type = IS_STRING;
	return T_ENCAPSED_AND_WHITESPACE;
}
	YY_BREAK
case 130:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) yytext[0];
	if (yyleng == 2) {
		yyless(1);
	}
	return T_CHARACTER;	
}
	YY_BREAK
case 131:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) yytext[0];
	return yytext[0];
}
	YY_BREAK
case 132:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) yytext[0];
	yy_push_state(ST_IN_SCRIPTING TSRMLS_CC);
	yyless(1);
	return T_CURLY_OPEN;
}
	YY_BREAK
case 133:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) '\'';
	return T_CHARACTER;
}
	YY_BREAK
case 134:
YY_RULE_SETUP
{
	zendlval->value.lval = (long)'\\';
	return T_CHARACTER;
}
	YY_BREAK
case 135:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) '"';
	return T_CHARACTER;
}
	YY_BREAK
case 136:
YY_RULE_SETUP
{
	zendlval->value.lval = (long) '`';
	return T_CHARACTER;
}
	YY_BREAK
case 137:
YY_RULE_SETUP
{
	zendlval->value.lval = strtol(yytext+1, NULL, 8);
	return T_CHARACTER;
}
	YY_BREAK
case 138:
YY_RULE_SETUP
{
	zendlval->value.lval = strtol (yytext+2, NULL, 16);
	return T_CHARACTER;
}
	YY_BREAK
case 139:
YY_RULE_SETUP
{
	switch (yytext[1]) {
		case 'n':
			zendlval->value.lval = (long) '\n';
			break;
		case 't':
			zendlval->value.lval = (long) '\t';
			break;
		case 'r':
			zendlval->value.lval = (long) '\r';
			break;
		case '\\':
			zendlval->value.lval = (long) '\\';
			break;
		case '$':
			zendlval->value.lval = (long) yytext[1];
			break;
		case '{':
			zendlval->value.lval = (long) yytext[1];
			break;
		default:
			zendlval->value.str.val = estrndup(yytext, yyleng);
			zendlval->value.str.len = yyleng;
			zendlval->type = IS_STRING;
			return T_BAD_CHARACTER;
			break;
	}
	return T_CHARACTER;
}
	YY_BREAK
case 140:
YY_RULE_SETUP
{
	zendlval->value.str.val = (char *) estrndup(yytext, yyleng);
	zendlval->value.str.len = yyleng;
	zendlval->type = IS_STRING;
	return T_ENCAPSED_AND_WHITESPACE;
}
	YY_BREAK
case 141:
YY_RULE_SETUP
{
	BEGIN(ST_IN_SCRIPTING);
	return '\"';
}
	YY_BREAK
case 142:
YY_RULE_SETUP
{
	BEGIN(ST_IN_SCRIPTING);
	return '`';
}
	YY_BREAK
case 143:
YY_RULE_SETUP
{
	BEGIN(ST_IN_SCRIPTING);
	return '\'';
}
	YY_BREAK
case YY_STATE_EOF(ST_DOUBLE_QUOTES):
case YY_STATE_EOF(ST_BACKQUOTE):
case YY_STATE_EOF(INITIAL):
case YY_STATE_EOF(ST_IN_SCRIPTING):
case YY_STATE_EOF(ST_LOOKING_FOR_PROPERTY):
{
	return 0;
}
	YY_BREAK
case YY_STATE_EOF(ST_COMMENT):
{
	zend_error(E_COMPILE_WARNING,"Unterminated comment starting line %d", CG(comment_start_line));
	return 0;
}
	YY_BREAK
case 144:
YY_RULE_SETUP
{
	zend_error(E_COMPILE_WARNING,"Unexpected character in input:  '%c' (ASCII=%d) state=%d", yytext[0], yytext[0], YYSTATE);
}
	YY_BREAK
case 145:
YY_RULE_SETUP
ECHO;
	YY_BREAK
case YY_STATE_EOF(ST_SINGLE_QUOTE):
case YY_STATE_EOF(ST_HEREDOC):
case YY_STATE_EOF(ST_LOOKING_FOR_VARNAME):
case YY_STATE_EOF(ST_ONE_LINE_COMMENT):
	yyterminate();

	case YY_END_OF_BUFFER:
		{
		/* Amount of text matched not including the EOB char. */
		int yy_amount_of_matched_text = (int) (yy_cp - yytext_ptr) - 1;

		/* Undo the effects of YY_DO_BEFORE_ACTION. */
		*yy_cp = yy_hold_char;

		if ( yy_current_buffer->yy_buffer_status == YY_BUFFER_NEW )
			{
			/* We're scanning a new file or input source.  It's
			 * possible that this happened because the user
			 * just pointed yyin at a new source and called
			 * yylex().  If so, then we have to assure
			 * consistency between yy_current_buffer and our
			 * globals.  Here is the right place to do so, because
			 * this is the first action (other than possibly a
			 * back-up) that will match for the new input source.
			 */
			SCNG(yy_n_chars) = yy_current_buffer->yy_n_chars;
			yy_current_buffer->yy_input_file = SCNG(yy_in);
			yy_current_buffer->yy_buffer_status = YY_BUFFER_NORMAL;
			}

		/* Note that here we test for yy_c_buf_p "<=" to the position
		 * of the first EOB in the buffer, since yy_c_buf_p will
		 * already have been incremented past the NUL character
		 * (since all states make transitions on EOB to the
		 * end-of-buffer state).  Contrast this with the test
		 * in input().
		 */
		if ( yy_c_buf_p <= &yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars)] )
			{ /* This was really a NUL. */
			yy_state_type yy_next_state;

			yy_c_buf_p = yytext_ptr + yy_amount_of_matched_text;

			yy_current_state = yy_get_previous_state(TSRMLS_C);

			/* Okay, we're now positioned to make the NUL
			 * transition.  We couldn't have
			 * yy_get_previous_state() go ahead and do it
			 * for us because it doesn't know how to deal
			 * with the possibility of jamming (and we don't
			 * want to build jamming into it because then it
			 * will run more slowly).
			 */

			yy_next_state = yy_try_NUL_trans( yy_current_state TSRMLS_CC );

			yy_bp = yytext_ptr + YY_MORE_ADJ;

			if ( yy_next_state )
				{
				/* Consume the NUL. */
				yy_cp = ++yy_c_buf_p;
				yy_current_state = yy_next_state;
				goto yy_match;
				}

			else
				{
				yy_cp = yy_c_buf_p;
				goto yy_find_action;
				}
			}

		else switch ( yy_get_next_buffer(TSRMLS_C) )
			{
			case EOB_ACT_END_OF_FILE:
				{
				yy_did_buffer_switch_on_eof = 0;

				if ( yywrap() )
					{
					/* Note: because we've taken care in
					 * yy_get_next_buffer() to have set up
					 * yytext, we can now set up
					 * yy_c_buf_p so that if some total
					 * hoser (like flex itself) wants to
					 * call the scanner after we return the
					 * YY_NULL, it'll still work - another
					 * YY_NULL will get returned.
					 */
					yy_c_buf_p = yytext_ptr + YY_MORE_ADJ;

					yy_act = YY_STATE_EOF(YY_START);
					goto do_action;
					}

				else
					{
					if ( ! yy_did_buffer_switch_on_eof )
						YY_NEW_FILE;
					}
				break;
				}

			case EOB_ACT_CONTINUE_SCAN:
				yy_c_buf_p =
					yytext_ptr + yy_amount_of_matched_text;

				yy_current_state = yy_get_previous_state(TSRMLS_C);

				yy_cp = yy_c_buf_p;
				yy_bp = yytext_ptr + YY_MORE_ADJ;
				goto yy_match;

			case EOB_ACT_LAST_MATCH:
				yy_c_buf_p =
				&yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars)];

				yy_current_state = yy_get_previous_state(TSRMLS_C);

				yy_cp = yy_c_buf_p;
				yy_bp = yytext_ptr + YY_MORE_ADJ;
				goto yy_find_action;
			}
		break;
		}

	default:
		YY_FATAL_ERROR(
			"fatal flex scanner internal error--no action found" );
	} /* end of action switch */
		} /* end of scanning one token */
	} /* end of yylex */


/* yy_get_next_buffer - try to read in a new buffer
 *
 * Returns a code representing an action:
 *	EOB_ACT_LAST_MATCH -
 *	EOB_ACT_CONTINUE_SCAN - continue scanning from current position
 *	EOB_ACT_END_OF_FILE - end of file
 */

static int yy_get_next_buffer(TSRMLS_D)
	{
	register char *dest = yy_current_buffer->yy_ch_buf;
	register char *source = yytext_ptr;
	register int number_to_move, i;
	int ret_val;

	if ( yy_c_buf_p > &yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars) + 1] )
		YY_FATAL_ERROR(
		"fatal flex scanner internal error--end of buffer missed" );

	if ( yy_current_buffer->yy_fill_buffer == 0 )
		{ /* Don't try to fill the buffer, so this is an EOF. */
		if ( yy_c_buf_p - yytext_ptr - YY_MORE_ADJ == 1 )
			{
			/* We matched a single character, the EOB, so
			 * treat this as a final EOF.
			 */
			return EOB_ACT_END_OF_FILE;
			}

		else
			{
			/* We matched some text prior to the EOB, first
			 * process it.
			 */
			return EOB_ACT_LAST_MATCH;
			}
		}

	/* Try to read more data. */

	/* First move last chars to start of buffer. */
	number_to_move = (int) (yy_c_buf_p - yytext_ptr) - 1;

	for ( i = 0; i < number_to_move; ++i )
		*(dest++) = *(source++);

	if ( yy_current_buffer->yy_buffer_status == YY_BUFFER_EOF_PENDING )
		/* don't do the read, it's not guaranteed to return an EOF,
		 * just force an EOF
		 */
		yy_current_buffer->yy_n_chars = SCNG(yy_n_chars) = 0;

	else
		{
		int num_to_read =
			yy_current_buffer->yy_buf_size - number_to_move - 1;

		while ( num_to_read <= 0 )
			{ /* Not enough room in the buffer - grow it. */
#ifdef YY_USES_REJECT
			YY_FATAL_ERROR(
"input buffer overflow, can't enlarge buffer because scanner uses REJECT" );
#else

			/* just a shorter name for the current buffer */
			YY_BUFFER_STATE b = yy_current_buffer;

			int yy_c_buf_p_offset =
				(int) (yy_c_buf_p - b->yy_ch_buf);

			if ( b->yy_is_our_buffer )
				{
				int new_size = b->yy_buf_size * 2;

				if ( new_size <= 0 )
					b->yy_buf_size += b->yy_buf_size / 8;
				else
					b->yy_buf_size *= 2;

				b->yy_ch_buf = (char *)
					/* Include room in for 2 EOB chars. */
					yy_flex_realloc( (void *) b->yy_ch_buf,
							 b->yy_buf_size + 2 );
				}
			else
				/* Can't grow it, we don't own it. */
				b->yy_ch_buf = 0;

			if ( ! b->yy_ch_buf )
				YY_FATAL_ERROR(
				"fatal error - scanner input buffer overflow" );

			yy_c_buf_p = &b->yy_ch_buf[yy_c_buf_p_offset];

			num_to_read = yy_current_buffer->yy_buf_size -
						number_to_move - 1;
#endif
			}

		if ( num_to_read > YY_READ_BUF_SIZE )
			num_to_read = YY_READ_BUF_SIZE;

		/* Read in more data. */
		YY_INPUT( (&yy_current_buffer->yy_ch_buf[number_to_move]),
			SCNG(yy_n_chars), num_to_read );

		yy_current_buffer->yy_n_chars = SCNG(yy_n_chars);
		}

	if ( SCNG(yy_n_chars) == 0 )
		{
		if ( number_to_move == YY_MORE_ADJ )
			{
			ret_val = EOB_ACT_END_OF_FILE;
			yyrestart( SCNG(yy_in) TSRMLS_CC );
			}

		else
			{
			ret_val = EOB_ACT_LAST_MATCH;
			yy_current_buffer->yy_buffer_status =
				YY_BUFFER_EOF_PENDING;
			}
		}

	else
		ret_val = EOB_ACT_CONTINUE_SCAN;

	SCNG(yy_n_chars) += number_to_move;
	yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars)] = YY_END_OF_BUFFER_CHAR;
	yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars) + 1] = YY_END_OF_BUFFER_CHAR;

	yytext_ptr = &yy_current_buffer->yy_ch_buf[0];

	return ret_val;
	}


/* yy_get_previous_state - get the state just before the EOB char was reached */

static yy_state_type yy_get_previous_state(TSRMLS_D)
	{
	register yy_state_type yy_current_state;
	register char *yy_cp;

	yy_current_state = yy_start;
	yy_current_state += YY_AT_BOL();

	for ( yy_cp = yytext_ptr + YY_MORE_ADJ; yy_cp < yy_c_buf_p; ++yy_cp )
		{
		register YY_CHAR yy_c = (*yy_cp ? yy_ec[YY_SC_TO_UI(*yy_cp)] : 1);
		if ( yy_accept[yy_current_state] )
			{
			yy_last_accepting_state = yy_current_state;
			yy_last_accepting_cpos = yy_cp;
			}
		while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
			{
			yy_current_state = (int) yy_def[yy_current_state];
			if ( yy_current_state >= 1351 )
				yy_c = yy_meta[(unsigned int) yy_c];
			}
		yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
		}

	return yy_current_state;
	}


/* yy_try_NUL_trans - try to make a transition on the NUL character
 *
 * synopsis
 *	next_state = yy_try_NUL_trans( current_state );
 */

#ifdef YY_USE_PROTOS
static yy_state_type yy_try_NUL_trans( yy_state_type yy_current_state TSRMLS_DC )
#else
static yy_state_type yy_try_NUL_trans( yy_current_state TSRMLS_CC )
yy_state_type yy_current_state;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	register int yy_is_jam;
	register char *yy_cp = yy_c_buf_p;

	register YY_CHAR yy_c = 1;
	if ( yy_accept[yy_current_state] )
		{
		yy_last_accepting_state = yy_current_state;
		yy_last_accepting_cpos = yy_cp;
		}
	while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
		{
		yy_current_state = (int) yy_def[yy_current_state];
		if ( yy_current_state >= 1351 )
			yy_c = yy_meta[(unsigned int) yy_c];
		}
	yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
	yy_is_jam = (yy_current_state == 1350);

	return yy_is_jam ? 0 : yy_current_state;
	}


#ifndef YY_NO_UNPUT
#ifdef YY_USE_PROTOS
static void yyunput( int c, register char *yy_bp TSRMLS_DC )
#else
static void yyunput( c, yy_bp TSRMLS_CC )
int c;
register char *yy_bp;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	register char *yy_cp = yy_c_buf_p;

	/* undo effects of setting up yytext */
	*yy_cp = yy_hold_char;

	if ( yy_cp < yy_current_buffer->yy_ch_buf + 2 )
		{ /* need to shift things up to make room */
		/* +2 for EOB chars. */
		register int number_to_move = SCNG(yy_n_chars) + 2;
		register char *dest = &yy_current_buffer->yy_ch_buf[
					yy_current_buffer->yy_buf_size + 2];
		register char *source =
				&yy_current_buffer->yy_ch_buf[number_to_move];

		while ( source > yy_current_buffer->yy_ch_buf )
			*--dest = *--source;

		yy_cp += (int) (dest - source);
		yy_bp += (int) (dest - source);
		yy_current_buffer->yy_n_chars =
			SCNG(yy_n_chars) = yy_current_buffer->yy_buf_size;

		if ( yy_cp < yy_current_buffer->yy_ch_buf + 2 )
			YY_FATAL_ERROR( "flex scanner push-back overflow" );
		}

	*--yy_cp = (char) c;


	yytext_ptr = yy_bp;
	yy_hold_char = *yy_cp;
	yy_c_buf_p = yy_cp;
	}
#endif	/* ifndef YY_NO_UNPUT */


#ifdef __cplusplus
static int yyinput(TSRMLS_D)
#else
static int input(TSRMLS_C)
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	int c;

	*yy_c_buf_p = yy_hold_char;

	if ( *yy_c_buf_p == YY_END_OF_BUFFER_CHAR )
		{
		/* yy_c_buf_p now points to the character we want to return.
		 * If this occurs *before* the EOB characters, then it's a
		 * valid NUL; if not, then we've hit the end of the buffer.
		 */
		if ( yy_c_buf_p < &yy_current_buffer->yy_ch_buf[SCNG(yy_n_chars)] )
			/* This was really a NUL. */
			*yy_c_buf_p = '\0';

		else
			{ /* need more input */
			int offset = yy_c_buf_p - yytext_ptr;
			++yy_c_buf_p;

			switch ( yy_get_next_buffer(TSRMLS_C) )
				{
				case EOB_ACT_LAST_MATCH:
					/* This happens because yy_g_n_b()
					 * sees that we've accumulated a
					 * token and flags that we need to
					 * try matching the token before
					 * proceeding.  But for input(),
					 * there's no matching to consider.
					 * So convert the EOB_ACT_LAST_MATCH
					 * to EOB_ACT_END_OF_FILE.
					 */

					/* Reset buffer status. */
					yyrestart( SCNG(yy_in) TSRMLS_CC );

					/* fall through */

				case EOB_ACT_END_OF_FILE:
					{
					if ( yywrap() )
						return EOF;

					if ( ! yy_did_buffer_switch_on_eof )
						YY_NEW_FILE;
#ifdef __cplusplus
					return yyinput(TSRMLS_C);
#else
					return input(TSRMLS_C);
#endif
					}

				case EOB_ACT_CONTINUE_SCAN:
					yy_c_buf_p = yytext_ptr + offset;
					break;
				}
			}
		}

	c = *(unsigned char *) yy_c_buf_p;	/* cast for 8-bit char's */
	*yy_c_buf_p = '\0';	/* preserve yytext */
	yy_hold_char = *++yy_c_buf_p;

	yy_current_buffer->yy_at_bol = (c == '\n');

	return c;
	}


#ifdef YY_USE_PROTOS
void yyrestart( struct _zend_file_handle *input_file TSRMLS_DC )
#else
void yyrestart( input_file TSRMLS_CC )
struct _zend_file_handle *input_file;
#endif
	{
	if ( ! yy_current_buffer )
		yy_current_buffer = yy_create_buffer( SCNG(yy_in), YY_BUF_SIZE TSRMLS_CC );

	yy_init_buffer( yy_current_buffer, input_file TSRMLS_CC );
	yy_load_buffer_state(TSRMLS_C);
	}


#ifdef YY_USE_PROTOS
void yy_switch_to_buffer( YY_BUFFER_STATE new_buffer TSRMLS_DC)
#else
void yy_switch_to_buffer( new_buffer TSRMLS_CC)
YY_BUFFER_STATE new_buffer;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	if ( yy_current_buffer == new_buffer )
		return;

	if ( yy_current_buffer )
		{
		/* Flush out information for old buffer. */
		*yy_c_buf_p = yy_hold_char;
		yy_current_buffer->yy_buf_pos = yy_c_buf_p;
		yy_current_buffer->yy_n_chars = SCNG(yy_n_chars);
		}

	yy_current_buffer = new_buffer;
	yy_load_buffer_state(TSRMLS_C);

	/* We don't actually know whether we did this switch during
	 * EOF (yywrap()) processing, but the only time this flag
	 * is looked at is after yywrap() is called, so it's safe
	 * to go ahead and always set it.
	 */
	yy_did_buffer_switch_on_eof = 1;
	}


#ifdef YY_USE_PROTOS
void yy_load_buffer_state( TSRMLS_D )
#else
void yy_load_buffer_state(TSRMLS_C)
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	SCNG(yy_n_chars) = yy_current_buffer->yy_n_chars;
	yytext_ptr = yy_c_buf_p = yy_current_buffer->yy_buf_pos;
	SCNG(yy_in) = yy_current_buffer->yy_input_file;
	yy_hold_char = *yy_c_buf_p;
	}


#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_create_buffer( struct _zend_file_handle *file, int size TSRMLS_DC )
#else
YY_BUFFER_STATE yy_create_buffer( file, size TSRMLS_CC )
struct _zend_file_handle *file;
int size;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	YY_BUFFER_STATE b;

	b = (YY_BUFFER_STATE) yy_flex_alloc( sizeof( struct yy_buffer_state ) );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_buf_size = size;

	/* yy_ch_buf has to be 2 characters longer than the size given because
	 * we need to put in 2 end-of-buffer characters.
	 */
	b->yy_ch_buf = (char *) yy_flex_alloc( b->yy_buf_size + 2 );
	if ( ! b->yy_ch_buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_is_our_buffer = 1;

	yy_init_buffer( b, file TSRMLS_CC );

	return b;
	}


#ifdef YY_USE_PROTOS
void yy_delete_buffer( YY_BUFFER_STATE b TSRMLS_DC )
#else
void yy_delete_buffer( b TSRMLS_CC )
YY_BUFFER_STATE b;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	if ( ! b )
		return;

	if ( b == yy_current_buffer )
		yy_current_buffer = (YY_BUFFER_STATE) 0;

	if ( b->yy_is_our_buffer )
		yy_flex_free( (void *) b->yy_ch_buf );

	yy_flex_free( (void *) b );
	}


#ifndef YY_ALWAYS_INTERACTIVE
#ifndef YY_NEVER_INTERACTIVE
#endif
#endif

#ifdef YY_USE_PROTOS
void yy_init_buffer( YY_BUFFER_STATE b, struct _zend_file_handle *file TSRMLS_DC )
#else
void yy_init_buffer( b, file TSRMLS_CC )
YY_BUFFER_STATE b;
struct _zend_file_handle *file;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif


	{
	yy_flush_buffer( b TSRMLS_CC );

	b->yy_input_file = file;
	b->yy_fill_buffer = 1;

	}


#ifdef YY_USE_PROTOS
void yy_flush_buffer( YY_BUFFER_STATE b TSRMLS_DC )
#else
void yy_flush_buffer( b TSRMLS_CC )
YY_BUFFER_STATE b;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif

	{
	if ( ! b )
		return;

	b->yy_n_chars = 0;

	/* We always need two end-of-buffer characters.  The first causes
	 * a transition to the end-of-buffer state.  The second causes
	 * a jam in that state.
	 */
	b->yy_ch_buf[0] = YY_END_OF_BUFFER_CHAR;
	b->yy_ch_buf[1] = YY_END_OF_BUFFER_CHAR;

	b->yy_buf_pos = &b->yy_ch_buf[0];

	b->yy_at_bol = 1;
	b->yy_buffer_status = YY_BUFFER_NEW;

	if ( b == yy_current_buffer )
		yy_load_buffer_state(TSRMLS_C);
	}


#ifndef YY_NO_SCAN_BUFFER
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_buffer( char *base, yy_size_t size TSRMLS_DC )
#else
YY_BUFFER_STATE yy_scan_buffer( base, size TSRMLS_CC )
char *base;
yy_size_t size;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	YY_BUFFER_STATE b;

	if ( size < 2 ||
	     base[size-2] != YY_END_OF_BUFFER_CHAR ||
	     base[size-1] != YY_END_OF_BUFFER_CHAR )
		/* They forgot to leave room for the EOB's. */
		return 0;

	b = (YY_BUFFER_STATE) yy_flex_alloc( sizeof( struct yy_buffer_state ) );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_buffer()" );

	b->yy_buf_size = size - 2;	/* "- 2" to take care of EOB's */
	b->yy_buf_pos = b->yy_ch_buf = base;
	b->yy_is_our_buffer = 0;
	b->yy_input_file = 0;
	b->yy_n_chars = b->yy_buf_size;
	b->yy_at_bol = 1;
	b->yy_fill_buffer = 0;
	b->yy_buffer_status = YY_BUFFER_NEW;

	yy_switch_to_buffer( b TSRMLS_CC );

	return b;
	}
#endif


#ifndef YY_NO_SCAN_STRING
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_string( yyconst char *yy_str TSRMLS_DC )
#else
YY_BUFFER_STATE yy_scan_string( yy_str TSRMLS_CC )
yyconst char *yy_str;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	int len;
	for ( len = 0; yy_str[len]; ++len )
		;

	return yy_scan_bytes( yy_str, len TSRMLS_CC );
	}
#endif


#ifndef YY_NO_SCAN_BYTES
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_bytes( yyconst char *bytes, int len TSRMLS_DC )
#else
YY_BUFFER_STATE yy_scan_bytes( bytes, len TSRMLS_CC )
yyconst char *bytes;
int len;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	YY_BUFFER_STATE b;
	char *buf;
	yy_size_t n;
	int i;

	/* Get memory for full buffer, including space for trailing EOB's. */
	n = len + 2;
	buf = (char *) yy_flex_alloc( n );
	if ( ! buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_bytes()" );

	for ( i = 0; i < len; ++i )
		buf[i] = bytes[i];

	buf[len] = buf[len+1] = YY_END_OF_BUFFER_CHAR;

	b = yy_scan_buffer( buf, n TSRMLS_CC);
	if ( ! b )
		YY_FATAL_ERROR( "bad buffer in yy_scan_bytes()" );

	/* It's okay to grow etc. this buffer, and we should throw it
	 * away when we're done.
	 */
	b->yy_is_our_buffer = 1;

	return b;
	}
#endif


#ifndef YY_NO_PUSH_STATE
#ifdef YY_USE_PROTOS
static void yy_push_state( int new_state TSRMLS_DC )
#else
static void yy_push_state( new_state TSRMLS_CC )
int new_state;
#ifdef ZTS
void ***tsrm_ls;
#endif
#endif
	{
	if ( yy_start_stack_ptr >= yy_start_stack_depth )
		{
		yy_size_t new_size;

		yy_start_stack_depth += YY_START_STACK_INCR;
		new_size = yy_start_stack_depth * sizeof( int );

		if ( ! yy_start_stack )
			yy_start_stack = (int *) yy_flex_alloc( new_size );

		else
			yy_start_stack = (int *) yy_flex_realloc(
					(void *) yy_start_stack, new_size );

		if ( ! yy_start_stack )
			YY_FATAL_ERROR(
			"out of memory expanding start-condition stack" );
		}

	yy_start_stack[yy_start_stack_ptr++] = YY_START;

	BEGIN(new_state);
	}
#endif


#ifndef YY_NO_POP_STATE
static void yy_pop_state(TSRMLS_D)
	{
	if ( --yy_start_stack_ptr < 0 )
		YY_FATAL_ERROR( "start-condition stack underflow" );

	BEGIN(yy_start_stack[yy_start_stack_ptr]);
	}
#endif


#ifndef YY_NO_TOP_STATE
static int yy_top_state(TSRMLS_D)
	{
	return yy_start_stack[yy_start_stack_ptr - 1];
	}
#endif

#ifndef YY_EXIT_FAILURE
#define YY_EXIT_FAILURE 2
#endif

#ifdef YY_USE_PROTOS
static void yy_fatal_error( yyconst char msg[] )
#else
static void yy_fatal_error( msg )
char msg[];
#endif
	{
	(void) fprintf( stderr, "%s\n", msg );
	exit( YY_EXIT_FAILURE );
	}



/* Redefine yyless() so it works in section 3 code. */

#undef yyless
#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
		yytext[yyleng] = yy_hold_char; \
		yy_c_buf_p = yytext + n; \
		yy_hold_char = *yy_c_buf_p; \
		*yy_c_buf_p = '\0'; \
		yyleng = n; \
		} \
	while ( 0 )


/* Internal utility routines. */

#ifndef yytext_ptr
#ifdef YY_USE_PROTOS
static void yy_flex_strncpy( char *s1, yyconst char *s2, int n )
#else
static void yy_flex_strncpy( s1, s2, n )
char *s1;
yyconst char *s2;
int n;
#endif
	{
	register int i;
	for ( i = 0; i < n; ++i )
		s1[i] = s2[i];
	}
#endif

#ifdef YY_NEED_STRLEN
#ifdef YY_USE_PROTOS
static int yy_flex_strlen( yyconst char *s )
#else
static int yy_flex_strlen( s )
yyconst char *s;
#endif
	{
	register int n;
	for ( n = 0; s[n]; ++n )
		;

	return n;
	}
#endif


#ifdef YY_USE_PROTOS
static void *yy_flex_alloc( yy_size_t size )
#else
static void *yy_flex_alloc( size )
yy_size_t size;
#endif
	{
	return (void *) malloc( size );
	}

#ifdef YY_USE_PROTOS
static void *yy_flex_realloc( void *ptr, yy_size_t size )
#else
static void *yy_flex_realloc( ptr, size )
void *ptr;
yy_size_t size;
#endif
	{
	/* The cast to (char *) in the following accommodates both
	 * implementations that use char* generic pointers, and those
	 * that use void* generic pointers.  It works with the latter
	 * because both ANSI C and C++ allow castless assignment from
	 * any pointer type to void*, and deal with argument conversions
	 * as though doing an assignment.
	 */
	return (void *) realloc( (char *) ptr, size );
	}

#ifdef YY_USE_PROTOS
static void yy_flex_free( void *ptr )
#else
static void yy_flex_free( ptr )
void *ptr;
#endif
	{
	free( ptr );
	}

#if YY_MAIN
int main()
	{
	yylex();
	return 0;
	}
#endif
