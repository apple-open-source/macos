#define JQ_CONFIG "--with-oniguruma=builtin"
