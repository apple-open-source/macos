DEFAULT = 5.34
KNOWNVERSIONS = 5.34
EXTRAVERSIONERFLAGS = -DFORCE_TWO_NUMBER_VERSIONS

MY_ARCHS := $(or $(RC_ARCHS),$(MY_HOST))
ARCHFLAGS := $(foreach A,$(MY_ARCHS),-arch $(A))
EXTRAMERGE = mergeplist mergeman
MERGEDEFAULT = usr/local/OpenSourceLicenses
