// moved to CNBPServiceLookupThread.cpp