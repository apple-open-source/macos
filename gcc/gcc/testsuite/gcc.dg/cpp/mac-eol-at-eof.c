/* APPLE LOCAL file mainline 2005-03-04 */
/* Test no newline at eof warning when Mac line ending is used*/
/* { dg-do compile } */
int main() { return 0; } 
