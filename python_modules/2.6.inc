MODULES = \
    setuptools-0.6c12dev-r88846 \
    altgraph-0.10.1 \
    modulegraph-0.10.1 \
    macholib-1.5 \
    bdist_mpkg-0.4.4 \
    py2app-0.7.1 \
    numpy-1.6.2 \
    xattr-0.6.4 \
    bonjour-py-0.3 \
    scipy-0.11.0 \
    pytz-2012d \
    python-dateutil-1.5 \
    matplotlib-1.1.1 \
    pyOpenSSL-0.13.1
