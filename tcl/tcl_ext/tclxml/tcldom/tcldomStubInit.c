/* 
 * tcldomStubInit.c --
 */

#include "tcldom.h"

/*
 * Remove macros that will interfere with the definitions below.
 */


/*
 * WARNING: The contents of this file is automatically generated by the
 * genStubs.tcl script. Any modifications to the function declarations
 * below should be made in the tcldom.decls script.
 */

/* !BEGIN!: Do not edit below this line. */

TcldomStubs tcldomStubs = {
    TCL_STUB_MAGIC,
    NULL,
    NULL, /* 0 */
    NULL, /* 1 */
    TclDOM_Register, /* 2 */
};

/* !END!: Do not edit above this line. */
