//  pickdir.h  -  directory picker sample code
//
//  Copyright (C) 1996-2000 Jean-Claude Wippler.  All rights reserved.
/////////////////////////////////////////////////////////////////////////////

extern CString PickDirectory(CWnd* pParentWnd =0);

/////////////////////////////////////////////////////////////////////////////
