/*
  ===========================================================================
	MacHeadersMach-O.c	© 2000-2002 Metrowerks Corporation.  All rights reserved.
  ===========================================================================

	Includes used to generate the 'MacHeadersMach-O' precompiled header for
	Metrowerks C/C++.
*/

#define _MSL_MACHEADERS_INCLUDES_CMATH 0

#if defined(__cplusplus) && _MSL_USING_MW_C_HEADERS && _MSL_MACHEADERS_INCLUDES_CMATH
	#include <cmath>
#endif


// Apple Framework Headers

#ifndef __NOEXTENSIONS__
	#define __NOEXTENSIONS__
#endif
#ifndef __CF_USE_FRAMEWORK_INCLUDES__
	#define __CF_USE_FRAMEWORK_INCLUDES__
#endif

#include <CoreServices/CoreServices.h>