// CoreHeadersMach-O.h

#if __mwlinker__
		#include <CoreHeadersMacOSX>
#else
		#include <CoreHeadersMach-O>
#endif