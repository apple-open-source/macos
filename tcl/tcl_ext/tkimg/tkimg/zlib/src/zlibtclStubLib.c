../zlibtclStubLib.c