../zlibtclStubInit.c