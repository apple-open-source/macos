[comment {-*- tcl -*- doctools = format-footer.inc}]
[list_end]

[see_also img-intro img-bmp img-gif img-ico img-jpeg img-pcx img-pixmap img-png img-ppm img-ps img-sgi img-sun img-tga img-tiff img-window img-xbm img-xpm]
[keywords {image handling} tk [vset FORMATNAME]]
[manpage_end]
