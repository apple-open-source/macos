[comment {-*- tcl -*- doctools = compress/middle.inc}]
[para]
[list_begin definitions]

[call [cmd [vset compress]] [opt [arg options...]] [opt [arg data]]]

[list_begin definitions]
[include compress/options.inc]
[include common/options.inc]
[list_end]
[list_end]
