[comment {-*- tcl -*- doctools = compress/footer.inc}]
[include common/sections.inc]

[see_also trf-intro bz2 zip]
[keywords [vset compress] compression decompression {data compression}]
[manpage_end]
