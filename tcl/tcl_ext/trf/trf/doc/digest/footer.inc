[comment {-*- tcl -*- doctools = digest_footer.inc}]
[include common/sections.inc]

[see_also trf-intro crc-zlib crc adler md2 md5 md5_otp sha sha1 sha1_otp haval ripemd-160 ripemd-128]
[keywords [vset digest] {message digest} mac hashing hash authentication]
[manpage_end]
