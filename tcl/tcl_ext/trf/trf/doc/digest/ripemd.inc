[vset digest ripemd-[vset digest]]
[include digest/header.inc]

[section NOTES]

See [uri http://www.esat.kuleuven.ac.be/%7Ebosselae/ripemd160.html]
for additional information.

[keywords ripemd]
[include digest/footer.inc]
