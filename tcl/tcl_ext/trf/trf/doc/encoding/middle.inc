[comment {-*- tcl -*- doctools = encoding_middle.inc}]
[para]
[list_begin definitions]

[call [cmd [vset encoding]] [opt [arg options...]] [opt [arg data]]]

[list_begin definitions]
[include encoding/options.inc]
[include common/options.inc]
[list_end]
[list_end]
