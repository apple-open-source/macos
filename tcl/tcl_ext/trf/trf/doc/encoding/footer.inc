[comment {-*- tcl -*- doctools = encoding_footer.inc}]
[include common/sections.inc]

[see_also  trf-intro ascii85 base64 bin hex oct otp_words quoted-printable uuencode]
[keywords [vset encoding] encoding]
[manpage_end]
