[comment {-*- tcl -*- doctools = encoding_header.inc}]
[include common/trf_version.inc]
[manpage_begin [vset encoding] n [vset trf_version]]
[titledesc "Encoding \"[vset encoding]\""]
[include common/trf_header.inc]
[description]

The command [cmd [vset encoding]] is one of several data encodings
provided by the package [package trf]. See [syscmd trf-intro] for an
overview of the whole package.
