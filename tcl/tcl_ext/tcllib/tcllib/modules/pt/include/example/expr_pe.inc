[example {
    Expression <- '(' Expression ')'
                / Factor (MulOp Factor)*
}]
