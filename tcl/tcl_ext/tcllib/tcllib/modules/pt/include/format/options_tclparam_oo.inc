
[list_begin options]
[include options_std.inc]

[opt_def -class string]

The value of this option is the name of the class to generate, without
leading colons. Note, it serves double-duty as the name of the package
to generate too.

The default value is [const CLASS].

[list_end]
