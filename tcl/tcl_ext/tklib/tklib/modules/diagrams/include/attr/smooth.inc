[def [cmd smooth]]

Specifies the use of bezier splines for the [cmd line] element.

If not specified lines are drawn exactly through the specified
waypoints, without any smooth curves.
