[def "[cmd color] [arg spec]"]

[image figure-21-style-colors]
Specifies the color used to draw the lines of the element.

If not specified the system falls back to the value taken from the
language variable [var linecolor], which itself defaults to [const black].
