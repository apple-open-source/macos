[def "[cmd aspect] [arg number]"]

Specifies the aspect ratio, i.e ratio of width to height, of the
[cmd diamond] element.

The manner in which a default is calculated when not specified also
depends on the specifications of the attributes [cmd width] and
[cmd height], if any.

[include diam_awh.inc]
