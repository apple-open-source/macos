[def "[cmd textfont] [arg spec]"]

Specifies the font used to draw the text of an element with.

Ignored if there is no text.

If not specified the system falls back to the value taken from the
language variable [var textfont], which itself defaults to
[const {Helvetica 12pt}].
