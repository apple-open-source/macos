[def "[cmd radius] [arg length]"]

Specifies the radius of the [cmd arc] element, or rather, the radius
of the circle the shown arc is a part of.

If not specified the system falls back to the value taken from the
language variable [var arcradius], which itself defaults to the pixel
equivalent of [const {1 cm}].
