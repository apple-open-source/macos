[def "[cmd radius] [arg length]"]
[def "[cmd rad] [arg length]"]

Specifies the radius of the [cmd circle] element.

If not specified the system falls back to the value taken from the
language variable [var circleradius], which itself defaults to the
pixel equivalent of [const {1 cm}].
