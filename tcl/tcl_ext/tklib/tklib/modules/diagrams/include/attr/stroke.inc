[def "[cmd stroke] [arg width]"]

[image figure-20-style-stroke]
Specifies the width of the lines drawn for the the element, in pixels.

If not specified the system falls back to the value taken from the
language variable [var linewidth], which itself defaults to [const 1].
