[def "[cmd height] [arg length]"]

Specifies the height of the [cmd text] element.

Defaults to the natural height of its text.
