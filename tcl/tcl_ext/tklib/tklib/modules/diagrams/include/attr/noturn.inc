[def [cmd noturn]]

Specifies that the direction of [cmd line] element at its end is not
propagated to the layout management.

If not specified the direction of the line becomes the new direction
the layout.
