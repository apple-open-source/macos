[def "[cmd to] [arg location]"]

Specifies the location where the [cmd arc] element ends.

Defaults to a location such that a 90-degree arc is drawn in the
chosen direction, starting at [cmd from].
