[def "[cmd width] [arg length]"]

Specifies the width of the [cmd text] element.

Defaults to the natural width of its text.
