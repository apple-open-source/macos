[def "[cmd width] [arg length]"]
[def "[cmd wid] [arg length]"]

Specifies the width of the element.

If not specified the system falls back to the value taken from the
language variable [var boxwidth], which itself defaults to the pixel
equivalent of [const {2 cm}].
