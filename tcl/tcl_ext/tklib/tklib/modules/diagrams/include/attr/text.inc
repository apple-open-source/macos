[def "[cmd text] [arg string]"]

Specifies the text to associate with the element.

Defaults to nothing.

When specified multiple times the actually shown text is the
concatenation of the individual strings, vertically stacked, with the
first string specified being the topmost element.
