[def "[cmd slant] [arg angle]"]

Specifies the angle by which the [cmd box] element is slanted, in
degrees.

If not specified the system falls back to the value taken from the
language variable [var slant], which itself defaults to [const 90],
i.e. vertical, no slant.

0 degrees is slanting straight east, pointing to the right.
90 degrees is slanting to the north, pointing straight up.
