[def "[cmd fillcolor] [arg spec]"]

[image figure-21-style-colors]
Specifies the color used to draw the inside of the element.

If not specified the system falls back to the value taken from the
language variable [var fillcolor], which itself defaults to the empty
string, signaling "no filling".
