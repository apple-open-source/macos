[def "[cmd with] [arg corner]"]

Specifies the corner of the element to place at the location given by
the attribute [cmd at].

Defaults to the current corner as maintained by the layouting system,
except if the value for [cmd at] was specified by the user. In that
case it defaults to [const center].
