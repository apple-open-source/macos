[def "[cmd from] [arg location]"]

Specifies the location where the [cmd line] element begins.

Defaults to the current location as maintained by the layouting
system.
