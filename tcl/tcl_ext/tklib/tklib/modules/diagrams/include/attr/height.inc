[def "[cmd height] [arg length]"]
[def "[cmd ht] [arg length]"]

Specifies the height of the element.

If not specified the system falls back to the value taken from the
language variable [var boxheight], which itself defaults to the
pixel equivalent of [const {2 cm}].
