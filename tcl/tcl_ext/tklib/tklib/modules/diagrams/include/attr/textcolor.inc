[def "[cmd textcolor] [arg spec]"]

Specifies the color used to draw the text of an element with.

Ignored if there is no text.

If not specified the system falls back to the value taken from the
language variable [var textcolor], which itself defaults to
[const black].
