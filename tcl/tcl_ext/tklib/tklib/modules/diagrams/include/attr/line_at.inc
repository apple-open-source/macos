[def "[cmd at] [arg location]"]

[cmd Line] elements are normally positioned absolutely, using the
locations specified through the attributes [cmd from], [cmd then], and
[cmd to].

If [cmd at] is specified however then these positions are translated a
last time, moving the line's corner named by the attribute [cmd with]
to the location given by this attribute.
