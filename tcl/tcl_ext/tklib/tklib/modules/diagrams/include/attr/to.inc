[def "[cmd to] [arg location]"]

Specifies the location where the [cmd line] element ends.

This attribute has no default. The default is handled by the attribute
[cmd then], which makes it appear as if [cmd to] has a default when
not specified.
