[def "[cmd at] [arg location]"]

Specifies the location of the element's corner named by the attribute
[cmd with].

Defaults to the current location as maintained by the layouting
system.