[def "[cmd aspect] [arg number]"]

Specifies the aspect ratio, i.e ratio of width to height, of the
ellipses which are used to draw the top and bottom of the [cmd drum]
element.

If not specified the system falls back to the value taken from the
language variable [var drumaspect], which itself defaults to
[const 0.35].
