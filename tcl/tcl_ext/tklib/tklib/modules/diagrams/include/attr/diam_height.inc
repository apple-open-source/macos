[def "[cmd height] [arg length]"]

Specifies the height of the [cmd diamond] element.

The manner in which a default is calculated when not specified also
depends on the specifications of the attributes [cmd aspect] and
[cmd width], if any.

[include diam_awh.inc]
