A closed element with the corresponding corners, i.e. the eight
directions of the compass rose, and "center".
