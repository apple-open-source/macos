[call [cmd drum] [arg attr]...]

[image figure-02-drum]
[include cat_closed.inc]

It handles the attributes

[list_begin definitions]
[include ../attr/anchor.inc]
[include ../attr/drum_aspect.inc]
[include ../attr/at.inc]
[include ../attr/color.inc]
[include ../attr/fillcolor.inc]
[include ../attr/height.inc]
[include ../attr/justify.inc]
[include ../attr/stroke.inc]
[include ../attr/style.inc]
[include ../attr/text.inc]
[include ../attr/textcolor.inc]
[include ../attr/textfont.inc]
[include ../attr/width.inc]
[include ../attr/with.inc]
[list_end]
