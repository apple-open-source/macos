An open element with the corresponding corners, i.e. "start", "end",
and "center".
