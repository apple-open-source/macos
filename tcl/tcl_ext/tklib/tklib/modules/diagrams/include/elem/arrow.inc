[call [cmd arrow] [arg attr]...]
[call [cmd -->] [arg attr]...]
[call [cmd <-->] [arg attr]...]
[call [cmd <-->] [arg attr]...]

[image figure-02-arrow]

An alias for the [cmd line] element (see below), with the attribute
[cmd arrowhead] preset to [const ->], [const <->], or [const <-].  The
[cmd arrow] is equivalent to [cmd -->].
