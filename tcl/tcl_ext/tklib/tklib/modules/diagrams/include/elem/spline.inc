[call [cmd spline] [arg attr]...]

[image figure-02-spline]

An alias for the [cmd line] element (see above), with the attribute
[cmd smooth] preset.
