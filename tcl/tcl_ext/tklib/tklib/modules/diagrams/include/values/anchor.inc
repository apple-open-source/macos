
The legal values are all those accepted by
[uri \
     http://www.tcl.tk/man/tcl8.5/TkLib/GetAnchor.htm \
     Tk_GetAnchor].
