
The legal values are [const left], [const right], and [const center].
