[def [var linestyle]]

The default value for the attribute [cmd style] of all elements
having to draw some line.

Initialized to [const solid].

[include ../values/style.inc]
