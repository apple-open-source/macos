[def [var linewidth]]

The default value for the attribute [cmd stroke] of all elements
having to draw some line.

Initialized to [const 1] (pixels).
