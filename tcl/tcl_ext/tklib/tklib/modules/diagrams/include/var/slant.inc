[def [var slant]]

The default value for the attribute [cmd slant] of [cmd box] elements.

Initialized to 90 degrees, i.e. slant straight up.
