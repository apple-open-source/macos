[def [var anchor]]

The default value for the attribute [cmd anchor].

Initialized to [const center].

[include ../values/anchor.inc]
