[def [var fillcolor]]

The default value for the attribute [cmd fillcolor] of all elements
which can be filled.

Initialized to the empty string, signaling that the element is not
filled.
