[def [var diamondaspect]]

The default value for the attribute [cmd aspect] of [cmd diamond]
elements.

Initialized to [const 2].
