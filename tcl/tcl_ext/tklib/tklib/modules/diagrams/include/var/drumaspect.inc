[def [var drumaspect]]

The default value for the attribute [cmd aspect] of [cmd drum]
elements.

Initialized to [const 0.35].
