[def [var arrowhead]]

The default value for the attribute [cmd arrowhead].

Initialized to [const none].

[include ../values/arrowhead.inc]
