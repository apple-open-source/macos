[def [var movelength]]

The default value for the directional specification of intermediate
locations by the attribute [cmd then] of [cmd line] and [cmd move]
elements.

Initialized to the pixel equivalent of [const {2 cm}].
