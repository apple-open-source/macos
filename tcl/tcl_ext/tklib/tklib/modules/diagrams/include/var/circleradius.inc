[def [var circleradius]]

The default value for the attribute [cmd radius] of [cmd circle]
elements, and also the default for the attribute [cmd chop], when
specified without an explicit length.

Initialized to the pixel equivalent of [const {1 cm}].
