[def [var boxwidth]]

The default value for the attribute [cmd width] of [cmd box],
[cmd diamond] and [cmd ellipse] elements.

Initialized to the pixel equivalent of [const {2 cm}].
