[def [var linecolor]]

The default value for the attribute [cmd color] of all elements having
to draw lines (all but [cmd text]).

Initialized to [const black].
