[def [var boxheight]]

The default value for the attribute [cmd height] of [cmd box],
[cmd diamond] and [cmd ellipse] elements.

Initialized to the pixel equivalent of [const {2 cm}].
