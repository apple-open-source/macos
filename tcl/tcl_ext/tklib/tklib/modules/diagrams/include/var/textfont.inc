[def [var textfont]]

The default value for the attribute [cmd textfont] of all elements
having to draw some text.

Initialized to [const {Helvetica 12pt}].
