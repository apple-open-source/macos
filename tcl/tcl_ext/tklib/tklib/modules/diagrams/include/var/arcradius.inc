[def [var arcradius]]

The default value for the attribute [cmd radius] of [cmd arc]
elements.

Initialized to the pixel equivalent of [const {1 cm}].
