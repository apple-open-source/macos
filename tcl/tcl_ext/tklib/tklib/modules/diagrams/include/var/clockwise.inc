[def [var clockwise]]

The default value for the attributes [cmd clockwise] and
[cmd counterclockwise] of [cmd arc] elements.

Initialized to [const False], for counter-clockwise direction.
