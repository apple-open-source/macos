[def [var justify]]

The default value for the attribute [cmd justify].

Initialized to [const left].

[include ../values/justify.inc]
