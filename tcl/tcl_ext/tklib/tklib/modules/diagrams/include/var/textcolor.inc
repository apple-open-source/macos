[def [var textcolor]]

The default value for the attribute [cmd textcolor] of all elements
having to draw some text.

Initialized to [const black].
