../fips-1.0/hmac/fips_hmactest.c