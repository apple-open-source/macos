../fips-1.0/rand/fips_randtest.c