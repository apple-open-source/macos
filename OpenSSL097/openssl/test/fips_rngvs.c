../fips-1.0/rand/fips_rngvs.c