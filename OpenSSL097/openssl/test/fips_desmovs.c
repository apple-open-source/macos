../fips-1.0/des/fips_desmovs.c