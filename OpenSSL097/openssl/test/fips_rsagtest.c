../fips-1.0/rsa/fips_rsagtest.c