/* Autogenerated by script/mkversion.sh */
#define SAMBA_VERSION_MAJOR 3
#define SAMBA_VERSION_MINOR 0
#define SAMBA_VERSION_RELEASE 28
#define SAMBA_VERSION_REVISION "a"
#define SAMBA_VERSION_OFFICIAL_STRING "3.0.28a"
#define SAMBA_VERSION_VENDOR_SUFFIX "apple"
#define SAMBA_VERSION_STRING samba_version_string()
