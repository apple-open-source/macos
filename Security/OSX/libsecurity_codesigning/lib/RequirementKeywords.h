        "guest",
        "host",
        "designated",
        "library",
        "plugin",
        "or",
        "and",
        "always",
        "true",
        "never",
        "false",
        "identifier",
        "cdhash",
        "platform",
        "notarized",
        "anchor",
        "apple",
        "generic",
        "certificate",
        "cert",
        "trusted",
        "info",
        "entitlement",
        "exists",
        "absent",
        "leaf",
        "root",
        "timestamp",
