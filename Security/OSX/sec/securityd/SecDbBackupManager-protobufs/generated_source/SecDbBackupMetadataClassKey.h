// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from SecDbBackupRecoverySet.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

#ifdef __cplusplus
#define SECDBBACKUPMETADATACLASSKEY_FUNCTION extern "C"
#else
#define SECDBBACKUPMETADATACLASSKEY_FUNCTION extern
#endif

/** Insert into metadatakeys table, v12_metadatakeydata column */
@interface SecDbBackupMetadataClassKey : PBCodable <NSCopying>
{
    NSData *_backupWrappedMetadataKey;
    int32_t _keyClass;
    struct {
        int keyClass:1;
    } _has;
}


@property (nonatomic) BOOL hasKeyClass;
@property (nonatomic) int32_t keyClass;

@property (nonatomic, readonly) BOOL hasBackupWrappedMetadataKey;
/** wrapped by appropriate backup keyclass for recovery */
@property (nonatomic, retain) NSData *backupWrappedMetadataKey;

// Performs a shallow copy into other
- (void)copyTo:(SecDbBackupMetadataClassKey *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(SecDbBackupMetadataClassKey *)other;

SECDBBACKUPMETADATACLASSKEY_FUNCTION BOOL SecDbBackupMetadataClassKeyReadFrom(__unsafe_unretained SecDbBackupMetadataClassKey *self, __unsafe_unretained PBDataReader *reader);

@end

