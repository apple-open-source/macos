// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from SecDbBackupRecoverySet.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

@class SecDbBackupBagIdentity;

#ifdef __cplusplus
#define SECDBBACKUPBAG_FUNCTION extern "C"
#else
#define SECDBBACKUPBAG_FUNCTION extern
#endif

/** Insert into backupbags table, v12_backupBag column */
@interface SecDbBackupBag : PBCodable <NSCopying>
{
    SecDbBackupBagIdentity *_bagIdentity;
    NSData *_keybag;
}


@property (nonatomic, readonly) BOOL hasBagIdentity;
@property (nonatomic, retain) SecDbBackupBagIdentity *bagIdentity;

@property (nonatomic, readonly) BOOL hasKeybag;
@property (nonatomic, retain) NSData *keybag;

// Performs a shallow copy into other
- (void)copyTo:(SecDbBackupBag *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(SecDbBackupBag *)other;

SECDBBACKUPBAG_FUNCTION BOOL SecDbBackupBagReadFrom(__unsafe_unretained SecDbBackupBag *self, __unsafe_unretained PBDataReader *reader);

@end

