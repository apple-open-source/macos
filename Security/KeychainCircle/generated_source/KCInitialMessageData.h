// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from KCInitialMessageData.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

#ifdef __cplusplus
#define KCINITIALMESSAGEDATA_FUNCTION extern "C"
#else
#define KCINITIALMESSAGEDATA_FUNCTION extern
#endif

@interface KCInitialMessageData : PBCodable <NSCopying>
{
    NSData *_prepareMessage;
}


@property (nonatomic, readonly) BOOL hasPrepareMessage;
@property (nonatomic, retain) NSData *prepareMessage;

// Performs a shallow copy into other
- (void)copyTo:(KCInitialMessageData *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(KCInitialMessageData *)other;

KCINITIALMESSAGEDATA_FUNCTION BOOL KCInitialMessageDataReadFrom(__unsafe_unretained KCInitialMessageData *self, __unsafe_unretained PBDataReader *reader);

@end

