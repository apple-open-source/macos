// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from MockAKSOptionalParameters.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

#ifdef __cplusplus
#define MOCKAKSOPTIONALPARAMETERS_FUNCTION extern "C"
#else
#define MOCKAKSOPTIONALPARAMETERS_FUNCTION extern
#endif

@interface MockAKSOptionalParameters : PBCodable <NSCopying>
{
    NSData *_accessGroups;
    NSData *_acmHandle;
    NSData *_externalData;
}


@property (nonatomic, readonly) BOOL hasAccessGroups;
@property (nonatomic, retain) NSData *accessGroups;

@property (nonatomic, readonly) BOOL hasExternalData;
@property (nonatomic, retain) NSData *externalData;

@property (nonatomic, readonly) BOOL hasAcmHandle;
@property (nonatomic, retain) NSData *acmHandle;

// Performs a shallow copy into other
- (void)copyTo:(MockAKSOptionalParameters *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(MockAKSOptionalParameters *)other;

MOCKAKSOPTIONALPARAMETERS_FUNCTION BOOL MockAKSOptionalParametersReadFrom(__unsafe_unretained MockAKSOptionalParameters *self, __unsafe_unretained PBDataReader *reader);

@end

