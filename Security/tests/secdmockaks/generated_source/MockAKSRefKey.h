// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from MockAKSRefKey.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

#ifdef __cplusplus
#define MOCKAKSREFKEY_FUNCTION extern "C"
#else
#define MOCKAKSREFKEY_FUNCTION extern
#endif

@interface MockAKSRefKey : PBCodable <NSCopying>
{
    NSData *_key;
    NSData *_optionalParams;
}


@property (nonatomic, readonly) BOOL hasKey;
@property (nonatomic, retain) NSData *key;

@property (nonatomic, readonly) BOOL hasOptionalParams;
@property (nonatomic, retain) NSData *optionalParams;

// Performs a shallow copy into other
- (void)copyTo:(MockAKSRefKey *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(MockAKSRefKey *)other;

MOCKAKSREFKEY_FUNCTION BOOL MockAKSRefKeyReadFrom(__unsafe_unretained MockAKSRefKey *self, __unsafe_unretained PBDataReader *reader);

@end

