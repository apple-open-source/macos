const char *secdmock_db_version10_5[] = {
"PRAGMA foreign_keys=OFF;",
"BEGIN TRANSACTION;",
"CREATE TABLE genp(rowid INTEGER PRIMARY KEY AUTOINCREMENT,cdat REAL,mdat REAL,desc BLOB,icmt BLOB,crtr INTEGER,type INTEGER,scrp INTEGER,labl BLOB,alis BLOB,invi INTEGER,nega INTEGER,cusi INTEGER,prot BLOB,acct BLOB NOT NULL DEFAULT '',svce BLOB NOT NULL DEFAULT '',gena BLOB,data BLOB,agrp TEXT NOT NULL,pdmn TEXT,sync INTEGER NOT NULL DEFAULT 0,tomb INTEGER NOT NULL DEFAULT 0,sha1 BLOB,vwht TEXT,tkid TEXT,musr BLOB NOT NULL,UUID TEXT,sysb INTEGER DEFAULT 0,pcss INTEGER,pcsk BLOB,pcsi BLOB,persistref BLOB NOT NULL,UNIQUE(acct,svce,agrp,sync,vwht,tkid,musr));",
"INSERT INTO genp VALUES(1,540009245.94961404799,540009245.94961404799,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'8382da59a29b55be466989dfa2aebd753d64c29e',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000003aa6d8ef67454036a5400ffa795e8da6a8c0415f8eac42c453a55193b984e5b0ffffffffffffffff6d1db45fd916e0eea6e4d6461652236de8eb2b06f4d46f97f44d142cd7889e5b300f067bd4b05d2885b079437f47fac2a95a5fbd65ef3fc907f93b10f7df6aadfa5fb481d2af38fd042703d255fbb6883646147c34f06def5424c3c261ada76dee25aa1347e50869ea0285b6a6f6aaf9bacd6f88044dea72b1b7eda52f15c9c504cd8d589f7a1871c2b69b4a18f7f274a4a67ce7a96bbc7c20497cbdae1ac51b716d71edd274e275df5fc5687d0ee77748c6345538508a8b575287b85cffc8f6d108046c65c45ef33fcf728bdc451f0013b736daa0329ebb99dd60f49c','sync','ak',0,0,X'9606421eed00b577e315aa2f1cb355b42dfcf455','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(2,540009245.95954704282,540009245.95954704282,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'5aae321010aed69c632f05d26ff25a3264daf9df',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000fed80c22727d56ebcb7642031807e29b886a45f7367bc57c39dd4ff0c87a2147ffffffffffffffff432a9bab1064e002f1829613adc70b526bd34b18bfd2e80bbd5dfd6242aa83294f94554607ae0095f564e92748bd1fe95cb0a5669d475a755c54ae2aa6776f79911acb5271539e7f3616c4424a1fc9f8629558138d51f7da0cec0e6fb1890fcd7a331059b727368d36cb635c5dcbb9aa09a132528d871b3c3fa4e6f57047c314995523818e722049732acd5aa58db7a2f638eb11bb38219f44837e0a69e63efa3ea8a2cea9d37bd92830212803770d4f08f93576be06390f2f7f31b9a33a95959695d5b879485a39aff82795705b01e266c14e7c1a5f3aaf14ee328ba8','sync','ak',0,0,X'465af1664ec91a1b3e40961935d62f1d0f51f431','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(3,540009245.96500504016,540009245.96500504016,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'4872b599a64f42a50c2bb8190f4a3053f8f68b83',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000f03a72b4037f8e2566b5abd12b3fd63fdb8b7b686f58d74264db2c57741758a5ffffffffffffffffc56e4643d616e47c39de15202aaa6a7728282a53da54199b3fc9a118131a3e244d75bf98681bee9201fd2d564a9e14f9232ac9ff5bcaa61b9bd9338a171a3fcf7bf726dd618fb22e45537850b65e4bb817e7c4986484c9ae2c5fe19864f5bdd485720ae0a452a942a9b0f1c69a2be72c51bb25861c9141532e57e76be84086345ef5ac55b0edcf24f0fafcffe303b7309cb42d8f782d79829cc814a9855b8d2d8a60c2c4cbae8ee74b6e9638b09c64cdb5957ffa5da290cddf37babf88494aeedd52d2926cd479d4727f384fd57b1a5dc4ac3eac751abbbdb7dbab5e49','sync','ak',0,0,X'db56704c6d1961215f3cb01153997cffd5923bb2','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(4,540009245.96904194357,540009245.96904194357,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'7c93f04b766453571932dd9f62fc2ec2e6fff1bd',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000333ae41a218d6acd22d392f6051eea737b9e4a72e1a82dad9bb987b11bfa46feffffffffffffffffed5f369356888535aa502a458fb9fcd53dd06b43dc7e3012d6a69b15a184f828d7c163404ae16f07ed3344b50e909d146e4a16bb503f03a76c707e0943386616d1224dad995205297d9562e1e3ae676ec5d33a38d94ee276910b54d0dbe032673b3630dc868352c83d24c265b46e3800accec6e2071d28d1551e9b933a09f482cd6be09f2499fbcff37e224c237734d9148dda5decee75a4a997647964299cc090fda9a1dd5ab9df91227beb9d67dd539905a1b1d5bba1e2970e79c5dbab3449d62efa35d247cc4801bdb5b9d4bfbee3e9d82c87d9f7ed1abb1a54e9df','sync','ak',0,0,X'8194c6d9143186d4a3dd9c91bd4ca336807ca149','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(5,540009245.97303295135,540009245.97303295135,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'c9304138ee216d27ad7e02188309e730eae3c88c',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000034a5f9344d362336bce4e70edac9832c3914b78d5332a5e4bfeeb6382fdc1adfffffffffffffffffe5356b12f073d4982a140267127bb47de510b91b8b9ac1b22fd563a4dfde6ab7ca2c3cd9c30c5fdb9f879f8f768ab8ea9fc8f62ac1a8f2ad0418674d0afd5e5aa359a8f8e8a862ef6465c2693330d09cbd165fc56dc7003f0174fd8554674da790bdf311b16cd81c68904a36801ff3eca33aa8522966ed7a30a31e576b850af4091f937e8cbdbad37a9dafcf8271e353bb8105351f2e0c7725e467b57e3fecc18a210958fe65976de9c9b9b8317e8d77397ba605f79172042aab81e25e76ef0672f07c326d80d2ed8b769d381102869eed906d7218a784f3d2cff93394','sync','ak',0,0,X'29b024b51b20557236b0ffba807e7439b260906d','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(6,540009245.97699296474,540009245.97699296474,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'eeb4d0c9c2cd4376e4790e8afa7e80514b2ddb03',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000010cbc193247a8174b7368cb5215386128e054ca5f582eaca931796a5b1abbd7ffffffffffffffff2a73831c0172d2e39809b75adbd999224ff6f123fc00de6316a65e9cb31ce29dd63772036bed62e97528ce65592d991590e1ef738cc428b96b54eab0798b477ad981a301ede7fa8cb4a8d83a165b8fde9e57ff60b245b553217678f2b8193b0130093acbddca9a95ee6909b6275210012e57b2bfbbc85ce21f0ceed5253a48faf3c13bc7fd5bf521c1a54954b72f1fc1a953bc1daca5147c537724211e4fb6cfbc9dd11d8cc57436aa47e0cf864fe64f39ceec1944e4b533f8d4f8fea2fa6dbca6b46ea0c95a78238a4d14cf6f553dea440b28c0ae2bfd3a4d90f63def','sync','ak',0,0,X'e0009e99650e1c3e16a99b661ba78024ebd03e98','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(7,540009245.98067498207,540009245.98067498207,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'c5bd6ce0d501326fa6a0aec020542fc94cff130b',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000100b9dedff390f782856d382411dd00b328185a25a878a57d34904ee13603f85ffffffffffffffff2820cdc6b257aa66bb1098308a8282a0bdb2c1a62621d0e050042535de7070a6140073e7aca0c6dff260cbf90931ed530a49f4030c176b16c72e8f1428021aece0b4c41378e66d7b997f2ec4a7d25d8e9f34b5e04ed1224df1fde1d493dfcb5ebb621ed361db51ee406c2bf45cf15a3f2154a09ec089a1481fda3c0c236407665a7de081eecbd055cd963c364de000b274bf753158eadc8b9637140d22502f1c1ae15f3be15af72f9078d07724b799e0bca1791f6ed12be050d13cd173adff0abc87c36cd282812bae25e732bd89053a9eeb4393d2991810cd2eb72275','sync','ak',0,0,X'f2434775aa80960763f972b24e880056436a8365','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(8,540009245.98510801791,540009245.98510801791,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'2a6383e0e35bc696730fd84da42d4c7123e8fbf1',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000078ca5addb75af33904cf214f7b59f583d5ec3b21358d9af12109793e1adf2c57ffffffffffffffff28ba59afec9308cd00aada0f04e2a9c3ce18d3a50eece6cb12afd497d05fa9d86c1c5927f7c794ba199eb768ed48c888b8bfa29b997f0b2f2ac2a5d2f0ee2e0c87f2f8ac872a692a1f437de244e2772f8b3ce83e296a728a1fa4b3a05c2a4e8b930ed2aa9e4fc2d2576010ac42eb7110c79a57f0c228774902648c5e80b7bf9a14b2ca75fc76c39d5a10eeb3e7c4243a752ba502408ca2a4e43480778a4510fb90875ed39740dcecf45547f647a6c46d2fa630042278bc2acf01f51333c1edb2c7538b6061cbc6d5df0a2a819df97ee0bec3d6e19ac20a1f55ae5a81fa','sync','ak',0,0,X'014037894870b7772d48317e1970d33b59d2e953','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(9,540009245.98908996584,540009245.98908996584,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'a58a2dceecafe55cd69bc0824b050eecf0044f3a',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000d74cd676be86b1d01a4824f64952f4f9543128e31fc79d9023efa713b0545a56ffffffffffffffff7c4f0cd5daaa8404fbdcce3c3cf316abb81a2758f45337e905cfca0367b77475e4f7709ebfc8af53dc2820527f3ee5a9c544233ead690e9b2f54467fb39fc9929a9ad46d55083e3b430891f2d4eb71d28c7eb949cae6c592be94fc31720b6f6da5af9c18a5d41ca018b10ff7ee4889e70272c15c2453e31caf766c5fde3e6a9c1d37eae6b92dea67e40cf31178c98cfda69b0336f8c66c4181409b6ac0f92a66f45835aa66ff7d93cd9a6831cbd7aa38cbf1cb946a2ae59a8791c17a99bc647f1d0535eff7fc5e2b250f5900869508b75ab315f121ee8eaf15ba98','sync','ak',0,0,X'cf5df2df2ac4bbcf15a1d123b4ebda4b1ba044c7','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(10,540009245.99284398554,540009245.99284398554,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'e54afb2c10a7241d5305558d00fa9a63170adc8d',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000df7f87f28510d41c02269279cb124582e1a0c08497cab0ec6382616e8f8a7864ffffffffffffffff67b8dea891cc92bbafa73c119d022ac7e6122d50ea4431467fe7a862afa4bb485f5caf64580951f7b088d8b33c80feb3de5e4964f58b9e2d2d11c437d822c270def058a37b1630e72f51cabe11d9d5d5bb3297223a73363b33ac418407b12bd17f7316dee7b4c1156f3256f7cca083669823a9d8c3aaa6b63442b1da10514983ede00edf5e80868946fff7cf8396cc97c658ef4f621a1244c8ee457a7d2ef339e2d359ecd35f087faf98f2d45043d7eea899a217690ca32e55dad5b92d61634ad368b6064eae4a4a4e09a1ec784eb6643f11978301eea2801628a9b9c9','sync','ak',0,0,X'19347fe868dee17bf9d53435628b3e65e6465534','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(11,540009245.99883902074,540009245.99883902074,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'dd2cad2f1e45d7c4a7ad157b9f3b3ae503c69783',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000019f693e9260a0c2446d03f4074c775433f8cefbd9f4f505e78b5d8e9d4953215ffffffffffffffff19595f3de4d67cc15262fe104b9dccd8147c5c77452501e0d4eb06f263d973bb9a704d858afe788cdb59326cd80e9d1f0efaa580edac7ba55863c55a07da0cc78db79e3635252f6e4419926089a4236f273171179c7499aa9bb7f1e7d588deeb23ece5d8e0a7ac2f4ddf842d6ce5ea22499f2c867b5dc5f47013236eab19e36c93957a07c2a929ac11f82366656df094beab2fa07cd974f8e268e06fa4eb26a3bd918279d36e565151764e63d927e67ce631188c022d32a4dcbd599c65011548bacfef2fcd2186ee346b8d6a22a711cd5f4a1508d2bf2332f1a7a0c8ed3b','sync','ak',0,0,X'7fe2c9e56d13085e8e0cb985702cac582f3b85d3','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(12,540009246.00752496719,540009246.00752496719,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'e62d275c52a9542c792b5dee3fa10c886182d0c7',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000026f6dd4ccb424644dfbf0d2db960b04d4645b3f68ab3899e7b1d3adf8391afe9fffffffffffffffff6509376b61ee8920edc67fcce8fc9ed0c32878790078791ca1cdb7c290fa8c6a3eb8202bf456145dc18b515e750ab9566933558235611ab8ff45fab0766cfd0fe7c963797ccc7756b0ac2bcd82b3064de9b27802a715346c78fcc87b59f41521a96480c031674d6f8bdc52e05e65a2cbd63db9aacfbbfc667d9d0a443a9cde6321425ff358579d0699be7e153255647c8e7bafe563969752eb9c068c95d62cf6bdaeef20cc55f9723bc023eef47db1ff126ceb213761201ce4653a9206b84349d5edee0735761c5270e8676b0db9e1cce696c7552c5833718a18f69d4a9','sync','ak',0,0,X'5ba5995b1170c31766f42815c6db013b2a209027','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(13,540009246.01104497908,540009246.01104497908,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'ca8e8c88bcdd512029792ebd515c8f72a26bc372',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000a41baf094862b049b2fe6cae59e5705d744a6c4156ee32a26d1925a0fafa820affffffffffffffffdfe1c50a5f8f68ac7bad4caa88208ddd5a315609dfefcc4ce3f446117cd85e2c98ef020cb65919a42ea29e4f1ebce17af330cb35effb5a843d9e1e7712e7c12e4b8e9a964d64e2aee956b20e092e7545beaa90931169ac8155dea04f16a2178d6ea4b48d03e8a6f56b7fe5abb5e952c37f0940272b8b550380ae1d4b5c2e310528323568437e31afda02d21a49aa04bf3115075424da8f213f2df72dd090c2c911fd977ea8e712f935ef28d88c4168946208efd0e53ae0ae480bd92877930dbd94dd4c49be679801f79caad5873386183808abf6eaf730808c06821c729c','sync','ak',0,0,X'dd102ed52a178411e634f52c4f6c6bfb22b33198','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(14,540009246.01563894747,540009246.01563894747,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'3e988a865d4b20cd337fc4e675d986d8b5e47080',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000007df07212155ed960e619dfce4680f98fb776f3af6c3e8840c6ea7004cbfb13affffffffffffffff4f28f9306b5400f60c6c18e1fe7f2fe9839274a73b0d28a9833aefd22535fb71fbadbcf7c35ef9c7457d488d4a8ac9e8989f7affb1d534986b1e09194d6b212e01951855a4fe5385f8114eabdf7045c21d488e5360464e59f979ef2b6f8c9082cf62a7ea6091c725494dfddb32fe7ab6e440defd652938fc18afaf1e2341ee42f44ea28d8c32a5a7bf01ab52dfbac39e55572d874d3f8f1aff69f9a003f7b32040616a6e2de302c8742e230a17b512cd417490b5cc8953524a35a8afc4ac86ec37e8b4e41a4cfa4659a54608004fb904b6541cacba23bbe35e1f393a7daf','sync','ak',0,0,X'eb8d4a9dd3bbb1a4c9b748bf66c4f223fcd81cdd','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(15,540009246.01945900918,540009246.01945900918,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'848b91f19350904eec92e211f378cfb180f044d7',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000388ecbd28481b5690eb559e4e6d2c4c4c0d2f4e0f58784ff25bc6579e2938670ffffffffffffffffcd855236922ce10cda23969ee07b41e867cb4cdf845bde81cb3e49e8b5d4f12ad092630befcb16e679913939b34d3dcf3cc58f39d1f01b0b1a6555395b0849a03c4178c2059a75ca37fa3006980c769a477c4fba601501de495219ca467985ced76c7c005bec33033a57ec9056cf10990c02f4272a7bdf363e8260580d4a5352fee5e7bf214f373b286e26baf869697756bc9320ce071bce02bb5a49ddbd36e566650eb569554c409192e28ed77c4c826dba03aabb82fcd628f9a607fd5ab6cc5713f59db08d8c7329455df0a2a39b9588a3d3c847fad00b7728539bcffe','sync','ak',0,0,X'ede27d9bb278ad679e007ad8f64b68bc7d17106b','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(16,540009246.02373099325,540009246.02373099325,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'2d355d53dd86109d8946cc385d4e612799949a9a',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000046aab1b63efd4741847d88abbc315302f5676b8018f85a8615d88a96f3b9d4d1ffffffffffffffffeb12a3c6fe77e2a632ee611ade6fc64d12e0a63159863d7792503a97abd2bd6eb605fd317016f3c8cc81003b535cdb497948a862b819c371dc23f448da4dcf66fa75cb235df5ba8d086521c0292464db68e6bb339df98849daa90d589086f3147e605123336cb025041f46b806ac23e4a655757878d110962e96498b4269f3a21659872caf430741c738ade294b40d0fd97c23c10696c622299656cea133322d0a1b5457bb2d54b279ab95f0f1b9a466999646beb77d124894f4e50ea1a7c63ebeab07c19a86286ddc23f10a05dc891f5fd14fbca1ce74eac070e0bbc71a','sync','ak',0,0,X'064e731d3e677c837de05ae105b5f5e79fecc0bb','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(17,540009246.02740502356,540009246.02740502356,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'e9c5538b19dc0af4955ed3abdea0ab1827bb510d',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000c908fdff3a41c6de36487f1c8bfad9069f617536a4ef2e54ae344614dd1939aeffffffffffffffff46e76da3d8ae70564686863f1566a2ae2b727982d9b36ff7a4ba0498a9f7a89ab1562cd8c5dd6fd7f499cb3a2fc989bc48059c9a61fac52bd03298304cef0b997c30ce95b3fa9b1e4ed24052019d8c06c8df8fb2bc5de4214c3615e5a9f0b86209a074c5fcd7961398e87135d31b18e414629ccc132a61c7f5d706e994b8ff267a317857a36268b2bbfa7f9e59156d791b737d7f9dc979c712ea71ef2f03f113b2356b438123a68fc747eb2472a737dff167883ed5b9c121fabd70ba740b305e547e9d5b5b09d324ac58c3c146b806debdf31f48b3fbefaaef83eab27efa','sync','ak',0,0,X'9b0b25ad12cdf94fa248f877c6802645986729ae','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(18,540009246.03106105325,540009246.03106105325,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'6384e8ebbd7b08d9e8f5f25c207b5db3bea3fde0',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000093b97b5d3b79973652b07b15cacbc990c5d3288c7326b9db25e1dbd3df4f1de5ffffffffffffffff80e8ec8057b8c60c69b7d4fcb862fd5bf9e84000ae94ee1e0fb807174c83b4af17372e9729e6557fe69bcda161c7031ff1ecff9442e4783d4436ea45b7addd051cea1706b27d93e65ad559437a5fa3601209e4e23e401647b09b8b836b8b7cfcead4d4d9bb3b24c5c47c3b4000fac61fff5da191680b5b0dc3562e716a3dfcc665ec6588a4d8d70f07d1d65bddbed8abef9aad5be34954734435315934eb5be1a4de0b2a5d28957c8f4a47e687e7f580fd4ebc90dcf7f30dfc2068f0a49607f42c2ba9c73353d739fd07227d37cfbceab73837deb14ea326fe1d6ff5e95a','sync','ak',0,0,X'b83757a8e52e2502a2eb604322ee87f2cc298779','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(19,540009246.03506100176,540009246.03506100176,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'e29530802ccf90dc256fa5b247487074a1b5100a',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000b6433d250303dd30033868240d785d8bb5b235522c19f05c9074717ab528c49affffffffffffffff722594202e4609bdaec66c529c0d60e96cc4424eea8c739341f652ae8502f4aa435061dedf2ac879a5c5610de80cc8bb9cba22a60e8d3ba3f728425847b388808505574e6c505f9e2756e4218877d8dcb31829b25081c6012708c02db495dbff67d061365217dbcd09fef56024456c6bfa4b98b542f52dff2d977eb2f70219cd27e5abdb19b5e28d7806ba7c39bae21440a4fc4bec46538ec19b5ecfbb8d190d17157960e8cb21e8a9d38538f167e02c3eb1b73a51d50d275bf7ca3b206030cd1428880c51e0240975d8b7cc3782eb58513c2175af7b8072ef6174fdc560','sync','ak',0,0,X'daf523c6580d71580e31a3936e997f682a702f8a','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(20,540009246.0390599966,540009246.0390599966,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'84182bc7bda9bac9ff3e6496511884f90f573b84',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000001d0f77962162a1df9b4e0315b2083084217578d8c6e54fcf6fc4bc8df8ebc00effffffffffffffff51b1b49445813c16875090510cbbdcb5619cca1c239c633001d28c4628655bbc8347adb6edcab1bd48e8027571a3bb4c96cf231975604302666c4d12eb5e90a2803f9dd5e5336675e3bdd179f34e12ea969312aa3f471b0800e38f49060fa7136c71d0ba24164d9999efa4298447ce9c1168841a198382b275167b99dc6b7703e6fa044914791de625daa4e50dc7dea72105f7ca8195ffa6d973050699a37302688b46c6a94029f364a0691dd2e9d316c5c8a400f4e09e7b802f3b202e790cc87f89bc06da3b4fb8bb8829b7c5dc84d67a796d846b148b42cf9bc5b5','sync','ak',0,0,X'2111c6975ba46a7b4be18438cb4dcd60ecd58999','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(21,540009246.04271399974,540009246.04271399974,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'fd3b25de8b7936d68251083799bc37899591cd92',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000031f1f25faede3227e172f92649184c66afe60b2afb8faa45cd84e0c01f09303effffffffffffffff98f9094a91cd8526db74bec5d53ac2f858360952b557e73713a9a57a074263e80d42660ff9719294095efd76c868be6f232c5bcfcb398824d51b7a2503c0a2b3362660bcb02177bed89a9a48815eb33fed927cb2e66af873ddfd3bb156a39fd5abf60d1158dbaf1cf63dd58dab9aadca82b571e85f5ad294d3fe346cf6a121440aeb8c8c53d05b926ad1a57c4c98130493ca04676afa09767bc09bae57f6a64be7bf0bb25111108d754ad46ac159170ea5fbc536880714672f32d806e7bb6ef8b7573e16ff4158dae08d2c1d5e0f46b04d0f218fc38775671c0bb5aae949','sync','ak',0,0,X'e2a22915b25aa87d70721ef02dac4b65ca83c763','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(22,540009246.04644501207,540009246.04644501207,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'166994f82033c7f123770fd93a4ca5be1ef65cd4',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000003eba0ada457dd11d98c5eff89c2be18c58c7f56a5a1b11fbe9bb88175cb35f8cffffffffffffffff9b0a96d3f2635faae49f0e03e8fc27d9791483a2c4b0f30174131982d0f4e738cb3d289f37d6c311a5b152920742aa242bd46c08b22a864931ab55c9c35908a486a73e56aefbf555bab7b2b62322026e20cac5585eae5a0ba59f5094e3eea041bf0dc9158290d708a240def28a5c990972b75206544b53ee30a80360d2c6b19a28d35f6dd9255ecd03e30585023f950c34992b1b6bc488c59792e5d0750364b2eac9586ebe9c680c18f7c0a5d4a303412d1fbe15b5dbd3f7afbf4c9f158c3fa7d616130eb3e826e4e419adfd7b3e773a95417c5c6b397c2dd650409b6d93','sync','ak',0,0,X'c9069fa763684b884561b332b43c8e4d7b421961','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(23,540009246.0500359535,540009246.0500359535,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'fe441bf8ed28ee3f57594bed1e7e32dafcf598de',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000079ed9dd821eda407329291bd377b25325f1832c70b354c37ee8bbe06c5beb188ffffffffffffffff1d9040d1d8a706817fa2f11c9d00dcc27a68cda36153dce1cb497a17f9c0e27dbdd595c7df0beb82361cfeeea9d45d9b7247e6b0ef1c99d21c460b2d56ba85d0cf2edd732fcda6a2315765aa3c20387a9d444c2e44e6c260d64ad2c4c499611e1e13d1dea16e615363f569be1a1b428b495434573c15e80c7116bbdd93c5ca77213eed47de7014d9829f695465f1697643d1863eeee681d2d973a77e7ac417b2184a4e7bc054841fb0e8f11c5eba3df57a2df8f1a5dff2a3469854f42370c8925020a105da93ef54ddff78a4061467a36e9eb44aa762c19e42d67224dce5','sync','ak',0,0,X'963e55dc2b9f20af288c3ac668dc63cb977a02d9','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(24,540009246.06836700437,540009246.06836700437,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'215abad1bcead4124197850dee86ce1e8a87e7af',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000006c1f41825815f257ca6372249f01b45036cdc751dbd926d85a06d0e0db699e1affffffffffffffffd1791f6f4a1976976da6fd5cd2cb539bbc219567de638ec2a8f294a4056f5f60ebe6056acbc23b6444293656031a508c1b2bf2c20b61a8902fd6fb2f746996ac520da159cb6b82b137743a9000d77c93235ddf48efe1c286473b03928f10ee67e39e9fb579dd9c3778cf6104889d4fb8df1744de2585d932ea62e6305ae7bb2a5a207453e34697086fd415885ef805eca7864e56f10d6c723f3da17595a86ad877dccea58cada27dbb563381b900e93881d48a2d43d4a665801933466ed38d67cffab0d1a1f2147ba320c060f4a633c6bba7340384b82decb4e6728ca1c3','sync','ak',0,0,X'72f52b8d9cbde9b80f3a289ab6f7e174c3c6d237','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(25,540009246.07308697701,540009246.07308697701,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'298c1e15fc3964aead90dc076a13679e14a2ac2c',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000004bb209bc16910ca296541b38d67f7ca1f675fe5b2265fbd1bd80e5863e3d2044ffffffffffffffff79f1a89e94bfc3c27d8e238bdfa441dd2739e4d46577f36a9192678dafdec8276503c5e1f42d779baa68f0289b8e41402b260fe84dac87cfac349f79c3c1b663c5c0a9f614305a4810f4d1a21ac9d30d1903f0f0ea77a544bec49c84da9109025d391220e8c7c111476fa77d68a80388a3ca8bcf0b16984a8fb077e87c163582be970d999194e283c078beca893bfa8f3c7dd4fc67652c767518de06a3bb87cb72ffe7a0e6c78478e8aa6dfb8f2d32a33eb5e0fb0fd3650a26b1323c0b1cc45e33fb4eed360590cee6a014b89a11550af12bada506fe727be9c94cb9c9a6','sync','ak',0,0,X'21f34fed5a4b46a2661562af9062656da7d8ea9c','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(26,540009246.07746100423,540009246.07746100423,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'bbb92bd8956ce7ea51e3b5a52770f63878e8e935',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000607c37b5240275af50a4bef5fa8a876aa7502c0f0afb132426390cf452ad88ffffffffffffffffff28f2dbbfdff39bdf32899676854a3aa0e52238eb2823488d310597342e71bf8541bde80e7eddd8916baeb102f3359df3db3843bbc0588b223a8a901cea598d718b54417b35a5d3afd8ae47165c9fc5ba46a44edecab2da7a736a96ebe5e74bd4e9c57104594c6a99b9430979fafd58672f66fa848b8895cd7ff3f36ff1dbc3cc3ebbb8d63e2873d8d251d699c4403bc2739f3c8b8ac28ccef0265cf1147f557bb1b17aecab035c65799eac5d491a93005552cb789d58226b6233e6f62ce57e61b3d01b1989cbfdf77089ac1cfa306710a42f580633c89b1828b499542b36','sync','ak',0,0,X'88facef56a3d4b6e564da7dc286c68f4719270e3','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(27,540009246.08136796952,540009246.08136796952,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'9ff2f7c4b27e2d78a8d00d1989a41896dc3e3691',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000001395f10a95872f2cb8f7bb740403d3d5daf6cdcfcd2e0dd915d81786ab1b59bcffffffffffffffff2e26e36d9f973ef41685f520fe218bd0477945500196867e1a1dacc35a8e348de80cb921c70d3d05eed4bdb070c8c6cc7f309cc9cb3e6d9c10a9cff8c70809217617047bc99a3e779454f5d6d8cba071b500db671e44651dc0c1fe791d323cacdbad75518e49f073a3ca4b798f4b2e10b85a1b7793c539b7db1e7410d0cf42ab4a65e83c86184d73c79c336577717b76dc1fa701d63a88979380a89a5f73a78e2404bfe349c24e6a3b215dca8521f18bf73246e54503986c7bc5229fd192061ee224f7a1782bfbcf4558e83c27b743e826c23832ec65900563de164ec33c','sync','ak',0,0,X'f0973208d33e467e4b0813858d22c799b48fe79f','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(28,540009246.08478295804,540009246.08478295804,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'f1fd3a0e76155cead83c6fba2a82fb56350df259',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000ccb381b7635074bd24f70511d7f6be4a133f94862ccebe48e5c378952c64372dffffffffffffffff691c40d07dc45276276f49eed47c12f3fbe9ca71d7331861e20e4cd16bb95b880c7821c32fef4b84060e98bcceed100a5e6d57888ebb84423fdda8295796cddfa1b48c86c2d8cef98abe9ccd895f6bb3a9147a34200cab6fcd37ad9f311aac23223088e689555eea2e03b908efe347deff926eac98fe634f1884488820d3645f5b699ccaab603eaae68da649b872ed8794aafaaf1532073f8409dd3937298e2cababe89a4a9bf16aae65c080619f05a1026eace4a5956d7e17afba3df4c3eb60a003dac1acf5dc06324ff36cd0138b67cd96df0b57e836acc72fa172de30','sync','ak',0,0,X'dc591988007f260a636861192c80c483bd957123','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(29,540009246.08790004254,540009246.08790004254,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'457ca81200fc6ef89b19fa8c5687fb3afcc28fd8',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000002c4e3519fb054d2a23e6c525061d2513cbff9b15acc4dac42cef667457ec8b52fffffffffffffffffee39a69e50c522bd06f53f36a305e664c31598d115ea31f832b92d9db8d4b1a295640bde3246b2795cbca34651b5af1dd2f5da9bce168f9b47bbf7ad0e790ddeb22e648a82381ca9e877dceb89ba718938a797af58075556cd1f17b606d3bd4b625168058206c2426baae58a1d25e2aa0740b5a8db0b3d9c987bde7cba59a42291c478bcf1bd7d8aeb80271b6eabb824a07fc85fabf0d0d5bd5cdca6b8b41e0d4a7966b042e1faf60be3118a7119169077478aab0086a8c670eb92989733d79df80168200f1a79c33a705e4108a08f6e77e7120482d5d8a0452','sync','ak',0,0,X'6a2af463ea21cc27aeab8dd374436f185c297924','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(30,540009246.09233105183,540009246.09233105183,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'0b3028c40099176e838e81ead36f67ad18928d48',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000004b4c4c273000e4bca1693d8548582038c63ad8653eb9aa73c3ad1e76f5dc0fb4ffffffffffffffffa77afd4b131e57080333cbda89bcc90ef0b4f2ce860d5e0023831f26ef83fa29f8d20aab3a80611d64b3a256dbd8495ad3b906b5f18336e4816ff825a35fb33a714d2ade4a1b3ff52ab52a15a4f9c4613af6c218da7cb4dbc817e54d52d6105eceaa46b28ee4ed5c1cdefe947263e72cfc7ec3a7f07d29c8dbd1fe571cdb6485622569a6ae17fe4d43e489de84fea7282e327757a530f2e0aa74dc19d2a756895f5d13f3c0e09f67f20d3edc107a36023959acd8c94a90f75bee1372f23a5abbbdf0502658255716da26bfc3281a6ef20e4bba3279933c7c28a250a13a01','sync','ak',0,0,X'dccb82d6d4775ef77809ca0020d03d03a4cc3679','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(31,540009246.09653496743,540009246.09653496743,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'7cb537d6c581482a1c1192a904a2baeb68622b14',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000007350fc643562ecc25943bb3d9243f5c054ba1b1cf75afe812b3f3b07213a8b92ffffffffffffffff88609d1daa302e80908ec745a3d053dd05bce0a447b005c1c5512b106f76f7319b7083a7e5ad542b73f6e8f98cd44dde01a7fa3a358763ce17bff030fe76f13fd7c50ec82505b6d54ffcf1e2262b807edda5e50b4d3c8190bc96e6a2febb3f1be3d68be132bcc2cd3192cd782c7c4e75cf3ae99bda4a34c668dee15476e2eb3e2e8a33cc24a6f402bb71f9cb4468ebd7124363b7cee20c0fd5e798cc1d401d5f5a29e5a03a1b7a324e434aa19bff6d205d1085bb367221d0275522b7f3537f61bc44ba336bb5bcceb9d13da1820bf5f05f792ee6eb2ef5b80ac3c3f794ee','sync','ak',0,0,X'40bf8eb16fa28a2d22cb819e95bfc567520f60ce','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(32,540009246.10136699678,540009246.10136699678,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'9fa550e31db22b3968b29876e892efd739b7cbb4',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000cc991923c11cf3d9175a04658ee1f5e335074a6ac6283bd6479499530286f551ffffffffffffffffb43ecba3279e004f958c51ff4d581c3c054e82146efbd2326fb647bdd49c5f7936adc63357a2d86bf8d6a37387a707043800356a2ad4e83133692be5ab2efcd0189da7e9233430aee4296fbe16d89b84e061f129cfc6660d88c1ef704f1c79b76d3a3b763724e01f10c3e4b85ae58da682e2e904000bc98421fdbbd961f8597686273a1c4548640f686d1eb10a48e0a9a575c6cca1581e92b620dd01d7a8a94ca9f3094dd430bf32d0cc806a3c463863b3186e9ce52cee9a0a947441623ed4bd84d0afce3baeb1138be2ced6a8bb1d40b69b68d4110aecbc6e87324fc430','sync','ak',0,0,X'fd691e6048602d19dd155a88f142156b41a01305','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(33,540009246.10513496397,540009246.10513496397,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'481b02e558337bcaed9d54209d530e17d408e0cc',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000007db92007511383867241723797a9ccd4d28889c93351963f219f21810faa5d4affffffffffffffff869c81a43f39f42b416b7b4bb3852c9109bfe2ef54b96ffac148237cd02f657ee49c40b6e27a5b4a4d8fe75016696c808b1543d1599bdf035dc456281b6c812c8cfd2139a7487b0ca057d248970d97c45b914fb9e222a2ed4ca29f800f0c559714d24dc2853d23f56a703b8b0db1603d33db0b62e5d1f71b61ddeed4f29ce4175552b5de0a00a3e767262fabf1c4d630310d4cec1697053ebfc433a10ab733d330fe79f0663fa853ea0ea062e97fe47012b364829cafc63f7d44fc2c23fa9af3a8e8ac0784bd24e5fe1f0bb062861cddff94b77aac1897c1be41f9eae1e0','sync','ak',0,0,X'4cc770007795860f7af697ac327c2a512a56e5c5','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(34,540009246.10805094241,540009246.10805094241,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'c39bd8c7d03d60d6c9d46810e92d40ff2fa727f0',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000000501649f3f054c956f5b15bc501cc7ad8c8dab2aed0c14190f4f43bdf1ea772fffffffffffffffff8dc5fc06ce90205fb10eb00b4c268726c423400d21fc1c5856dffe7f0cea407571850b42b6eb0914617e98e70134dc6cc75b0ecaacff04932516f2ad17c0ed17ddbf37b362f6ce5266e3dff6550c302b4374d7e8b375c062aeae5567a745bb583a806c76f799554ca3df2b28e4b966ee93a77b068bb290b67b5af90b2b9acb5e99a535ad4472cbc83fe0110790e634061c3d7de2a6f1ca7e95bebf198231933dda7b23339054a69e4368ba46081bd7ee1a5bbb38294e9b6b0bffad5cd48fdc6d5d43b394ffb986db2c7502d0d3f9f18a0facff89c9ba2f2aafe0e87d4cd6','sync','ak',0,0,X'4416e3caf3305aeb56c7d82f5213a75cc2dbace6','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(35,540009246.11151099206,540009246.11151099206,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'fa9163eaa8e20394509f96572cd9904a455a9edd',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000004fcbc521042b2d24892b38ecb7e7f0a0715e0e768df8577f090224a99e52fec4ffffffffffffffff95c7ecb4264c8f0bdb76638376bd633e3880cda4b1d8b0d754e6c4018f1d2f04ac9971141dc5379a110054c82e8a0b0b13f5d9246a38d61b9acc4cd44b00d0ff6655d46ec84e6da6dbc7543077c2c00e1446ebe4d6804304ad9c760a47167b220238b35f07cd6eaf3ce70b20d83771acf84f505149221b9f2fe066dbb9a96f9a5bfb4a357fa036fc66eb5ded7f8231114483db87a7adf0e49a18548661f8ed24d4c0d1c0a5d31b2985f103afb366ff6531a517c050445b56fa545fdde7aa20cb2c45f82985964f0f28ead79dbd1bedacd5db05575be3721e6dc5a8f927a1','sync','ak',0,0,X'd741b608a5935373789035097ce5089534e0a615','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(36,540009246.11565101146,540009246.11565101146,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'c146e972cd43db30fcbe92ac84bb6759546a6a97',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000905342763f215c0a9a984fd678d89060ccc669650f5c1a4d9db6cc90b623d87cffffffffffffffff424bb5434cad764c0e4af92170782c292eb15316acad1ff9bd4d328fb9a39196e9dc0ce0877046f2c64a645147b1d9726059ddb2ff6d55cc37a9d474e8a51e93c412077e6dc0885dd57654c99bc96964bbd091310f573af8285c7db75dfe08e033916a411bed4f88c837adbcb49d9cdb5c3d1951662330cc1ed11dc75ddfa8aa0a9c33902bae6ce7baec8c51398cde632422d63b3e158217c928975cad15bf97bcae9c4a3c5cb69df9083d7ea9d5ebdc746fc886c37b2019aebeaebd002c1a7af053219253482fe604834b508153f477c08d540a78b5e9b3c8c3269062ad','sync','ak',0,0,X'70ea352c55c79851cc41a1c5982731a6abae7577','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(37,540009246.11884999274,540009246.11884999274,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'10d55ff7665a76399dd3b9bc325e080075e2ca80',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000eb64cd0cde58b64f05b37d4310d83fdd5f6b37e38041459d018b1723b5a28cefffffffffffffffff8595b53084d082cde671f8e32d5a1db5535de1a97e6e8630c5547ed82ba323a47c1853c5d67792e9fdf32346164f6e74f7e28b2674754ce893798b74f1d68652512f15489ff028f47647fec837e4dab7bf5dae93bc2830a9715602107efa63dfe37c8f9ff7ae9f37f13fff61e3bdb93a369fbabd5f34bd02c5b49c17f078b2fd12c9bde7d398d884a18d50c262b3d48115ca26da6426a894c6174cfcd5e0f05fdc3e717cce3c6707503ffe43c5a0472a9ea8da315ca4c3e5f4a53df6b329ee1bdcb08df38bbfe0fd4126cc13c26947d90d71ddfde103a97b54cc431b','sync','ak',0,0,X'10fa113010c1fa7cc8d78e530fa1a7268c38ad23','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(38,540009246.12437605858,540009246.12437605858,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'ae3d912d9c06192d7a912b5ca7813cf6fe85c363',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000cee7c95d6d334478b08e52bb9bf596648f680c686649049fab2db6e980629f6effffffffffffffff5768e69ee03ad4d33b19b82b4c8d853885e78db47b41a26a27fdbfb705bd77f9938b7aaaf20dd4f0f0550b2e9893f9b45bb39b73c13145cf7ac36c2be5713f7462b2b987b7f9cfa4e3f039924bc798c80245189b845577888b9957ac0186ceda93dfbbb9944dbd07f9320781eddd3bee15561ba673996c0b916a0266538b63fc1d1b18fbcf603521491466ec6b9b99b75b054a2d52705ba8f236f754c076940a9d109ccb85d9f3b708c3ab9c9a9e206eda19d42524316fd92978703976603f8ac575d5265f34466866ef9122d1c8044efab107861e5ee185394c06f9cf4d','sync','ak',0,0,X'4e6ab77f90390aca3cdfbd67e65641d94b56d912','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(39,540009246.12985503675,540009246.12985503675,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'cb26c3b4e982f9215562a5638e21368325e320ae',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000013eb07449f06d26474b303078921e5c00234dad3bb626387f47c24d365ee267cffffffffffffffff43f2ec6d496b16ce8f1f3a2d0cf51b68894dfa21dfc99b903d9d66de25fbe11c275040aa867962ea3860b51c029bc3f821fa42f2108e6425e67ba2b496b5a7e8ad43ffb37249985a3fe3c19ca2e4f6d4bb3c2b649ee1257f6e0e5e7da835a834ed520ee748696427d1e7d10a14e393408ab873600b2820e9ce18f689cd91227546d2518e161d5c8d4fcbcb344704524d07ce0bc5709b7608d2a46017cb545244de5744c50227fcf9706c9a1a29b6780e5f65e273aa8e1be043d7ba07a9797631c87b05c9ed4069bc7399fa448e94c473399f66c9693147c265d700fab2be','sync','ak',0,0,X'f3f13c555913aec22beddf172c5e8e846cd6a6ad','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(40,540009246.13457798959,540009246.13457798959,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'2a2f3bc6c0b0fa2c7d67857bba536c8286992ef5',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000001fa895844938c23e78b2fc7c8121d1ded5ef9e23a297de40c23f7f4297964c10ffffffffffffffff7d9e1fd229e1ae5f470932419ed3074e6776b690467a913cb972d6c3497493c872f34113232a21370470c9af51fc2650a675bd62e7b8c134b9e12a7a89436173c99113729084a64f1bc79cab4769bda9cea67f872121d5fd73dffc424df3a409355de87f2d6c3785c327f19a880c85b30fe9eeaeb175ac68548b23b65b1dc22da8758c7d131a1b7cb7f5700f871f842b42ce2cffb42ef37f33c31184df916a74210f0d9e07ba6f76c3567f8886fcb981c0ee0b10972df721e8f58181c6a76faa9324f99726da68398b68b130471f35f5d518dbc7e59ce2d27801815201c1','sync','ak',0,0,X'b48fc42bb7d984027c070247342e0ea560d40af7','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(41,540009246.13815200329,540009246.13815200329,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'aed7b09246a7e6fb7d12fcb5131cdfe5133f1ea5',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000006b85d74fdf19f68bca707aedd0304e8be229a0ad1a84f03ef9fe31ca0164fd9fffffffffffffffff7d6a3af6b7973a3827c703e365dcd3bfc5ffa2db339e5d44dd8ee3aa60b962d609552872a69b3164fb8d6a52ddb4121d22d29dcfccd848d88f8363a2c7144a2fa3114f671997d5ec60228bcf0aa71f25d59b3156363ab5c2d9fc21618fb6706b978732f3fd3ef1e56851c207496bb3bcef74b3fded822fc0b79f6c739c8e5985f0453702b4c8d206a1d2a69e116e68d4b566b6b46198f48c711a0f9fdda8569a80ed35193e9402472128425bc83a8b5f11f818b38ebf73b79c72256104476a81fbf00e7cee48d9e435bfa62f234e80b5d20dd8536251cb4ca89c37ae1c3','sync','ak',0,0,X'a4b63a617ea4b0ca502a01737075ceadd8ee978b','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(42,540009246.14087796211,540009246.14087796211,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'ffa6ae40a6afe4e6c9c676fa122bce8529992a5a',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000ece8f63a005e529b422a473b1aa791c95bd2fa861fc383863b254b6ada78f311ffffffffffffffff5f845e150333311755a4044c51ba874ca3c43400942eba9f14bc2da369e2d80ca281c9d43bcbc3a0398a75892c7779e20a3cc2097eec79f6fd39d260448b4e9b6d566ce3551e11ab291c17767bfe5aa9f644cc75d0b8337e56d9bf3c4c09b75ade0648ff2d0773e0964391487cbba01ae22dfff5462b6e96c2fefffab2685c44b9e3c99baa2283870ab24e5a58aa933f436ac91ef4507b85ec8c70209d91e0d70f9d7ce6d5585a17595594c84449bd29ea98486e06141693683981acf8e2bbf6e538749c3bb9f707a1fb0a16cf4c2787dfc2afc82195c1252b7529747d23','sync','ak',0,0,X'205053fd3a4ff552a332844a1d4e8dc57cd87ddd','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(43,540009246.14429497718,540009246.14429497718,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'a3d2b38f6e49125112a1804deece91e421f965e4',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000acbe8f196252107eb0710213824e1728e25af217b6e86a6c980c9b96ddf08c1ffffffffffffffffff8633d67b0816e4e7a2e328996e0c972d5d7c0ae2b98ce3e6d6a1978fac1d6cfa2dabb67cc5c22fd5d5f5c6673ce264ac553538dccbfbc907d586f888cd4eb10280f66c2ae555caddd2b4161cc5bb8b40641eab92b45ea6d01c283764fb58c745d38c8fbbaceb4dcd25df50f24bcca615ced354628c93b267e526c90705b5f7249519c78eb61061f8ead1760bd2724af14c9d3f1720c2e95825dc96a7aff0072e4c208932008c99bd92987f3573a6ea0c1ca5865c1d8b3635601516d358504625f19ee4fad35598dc657ac10869c4e7c51c356b6f6764fb6276638f6b925','sync','ak',0,0,X'a99fa6b8bb1a577e641ceaac6d42dc133f808965','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(44,540009246.14734101296,540009246.14734101296,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'a726f509119981ebbfeef50afe3118f653c171c8',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000009c805cfe08a7f97697e2b44bdcb1ec5528614fe7353549885d6f0be1c22a5c0affffffffffffffff32b0d2e5fff3341787b135c4b9a78efa9a96a87cec39c513525bb3e14f66cc82622f0124dda52bbdb44947b6854e25367dc02b3246985ecf1694ceea15729029bb86ff6605ba2eb3d8141054df7792eac3a025f1961e777a8e965d909676b7054f5a79ec8ad3d6edc10c8c17bfc402d2a1b24c06453bd1af07578a15a635cabe4cc851e35740894a7e7f7b0ac043aa57914c85d424edbcc569e1364fd6b18e0e1334972c06d253758ef2e3f665cd186c607552bd7639dd32623a861c91e6d540811b99e12a2c850e8b4bf2378f9519d7c6b511521d54d06eef10b0b9b082','sync','ak',0,0,X'017b6c1fda8f9ce1743e6c2fe2bf2258ef7989b7','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(45,540009246.15040802956,540009246.15040802956,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'c932b839c200a4b2d2dae9f543d3cf16e7fe9b11',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000980f3b8f00ddb2a079e93cfd435436b00f08f88f101834f4262de73c560d56cbffffffffffffffff8a1534379b3d4c4a9d1a99093560229e653f2911bfe9970b0fd028a09240ed03f4a72b2e76dd8a8a8022692fa5fb9c9b67ed5a402732f980eaa22b53e42df70b1ea858d39599f641d211dc745141d86b99281c029ba08205aaeb5fc3bcbd49ee12a1c5d7b6e29b602d58a35f769451831bb113269e13ee83731d757b3c365caca7c56c885a4364f8cba2cb701f24557aa15e7167cfc777aad1e3d45f141946ec583ff71630685258c91e5f50124fd4f9e8646c7dbe522df10f5a0a7475730e710cead70d60321912159ca9697c0e03e1006f9d02e25f7e2fe021e68da313','sync','ak',0,0,X'b85a6e345f2e091959d44faf1ed4ed06bc5d0eb3','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(46,540009246.15337598322,540009246.15337598322,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'218039970958276aa9280c9c38e67cb945818af7',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'03000080060000002800000070de334bc93720f3071104b02fd776113f5904c674a57558ac1114549a6d089afffffffffffffffff56651d147cf18cc584562bd1c3932af147762a507863635a01d388cde2ca6147b38c450cf42254cacce12d210a413a0821fc4b93468642a4d391c4d3045f956132ce60e70717b8c9d2dcdd74f77f5ac8bcfb3898a9b39beccfc6f51d658721aa992528a99682d62bf6e8de487a1c291e5359812ab6bf69f55e26566b2ab4bb9ceb0513314afd9963e6507cbc8005b021924d90d32c7a3ff19eb73d9a48988d3661db916cd6a410f6a7138dde5d229799405201833b7a799be9ea72d96fd855a78d688ff2f6e239a114bc433aba69c8b35d00c68301734ae82c1cf5e7a42','sync','ak',0,0,X'e3e79af64959c52963cb5f90d94cc7baa0afd741','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(47,540009246.15662097929,540009246.15662097929,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'b62ddddaa3d03b92122817af746791c7e6e86be4',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000004cb5f37926091210edf1d042d0186ba7e21ec7f706c7bcfad2fb38e736617357ffffffffffffffff7a4e286409d4e50d06183eda805e49464880ca9b7457f69b46d8718c1d8149c926c8a6f58b6fd329bc641391db3ab6eb21b681f70b4b2e5a51c2570f8481ec4d5ae8e39cc9530979f7fa8e19ab65b4701c7d0c6e01e06037aebf6787eeefcb841e5e7c7da1c236c20c52d9bbcbe9ed589d9da3ccf30b5861cdf8503522a589e0e4973a03fd8a24e55aeb2ec7174f196ff4a190c94275e9487f001fa2952988c0cc91e7754d6e82843b35b07d841cc97ca7894b571318c6452ddd38523da4deed9ad3655f2692c76df9762eb5c8112b54fd950563da225b37c005650dcfb5','sync','ak',0,0,X'931f503216aec2276cf4de013c8e17bdee01340c','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(48,540009246.15953397752,540009246.15953397752,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'28c7da70aa2baa1ba58d752eeca3e605eecc5806',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000269239d0792d33cc3ba5fa68f8d767f2c8db3e4e1f3bddb680baed083fb70e9dffffffffffffffff81389ea97f06441b683bb62ae06f88ca5c40f5cc7db5fd4accfc65e96739e1db20b13fe153beec620959c0993747effde1581c36513f329a2c47051b628861099185df63bf55071c69e0d739b3a6242794422b1bf980ccf46cc01e5c17ca7bee3ad0102c3e459845562c6438f377463727e1e7a98736bc452c008cc51c817b80061a4363e78c4ccaf278054bd3e28d29ea64a06db5cd3440e612db1b9271dacff57aff31064bee6c9e2b5c05450377cc37c68e6a1065511fa46a154f042749df9411499d6f27d48c69786fda878397e7ed40132b868df29a2f4fe350ffcc','sync','ak',0,0,X'73ffce8e3a24faace335fb57857cfe01bb112a62','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(49,540009246.16241300106,540009246.16241300106,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'9bad040aca6d5538965effb516a6af074bd9b95a',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'0300008006000000280000004e79bf61bb34b6a707449f4ab545707c3f32103e781fe7d4ab86518078dcab22ffffffffffffffff47ffff0dc56a1a4166acc4ebd6032b791ccde9607dcb08c1fbbc88393a43820c9cf82e37cb3bfbf4482db8052c1dfe5c79260d5c1e6eb60de8665cf7fdb52e315e6c401004e625c42bda3ff85d18ea8156ddee1d827d23afe0f691f2043d3eacae3ec6ebbdc514f21dbfff234fcd05da1ca5716412af4a5bc423fc1c272872877e2ea10aafde799e0e8f264180a2f66bf7eb19ade170fba6c60c80f3d8e0aaf212c4dfb89aa531332a82193c6b31e2bc509a08cafbc3addbe63cd4f17559fa82147e519805bff87ca79560eeb0c890dc77a8631521667414d065d9bf0512','sync','ak',0,0,X'5bdf5602f319d6fa9a48899ef41b099359c4b727','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO genp VALUES(50,540009246.16554105282,540009246.16554105282,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,NULL,X'c836ab78de836bb61f6e95ad145322eef78ac34a',X'60b0f62a25648e85ca93fbb508de87c5537a7a38',NULL,X'030000800600000028000000b38cc4c21b52e5847764fdca1a8de78e169c8f8818de9a76a717c5460f2bff0dffffffffffffffffef59d8614872a04f39f4996c41fd1edc52fce6a1f0e4d1540c62cb93e60974e4d193205cc0f26c1ed7abe0af03f15361b47902550f43d4dad57a9f888af7753999b9a5c2fd68a8709880534e814eaad0fe357924d63de8d088fcdd9e45c9457dc5d23c4ecf6fcb563a5e78dc63de703dbec694521d3695ad3cc568b1ba66488f360464aa9721fc80bbd6fbfd34d371a7f99a225b39a8942867bd14cb255ad00ddfac6147218e2a9d1d0c9ddca36de321df9e249ae9d966c44d03de515b0ec4eed5e7dd0bb5635bf6b8ce3854d47c0f806bfd6c64e4e8e86996ec0925b776','sync','ak',0,0,X'5e9787515348cc4321af5861ad0249d687f3dee2','','','',NULL,NULL,NULL,NULL,NULL,'');",
"CREATE TABLE inet(rowid INTEGER PRIMARY KEY AUTOINCREMENT,cdat REAL,mdat REAL,desc BLOB,icmt BLOB,crtr INTEGER,type INTEGER,scrp INTEGER,labl BLOB,alis BLOB,invi INTEGER,nega INTEGER,cusi INTEGER,prot BLOB,acct BLOB NOT NULL DEFAULT '',sdmn BLOB NOT NULL DEFAULT '',srvr BLOB NOT NULL DEFAULT '',ptcl INTEGER NOT NULL DEFAULT 0,atyp BLOB NOT NULL DEFAULT '',port INTEGER NOT NULL DEFAULT 0,path BLOB NOT NULL DEFAULT '',data BLOB,agrp TEXT NOT NULL,pdmn TEXT,sync INTEGER NOT NULL DEFAULT 0,tomb INTEGER NOT NULL DEFAULT 0,sha1 BLOB,vwht TEXT,tkid TEXT,musr BLOB NOT NULL,UUID TEXT,sysb INTEGER DEFAULT 0,pcss INTEGER,pcsk BLOB,pcsi BLOB,persistref BLOB NOT NULL,UNIQUE(acct,sdmn,srvr,ptcl,atyp,port,path,agrp,sync,vwht,tkid,musr));",
"CREATE TABLE cert(rowid INTEGER PRIMARY KEY AUTOINCREMENT,cdat REAL,mdat REAL,ctyp INTEGER NOT NULL DEFAULT 0,cenc INTEGER,labl BLOB,alis BLOB,subj BLOB,issr BLOB NOT NULL DEFAULT '',slnr BLOB NOT NULL DEFAULT '',skid BLOB,pkhh BLOB,data BLOB,agrp TEXT NOT NULL,pdmn TEXT,sync INTEGER NOT NULL DEFAULT 0,tomb INTEGER NOT NULL DEFAULT 0,sha1 BLOB,vwht TEXT,tkid TEXT,musr BLOB NOT NULL,UUID TEXT,sysb INTEGER DEFAULT 0,pcss INTEGER,pcsk BLOB,pcsi BLOB,persistref BLOB NOT NULL,UNIQUE(ctyp,issr,slnr,agrp,sync,vwht,tkid,musr));",
"CREATE TABLE keys(rowid INTEGER PRIMARY KEY AUTOINCREMENT,cdat REAL,mdat REAL,kcls INTEGER NOT NULL DEFAULT 0,labl BLOB,alis BLOB,perm INTEGER,priv INTEGER,modi INTEGER,klbl BLOB NOT NULL DEFAULT '',atag BLOB NOT NULL DEFAULT '',crtr INTEGER NOT NULL DEFAULT 0,type INTEGER NOT NULL DEFAULT 0,bsiz INTEGER NOT NULL DEFAULT 0,esiz INTEGER NOT NULL DEFAULT 0,sdat REAL NOT NULL DEFAULT 0,edat REAL NOT NULL DEFAULT 0,sens INTEGER,asen INTEGER,extr INTEGER,next INTEGER,encr INTEGER,decr INTEGER,drve INTEGER,sign INTEGER,vrfy INTEGER,snrc INTEGER,vyrc INTEGER,wrap INTEGER,unwp INTEGER,data BLOB,agrp TEXT NOT NULL,pdmn TEXT,sync INTEGER NOT NULL DEFAULT 0,tomb INTEGER NOT NULL DEFAULT 0,sha1 BLOB,vwht TEXT,tkid TEXT,musr BLOB NOT NULL,UUID TEXT,sysb INTEGER DEFAULT 0,pcss INTEGER,pcsk BLOB,pcsi BLOB,persistref BLOB NOT NULL,UNIQUE(kcls,klbl,atag,crtr,type,bsiz,esiz,sdat,edat,agrp,sync,vwht,tkid,musr));",
"INSERT INTO keys VALUES(1,540009246.19841694832,540009246.19841694832,X'3c585604e87f855973731fea83e21fab9392d2fc',X'9a08110bc764be9db9bc110742ba7e9a378f3d09',NULL,1,1,1,X'995a7134b96d07759386b20c4b450f7d275b7391',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000d9d8cb6901c0890249dc4125dcafcb4e00b820680f2c170af363cb9de8617a33ffffffffffffffff1f6c1d8abc39bc95cbf8b622523b5934e56156d052f1e481fe1d6c19a84e7be8776a09594830e7c29414e076bcd1d49a0dc768b99c833fbb4cb9129e052c107729858ebbed9af65c49978c332f7ac820ff963de358dd37c8b331df2cff5e19af60293fa32da1abe755e87af9928d79fff0ee19ebf4474b76ca1cbacf57966e06fe1eca6960b5c2926c889e985609884c17b7a0b2efa2a18d87b8e2016193b569e276bcb612a02280e31c13454ba1c53dc8c3a1c6c38a4875b6676ea291d22bd48ad8c1f9fbe9145ed17c99875eb14591bbc5df24e31d17b8ee019a6edebd602ab600f888bbf21cbfcfc6df9942bc0626a10ef3912a7604d247361f8f07e8e834e7be89b350dee08fd4d17d172d10ef008478a04705a278d6149f940c7470ed5613bb47018c02f00d29078f57484de7861d21a2108ab7e6fd116d8fe7928f9940ccad9e49df85eeebe1f0f6963bd35d03086d1807d92e5c9e0d0909dd18552054fff9858535af562dc95d606dea981447b48335a7b9b8133042c6d6404db569f1a43c2eb73090401774e322e6bbcf4fb16e8172aeecd55025d8227779e818528313a86d8c04f4e56bc3655a114a19da2f4f2097dbf2530f6128f0759b2aef873626d4d3b3c9b6cc122f9b1a0a0f81294130699f3f7d326f5356a3855b859bab2aa45400567f2fb2581331aef32d7a202c672a6bc45e0499aab35ef797361dba2beef4a0a796e4504f21a63e14fd2917b84c486c477da3d234a167a0d18a560e0ecea21e7ea9eebfa6f094b6c2633e98504f25428f7e9b18761d6a807a077244ff7ee75be7fa5a5543286dd87ab6723b77dbb23226996c5514a5831169b44b5c4325a8fae72d000a31cfb81bd593b9fe77478c35453f4a59d148b7013d86d29510e0817e8999312b56b727b05959ed222b20f24191e594e8d526728a2d4c2389c244b56dcfcf5d0c61da8ee03d270c027cdcb4b865f4747256659b663bc00be96b0740cada9df7ad39657683dd2af0bc6fa65d7125c7d4d9fcac05dabde572c47968710ec6f4da2b55539b5ba695400e92981e714e8685b80da2c70bd236a2baf1e1e3edbdd7944ee21fb05767c1617dd4df9dcda549ed1230c6f7c63b101eeec5f73158b28c831af5fd34a7875caefd6b096b6bb25e5cf5b865bc424f6cb3bd8bb6e7750a6b2c36793b0fca7765e1aa99ee53ebbac5f464b83edccd272f7574c7c1dd1463c08088b63c3727dd8e50008e0c705339f3311cb5be1c4f9e4a5d0309271492d3c0c357fd058464cccf97f777989641a2fa2b1a9eb65f78e1e6b38d0ec8c941ad33b26b6f1c586600db37455e84449fa5ee0dc235acc5f63470b5cabab8086cf6c7301f010629cb8e9957a75356823d7f6ae20ee238cb7409ebfddf0f056d3cc7c1c07e009cdeb6c56a0fcba426a745d77a637bc5dc13447c5474ad81601ac9810feec0605b038b0436d576da3c4aaa0c868ffa9d851fa6ed487c471a76e5b5fb498e19ff3922677209520fef0699f7b75cfcdfdfce79734881692b6c7ab37cea375634e1c780f95d146a01d81aabd517965ada68dca900d4c52169ae29bca20642996184','sync','ak',0,0,X'da54fd644fcef9c37d7ef945244ac15d2877fdc9','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(2,540009246.23930704592,540009246.23930704592,X'3c585604e87f855973731fea83e21fab9392d2fc',X'b32091dc8a67b6dfe720a532ca08683fa798431f',NULL,1,1,1,X'257ffd4973c8ecf11a6be35871f6c9c243fdd1cc',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000a0294251278f4316ec77109ed0a2ce3ba57938d6270107c4f4b65f8c7c67bd52ffffffffffffffffab4bf8cebc002fac883febdcd95cce5af390712a0e1fdae16a90f9c852f65fb47f77d7871ee9d5cbb6de7712fe814c2614e15ea63a8e08feb17d8e6efa6e6c42b88fb43947c756d2894bd8ab0e383af4b8a9d5fbc9b44a4ad5b923fcae155ec1d213b512cb924645c99a21ed6c40717896553511f07fbdb69b47e25cf61376f027dfd12ecd5fe81695ae2a7000768910a3866797acdbc0ef7afd73d9430e8f81327e501091471290ce4e59b104297247589b26dadcd4071343a6b381d824cb7b42d35df20b30ec5921ad45641ba6ed62bb51e0e954ab4bf3cc6eb83515d39e29d5645f82829d04433323836d593a9368ca5b572fd23a8c98be029ab089a28f6ce12cee9db97c16d1b0b50554b8a090c85e09a3d94fdcea7bf7a66907e55f03a699afc65d4775f0a269c777977e5effd7bcf5a7d2efc965d0d43d5352e367c53245f7707aa6e07687d598c5b73d367a23940223582da9e62f97fae53ac2ebe22c1dac615fdcfe6268eb559dfd277fd5339e74f5e9be70633d6081dc71776e6bda8a34463f8b1f2aaf53824fb8ac1a97ce0c4ab6fe105c3c8fe46c8a216823afac1dcc9834cc4507230fd77a94cb6fbbf5388100027eaf716298944ffbaea07a2157b49f1679dd0ec36ff71cf04091dd6de178e23738ea1566cbadd0d379c26f51abea16431a7e72425f574a9261bb1e18ddb87fa29100db70d77fa7f3c1e24a73b6f32f4ee3e904abfbb9a27bc700128a9000c781ce6931f905df1b510799a291cc0c78156e2046ffde04283f7f0d3b173c769df1decb521d81ceaf60cbb99a650d57cf7d6a5f89ce13b74cd55534f55716417a3a5e300a07206825081d70afd17b037319e119deb89733a7b7da4e6b453256c1140aa17d7963cf15945cc68f507fa1aab53ebd69515915ce4946357c2583ab8f88d3404e058e4902bad948e7dbe83b29b76cd54a2f75359a4af83d471e3f77a7bafa12746abb8e9b1b0e3ab5ac147cec356b4490e2aea80b94fcbf24ef49bdbf8dbffe94d427450055833183ca45a6eb0382998fe4b6257b89c4621012ac7b375a244ebaa4c902aa1452747201064640f95947ac14e60e75e970dd347d6651344861f8d973bfb8c05d737de01187e714074a48f77d332b76caf373e695b7aa8d74b0773e4ef103ed0c44434c2ca7873b2c7bf77464f79bf26552b5c076b628f5eb73459a58ec99bb1440dc8a53e2b380f8df117ef12e0f1ae1a2e00ca557f13eca771b9c98969040678a33df014a4cfdf74819c1c3cade75276d75cd08b1fa66fd9680c7ee8eaf76b55ccb3e5a1b147df419c079a035ebf0690aefa9ca01ca8c2a2659d88085fe118b41b8eb1c87a4c4cb49ae5846808a614ef1588efafadf155876d142da0700e5a8c44118c62296940c2cb819a42c499050a3de8d83faf6842d419284f860d330c239322dd863484528035ad50ef4adee3dbbfadb0bc5c5cdb9bc42c0363eba929e3203db6e047904ede891e24249631b61d4a0e575fb958be9842a352ae3235228a5a4d4077a4e10dac8b2b0cbc0b2fae23aea411ed189e48a7a8637e2de9303af489008bcb24e0abc812c','sync','ak',0,0,X'ec6e682433ba2e89a300f211303359809cf1a198','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(3,540009246.37129604816,540009246.37129604816,X'3c585604e87f855973731fea83e21fab9392d2fc',X'5dd8ad384c6356517e17af4755efbfbfdab3ace6',NULL,1,1,1,X'c150fb6a2a8c2419b9e96e7f7e5bd32b944108a8',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000002814bf69fed3af30c35a1301e831c31fdb981a5969b9b5fee18ff6cee5c76e8cffffffffffffffff74d317c525ec4735c9709d08f6385f62e3302c1f42324514df4b46a21049e2c0075a65913de66d463cc9eafbfb6545b94ee7b94048be87013f0331b1bcd2c6eaf2e3caecae22a3a09652c8195ea666d609a1fec92821f308b3dfa76ec7b226c4ff68177fb1dba75310142eaa386e85b143bb1311cceac9783c7b35d77cce4c472a938acd9dea9f002d5f249a1f998876ff94c7d2b89a5aa03f10028c639e0285ad82406e67ff38a0c7932bc0825b6c8e258a0ee4df5f1da8e08bde9a5938f747cd6d7805896b51dac95b480cc5b9b12d6c3278a767ae3ac1e811a781d74102b352274f755f3beea8556ae6f2ab876c0b966ad3d88cd6f12e86472949fee19bb6bf252bd1b58db1c2d0fc7b42fe2e57e8e51565a5278cc821694b780b6b60370c48daa99ed393e9e224173f526e9cde2160803c42bbf4b5743a261e95044d3ac7f4261ce89b847a59f6a1d16a2996e1cabecc4b97a5202905175295a557b8ecdcec70a1aea2527b7d14c8b6a8d3e881bc2119d65156fecc3e497bc1dfbfc7bca7727608e6c5e89e568ad70b43e416e2e7ec374006fa127281321fe06939fd885399d36d9d9a068d566df26254825d9172dfc36eb6c258728af9a0659080826e5a762f2ff9800936a92623bf5bc9f39fd32a99fd942df59afa887444d6fc8def7f8fe51b2e5f8827106a875196337fafff81607339aba2b735d5213c34b011f2cfe117f35b0ecb012507ceb5090ccd5b0e1900baa591948ceb2913bac43e1d98302b03db3ecfd821ddd67717b8fe1664ce40f9e4f9d2b780533ac26ac0247c874329344e6dad9004c8a6c61d48028a9e6a21d6b8e0a823c795ada2a00193fd78a412b0b4ddad3f02d1b25735720b97206e40e77bff94cad4f21046873813126d189e70756391f1e9dc9bcd21be7d3fb41360aed37e691efb29e80e10e12f40e41530354ac8b9b5397fbddfb4410ca607141e64c369b9502ec8f5c4ad64c05dfbf6c17d2151cab569aa187068497293725e03f43fcf156f3945a04579876ad03512475c8c908d597cf46229a4ec159948ab0fb566015aec0f86de2dcc8b00b368f49fa00c465bc0926e00f07e8ae7d89f2eb26df2fb549a276fae2850b9185fc194af4407bba1aea01cba802cdb23df59080a8c92e5e08dadab57233bac20168e4373c4d6f71a52e63b1c7d60085327a6058957457ef8163a313dffe83e0aa19a04b98ed119dc5e3724edd21d27d0180c9cebf638299e934240c89593a90e5107aa528079d043dd2849b588cd39a81a1fdad4515a02a430c52b36a7b85244b16119f0f94174b43d11a21513a25d235fc621a58aebc0fb4cf58950f3e35af43b0a1ea9a1d15741b053ff12d34beb1fbe45e46430875b50071cd2c14978af95550a1ef5fd5b80c5d81c7a2060691688bc3df0df982baa16a0a3dff01c245c826ea7418c18d0cb583746fd7a85771e622b36c2155c247a1cdf6dc66e03f2d72d2cc4fdd1fe538ae33482beae52acdd02b2d1cdbf2eb45ca5e2e89097d0a798500d1836fbdf2334c693aa5b5bd4bbfb74e5981948268f5cbf7f5c0d57d75a9ae1d66e640571034f78','sync','ak',0,0,X'26f896467e5b2b947c042f98916b41e11499d49c','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(4,540009246.39969503878,540009246.39969503878,X'3c585604e87f855973731fea83e21fab9392d2fc',X'f804b06b15c1ed1c561a3310eb36ffc10e88cde4',NULL,1,1,1,X'9d2647ea7ee5c3a92fd7864a1c1ab436daa9ebd2',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000c6bbbc21cb16083b7d3e2322efa3db4259177597bc364d0825ae7bc95d55db2affffffffffffffff74e7802d9adea9e03160a3b608e9f3ad921cd130ba441f91a713b23c028261e15a0d0c53965828ac49e0173a5bafe4237bdf039c145633cca616805ff783cc30634717fe850fa9130a1a380d275611d144a19ad9aa92117be49fd25008187fb030bd80b7544d029f558f0dd98fcfd5a493411d7ad50dcc5f001333ae3447ada8d20dc96ebcadba1cf1e1e586f0ddf969bdfde7acbdfecbe0049e4bd825c1fa7d965faf6259767e273de4fd42e989194f7f41df999008b6a7daf8527c720325ed59a298b3948dc8d7888e58c7890c760ba6b813e9c5ca040816c383eb7f19ff8f9923b073e4bae0709f61135690c82d3b4c5c08194ac2bc1483c595c5b0df674cf2a6fdaf9d37809577286044a535a48a0bc36711fa17a6cf019baca5dbc0c7755c27ac205445a2032e624674d73df0dfa50f0eebfc2b5c0e80ecc2c27f392b9633d7651094419533a7e83f1b5c5323aa0d1d3cdb5122cff3de052bfec503c7107c8a6f94389310790073b8b7a89b355583ff07a1fe99c302a9262120a0c153e130f4be462d08c9ebe07ffeba2faf41821974a5f3aa7162d4f4866e5a5b50e49b3f27a7c4b18d1903b2625b0e98ae3651ca69906c2da2c974a9bd2f0ba43c0bc43330abcca2c666b49e51e66d3b63bf6100843bd1e44ce2f16251d4dbe8ab7753602aabf3a32d3b61208e7726ec3d303ff05aee7f4d4826545f950d75fb1b5bca86d65966a68373d5d1e8cb4df16b8a3dcf9f63b904a7d30e21a624d4639e067293c596bfa178cb7ddc7d196e08153a6cd33886b91da870df7705d124e11418b98046e1afd2caa143429e37f6624b3bf97df8de7a7d535928bd08b115bf8e6b97b035c0b31c72c400601d78fde0f982e2e7473fc53dc203843042c86b43f0cb5db0c5b45a9b475cfb6b231f26f01bfd9642e7d463cbe1a9f4641de496d2e75092756274cb7d2bb4ec35aac72fc77db33639c6126f0632d5ca8d68b84e9dba010fd866f67f90f9601f2f0e61f7cd303b4e3ed27b97dfb8aaaa45cb2b9a64b3895966c5354e64b7ff178ec95eb1537290823369c83900b36d8425d9b978992485694322637290ebac932323f0d6a0dc984168551cf4e345ab4b7b4cafd5635bc31f7db5bcc338d79dbcab26e12c40f4c6bf6c2c4a1165cc1d7e757e05c058dfe505ba4e4912381e8cea4846460f4c48b32254da6c243f5d88c5a7eb9e3588194e4ac09277ffc83cbd71de087d2e9a11683fa71fa5e56fa0677ce873262c396c0edabebbc68e089236e47d96db930d81728815c9bf0d2380a86dc7960f629c32d7be1c0db60b74492c8c14b980960bef1abf2748370834b0eab98b88ad75338e942fa30433d03ed2de645be843acc0556ea4904e6c57073aa131588302535bb269868b122fe324ef51634c8293969b49a1f9a73a2146d30ef43f4bf051f36e06d98bf25bcd99c720b5442994ba9f4388d93420e1d6fb0a33ed639547af09db4a8cee8ccc056778f5273956d1c1e38eee15e558f17062f2b87689f178e5d59d63849fe173b68bcb015c45a53639a2163d12a0bc2b0f8fa22314214ff3011e7ac45c68475dd47c3ca8','sync','ak',0,0,X'6bf3cda6ec4d6a0ea59a3d9e79b1f39f9873c381','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(5,540009246.42938804625,540009246.42938804625,X'3c585604e87f855973731fea83e21fab9392d2fc',X'018dd86054c8c7ffc3c08d3138504c7d9c240b16',NULL,1,1,1,X'29c843d85c52ffca384eabd2b73a1dd4e16ff128',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000f292712363b137d0d0fcbff2c232e0add96e07840e5908d303adde064c330a4dffffffffffffffff7503bfed2da36a72d24b32fd863b120e8bb29f6d13d441854af23a438e00987c7c69457862e31e51e783f2e031a617ab17dbb044702ad93720ed91038112c33f6241080477cf003302fbbc1150b89868b6d104c54dcf34f4aaf83aec5e795a7c17d835bfb42c25e5c1e9bb7ddd6f191be1274e9029470a58de22b0e61c8236316af8698043d2deabb52f99445944f93c47ef556962c15216824bb78ffb21a8ba2701b9fa2894c2771ce0491f573147473f2f7dded38b5cf183f974e95bf5a81671c1552495bb52a0017f39c9199626cd6e6aba066cf77341742d5f7190beeff114899ff869a1ecb91b5fddee5043b4ba43c9c9e96f9dfec9cd2b1c0c80be51e26efd83a0433322a590425ccf20c03e8fed93ce425af27c7130b58db4a3c9cb818808fcc4b615c8945c671694f6c5daed7abff2f1cfacb922b774b8ab3c171b5dd62121aed934bf62aa0988877a108f3858cf768fcba4e835dff71c1826904580ad50dec3d99ab56170a2997484994a6697cd28a26a94323cdd6eacc336fb5bb850d2783ab1b0219160db933ced5c9f3991ae547665ce71d9fe3d1182591c35e81f22d697b59afe9111a3e4eb93ef0a84c402b97439f08016d5b95dcf7d70f3f5ee58bb5a59c55dff944d974c000764a49773579c082fdaa9cbd9808120a867ca2e8e0b7fd290b6183e2ca4389e056f9263c5858c923bd3ac3982b83f0b229425352cadbcbd00f066458c8bd13c5afdb90dc7ee85af206e1c014a13d0ae150bea96cae93c07a9bc093a912db59ea4341cfeb47d7183ff7bfb67627db00a98efafe091a90c318da65bbaa81bd644dc25a32185cd6450a5df0c85e528e46d6c93b05edd5500c7722e019093afb366d451f342cf341b44afa87d4ec96da09cf1aa2c0bfb4bb0105f297de407af9483be7bf7afbac4a22b2f05b0dc8e1355111d4745835c4f9b598dadebbd08d63f466c6a1a1a6e97d6ca614523b219ffe52498a806e981685adbad37d67e5dccb22a1e8a2cb3bb4386837455126e5bbc3e465186775c8e67e3e4b2b2654478b1db8ffd6c08b25dd03f8d4393cd7a53e01d54699180d01e6705757bad6a66b79739ec76ac3fa0efc1894727dbc1e35c68c5cae071daa35ed482cbb14c7b02557caae7dd8d7fbe0a5315347f3fc7674207e2063955768f1923966a91fdc621d19b41218a9f71b066c69222bdb9ec192bc0003377293d87460943cd17760da4082d29c0e7b80057f8fcc5d92a5171405a44200368cc43d3abeb6d15de97b03276c8e34c91139d89c901b07d6b19d8eaef7a078fdb5a37c9b24cbf898d0e2f7d015ff3547893e67821af6061dbf923c250c8906666fb23ece8db12dc4280590bf7c55f9ff3c31c583b4ae9d053d856063143d44acf77b06c4857abbc16a8f6c9fa7377ccd8b7f00a9f96fe2122e52fe33a19bfe3d66812d32945552b244672a1067e2c9123f6f732247dbd16215d77ae6e5ee851eb338fe70cb27faa78297ff648c0e8d906945a5f34e61b656b6eceb1bb27cdc1c550ac2b158f22d17f46e5aedb14e308d1aa184f7418b828ff3b44bd3fe52f70574214e8eb9f715065a3','sync','ak',0,0,X'5006f57e748dcd926d86fea7e31d8b9f8c0244ef','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(6,540009246.47465705871,540009246.47465705871,X'3c585604e87f855973731fea83e21fab9392d2fc',X'6bb46c6a660006ace3a0dd504e9f63f59975e1b1',NULL,1,1,1,X'03edbbcad1ffe196e6b840c412501beecab97f98',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000921cea45b77fe548e229bdc4406ea86bb035a5dd1254e5aaf49f86df83ce70d8ffffffffffffffff86943b0296919559b7eeab90141e12db8cf64711a3834b069dd987fd42ba4e6873e807406eb3be7e0481cede80717f97e9f007bf2af8010170f601e09f8c24fb39c02b97d5da9473507114d4c5c01db4d99496106937deffa73825486eded41b1388ef89650209dc841b07f53d8768f5aa8526c91f34772250e35247bfbb0d96c8dae75f7442b484bb72a145f719a1ffa6a87c2010815b8cad84faf11eca3fcad27ee41e77adabdadb8527b2f0cf77f078c3a87751a14b6d92c453bf5a57a882480794fb978ba2568a4ed864c97c012999ab7a2ba547f796d6d825b5b465bde443d660fb102d9831c62cd3ef59cf6e612d52718197511b1e548ec25ae65abe560b1d9fea2f25e15c36d48c304db740a3ba18ddcfff4c6d36be068fb8610d04914ffdd70f7d17ec58f8beda6aa7257f65b7b3e2c933d7e13d1c5117c2c212408430abc2254eda4b81d6343c95e0a29cdee3d79fd686d953ae7fe06b34d736fee2a4ca42e7afa037e54299ad2a332871347c874e23b01266f38f217077813b7a387c5d3ea71af302d6e7f2c9375d33d2540b5e61dbb3984c646a4df60d5fec7e3e5dbea40973cefcfacf8b19d4dd6d44f97fe573f3759313b790b97a720a61cdcc01acaaad1488cc0db6c87ea8f39082ee3cbb2a51816428993e8faf2257492fed7f961cb176596786e9919056c4ccc5816f867b8c7cafbdacaeae67bbcc778a3fafc894abe8b2a009e463c83c9f2d2316ccb81e5d5f949f620e204d7e112d642e6185ef81f1a7ee9fece3e8d2843b5c2926f1cb567b57e16fd6e66a7582fa4b70c0472f2a89fe5c29d124adc5b4232fcc257196344369aeb8bd575d03dc25361950ef402b551439700916067717d024b5ba6b54eab960eebdcb9ddd12bb13604a127c2a00ff5d27c73f43220f6baa7e4a5e457065d2b733ec34fb152b1cd7e2dcba7de0d53af572d1b8ec518fc9ec2317bccfcbec0baebdd33e32ddcce199ae3cbc356f020f0781e76400709e8658b2b551b60a2ecca72c92050ef597dea9900822796bb4f842e0e2105f38b28b4883521488b843a8164979237798eb1cd9bedd29d8b1f07b0b10518c7b43e7880cd80ebc1457ed20b29b699c200147b7dde900b48d714e5526b7f7cd982ea79915483009a64ff3be46f66d1c602c44800e72fe17dc902ea4b0166aeb3a73e75dd3a6177ddd7b7444dc581f0066542a7f7f50f8ef75d80fd097346bff3a08dc0672e17ec4031b11169db1269328b5845dbc42dced1a77219ca2f1d5aace201ebce1a643860e29b33e539c469dda3634fd0fd467c89667300ee5f075b0d7be0f5e6f5010b424ad539b77898b994c1e82a85918ed3b7436640363b5032eb44c4cc709ce43175ad8a715f513ddc0387aed61f3d3c5fc600b5f0d51cd5d6d915f296caba8669c251ca4d9c6cbdb62bf51857121256f7d419257b8c72f27e7320a6e6ab54d8919123ee9658c564345588c60b033801226d9e7ca20a380479c0647b74ac7ada676f80100354387fffceabb93ee5571b6dd084f0a1872f7fc30d091ca59f4d08b5529a7d1bcead55f8faa14ed444f5cc3ed48928d9765','sync','ak',0,0,X'3ce68f65039af6401bb7a0e2e0162814367e7822','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(7,540009246.5564240217,540009246.5564240217,X'3c585604e87f855973731fea83e21fab9392d2fc',X'262e1af502bea4f046b08007fbfb3e5469a2dfd5',NULL,1,1,1,X'b48a60c1e64af32847e1ee7193d5b88bc569f9ad',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000ebfd867ce4524712986412b226b31b6856123b1b680c23cd95afc1b8067a39adffffffffffffffffac98d92822c74a5409afbec794ef4ba4669bef490b7ad47f32ba1c74380589a0976bffef0191b1d8d5325739137e751fb1ce24eb802bfb2ed4ab34e5666cd5bf321dc7f09a2d3f3bffb3e068e788915d18b80e9a7f53dbe8a4372a35b1540345940ab2bc73ebff9f856373f078e2f1ea7626b3e596a736506c0eab230f52c6a41c6f520ac9f33e7b577a07982c4b7c07c4854298f14eb79279434eadb9b01422f3eba47fbdfac591a4e5a53bef806069e189aa68e43d599d05d8d1931bcb112af97aecdc09db21a32f6d4cc8ba137b9a13b605b95a7e95bc45df96bcfe58672164d666e6d3ccacdc7b76f12020b78282186d3393384b13fe9ea445b33dd4d11273dc2f00b1e9460729b1d49ab3f03a01bf5fe4433448f38060b6347f8e0077b1b2a451fb107150eb7a242033a185f0aa2074f921f53c162a7d5bac6c7d5be24481cde216140c62c2563ea86082ef5dcc696666357de02f53838e317ac35972e67eeb07ed12139972aee39c5edcef301aa417d4f6f3ba89d9794bd8884f9a567cfedef2b9c288ec4ca7722efedc09b4d41233762a3743617e871085e5b8ee09f05c2d67e7fdd1fb01dda108877227b8e06b865383e0df19dadb35eef0880e5a50a5887c28b884c55176aa12776b2eb22531c50a930c29f74b493147a420eb2a4405086911fd833d89da702d96e02f14e89b77f6d118d222f021a4a7df73e84e39eed95e7d8a4fcf47e590bc5867ca4ca5eec708826eb7e30c3a11a4719e0186cf4b9b1c9467a174196ac42bce8f4b12f493b306293b050ecd61dfb15377ad912ae009df81922ee19b474f565627dc0c53dc11752f4ed8372a55451ff008a20f88ed8cd526b84dbf82f0eb0cd26381438f71fc4deb16188326722e6bcb0152cc8bc4eb7655afbbc14a449275127ce919bcf9a15a909892b1c4a02877a2ea2e5578297b70ea9f1398eed051e79250700215e85558a1d593cfac24c847d99c28b021cf46a070079fe3eacd12673a301e7035d5ff5a0bf28ce20d0b2cb854930dc91930d7e5987df5f915c2996eebe4ad75fce264f618f665d87117a0886a587899da788c2ddf018d6a7312211e57d5aa6a553c7106a37ac8be8a50be41cbb2146220dd321d4a0b1ae880de684b3aae55c5f806f65e0277cd6f476fa4d45698bff992cf837ca940a5ccb2a84e4d565a493c424402e427f0ca89efeab37d731446c8c0acbc75c0d6f9ac1658b2c1227f70fa25309983fc396161c38798ee814087b18d9eea9d098b941c715cfa6f578d4e885afcc8ae5d003f4c99fe10d09db534d6939abd8cfc8e20e24cbd464b07bd12c9111653738c6ceffa329e967bd1bfdc9a61c80e7d223746e136c6318f547a5c01a93387972ace245ab2d61515889f765c375e5c6bc09c67524e5223d61a0e6d27461173c4116acbb91aa1157186e81cc5922de611f4de44a3d45addfec705fa84e589a0044f522b7d8c96e1d9a4d7a0ea2c79d10e51924cf6f7b1151f7e5f84061ca2ee8b31bc37acba2c5f316e0e754e4cd7f2bc6087a0094dc28c06f50fa92de2f4c3c02dc6cf5fc62bb5652221afa9668c63aea141ee','sync','ak',0,0,X'594fa5c4cfcc578b953b01cee110e06fa2f9dc36','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(8,540009246.58500099183,540009246.58500099183,X'3c585604e87f855973731fea83e21fab9392d2fc',X'4bd0fe69c51752bd66e2860cf51e030062b0e32e',NULL,1,1,1,X'95ab20914a5317e37e2d72dc26dd3ce8fc8c39ba',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000a8ad54fee4a485b7ba6611fbc2e1441949c4ec1a9f10352dd49471ecb61d7dd5ffffffffffffffff32980a58e608c9cee1d405977aeafa80a1bfcbfdd79492680e3d9a5f6883dedb8ad6a5c222c1452a9f7d195ea2e5e7b11d3ab09f69cfb27115c079bfb8844a8ce63a7b016ac60e6c1a92f08b2961d1f0008140ef33c92620c105d6831fa610f989f85915a45cd50fd9ca8f570af0f99d58bd697b19479597c4c2a1df709bc235c3680f818c17ab7ad28350d8103386dccabce6d94d98c699282242ebe86acdc777fa96c42734bcfd2ff9aceb0d29c0a9c88a18724768e819878d7ce3d6968001674c4c0f9d180a5e2f7fbefee2ecf406bd582e02a75e1d8f49df8d88d6e661034b87dec6d3217fcf9d426a5640338bb38c159604ca74bdb5aeae0ff1771ad350914b14386b7f4938de3a4952f42ca5919d46bf1c85c6fda568db3b58d1c26dde50f9814e051320082ef3ad7d1b8cd57dcf62d82727b4693a7808c89334c9a0e117973f0eb38b75e9489ee2846f189d6296f2eadd00b730609c944a4610b6d0666ed93e89ce9a6770886db9a845814a5ac149a37c6b09654565047aa5b439cb48823191d6d5f7ac4e7069865770e3f7f779f5f01e9a152258b639b75efce9cf4f86e64584962f4d4851ae6d47349f9c75df08e377d1b623e141202ad448c97598e1a98d83061189b129abe0374fbe52c5fe30495e179c0c64b90653857e61378669d0eda1cd327e1c84362ebe011993583a99de3b390c2c70e0ef373b865a2c42105a0b4e63965dd286022018d95a84263167e63f9840ec4fc0940a467239ed6cc3b63617c155ad5f96251c74fc3d64635c5f249b3fbde672f9327eaf09f0bba2836206f867e4ef7b2d177dd872b55a0d9cfb7a24bc5b2016a115bd512c3898e91e445cb08a023c684f834a3a81482c8d52c7b599720ce8efe3c430a70c24401828eb4c15051a6a5124b30e17fab9dd98917c2f4064bb848e0e0ff904e65c690f2f981c0934729430b9cfaff0c7ffe5fc4d80d5ce9113d1ec61b901e02b6e19ad2d4a2ef77c465bc97ff0c990ddd9cea6ee81a623fc21bf301cbb8a814cb9009329ea77b9cb8688b67f813fd6bebe612760a5a793e9d6c7b13fe2344f3dbd6a8e3b6cb398f7705cf27dd0a47a59fe229038fba98c2edca155f15407b9cffd4db21dbd7a0337d452ed2c7e33b21e3b4bdde58f87f706b574a0b4d1da5b64b89d3e5f86938256872e261e13d5ff3222cb7495a81df3f7c0c34dbf7dfd922c945d0424968a58a3ae55bb8b852d3067f7f4cec5f0f2f3c0318d2298708814c5483274dfe0b71facd4bb0f6f27d012331ae724fa72b440f77a44b027f7d7671ba9f43508a419deed4b2f4cbe3b51aaab4d489b91a2ff5aff3c6152341133c7a2b005e0a60e05a8539c9d3abd5cec5ccfe0b149c9944a85105076721b9757713bcd26322b88c0340912deb5667fe616630df80d2cd11a678dd97abf65455f3bf2bf4f3850c8d3053b958f528a07466413175ff4083c574cbc4db366011a8b8a1a35c37e6e468df282597c6d0e8b79feb44b667608520e51d4871d2ed3732fe85f2d3b38dedd44add4d265a705659733889ecaa724befb6e71271d54b9759847b42a27a5224e26069c0a3451','sync','ak',0,0,X'7af71ab0e26e44708e819d1e85a917324a4c4f25','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(9,540009246.62409603596,540009246.62409603596,X'3c585604e87f855973731fea83e21fab9392d2fc',X'0dc979403e4c0ac4d59fc55b01f01eaa78012f42',NULL,1,1,1,X'39de145b5758fe1fcbed02b5f338c57572c9128c',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000efd9994a52c5a1dcce75d0f442be01e32e44785a5431509d3b2950bbb638fcc9ffffffffffffffff08d888cd3c537fc01f11d9071c2fbfa127d84a83d87f52fbedb45d3a8279cacc39dc523ccd18f88fba71bdc08dde9f8d5f192a4b8db18be713703b26b6d84376b496a19f46aca5648888e5200525184f7f6e1b31b30398f790b075e41ed4f53f2c6196a9b00688042d823e2e11a040fc719a20cffc89b219e6daf65b0a4badbd1958b81248700fd112bf29561e04e897b8f54483f0ce0d1303e0e3784f04ac4c02afb0019f86fd90d41a57cf252bf6dde6ca56ab9b12bbfcd7d73ea7f5084bf3a4a7b319409150fae7c0fb2940e2c492fba94e2899c53939b88b69d97f8c732e82adc83d5ba4c170c454e0687b9a7d885944e94c70b989f2af1591860f779dd929d28cf6e6721cab48eb9a7f9974cfc4595d9fff94322a3cbab861877829db9b247dcedec53f3899e1c8e316485da74dc0ca9e847cc300ab2e06bf1517669f770817c0ba3ab9571eb4cfd406aad5bba4a0e9b9b16f647d36a80f3079df60b171f84fa9e4243b58ecdb757baa83071d7c5f55d1b85c6ade766a9237768303571b97b1ad826a01aa4cd4461fec09831337741eaba1fdf7c566812479a80423645eadda33ab589f419b680c2f0b09399bd01e0d422e0090ec19bb5f162c07a01b381bdd2bf42567a761005abd1b624dfd11ae88037b88a7b5f6d78d536f171318492c6baf605350cc8de078b604256bcb544c76a8afcc80e8d988b278197345747fb620edf0dd12e4e0f2a3ac4440c7da08711509ec1700b4ebe3054e7991dfba7e04c226532afa831778a9cfc69118145caf5068de695ffe3e89b9ebf699c39fba216972bcafaf7aa70361c06ec75b1e95b99dc05af05a2cd4c1396b044dd3e0274b6f443e53211217a0c24e6dadd4983988c7d4435d4678a23410649b08f3fad0e8749f486d7e7ef37f47098c469a665d3c79c6f87f2aefa38150dc921d59f4c06931673b18fa236c6bc1f463452893b5cbb9b6fadab23968962ee1efc0f87b223a3424917440813579257389792cae09df518fea9c773156a77c72921922aea13d20038c15104e50481b0196e57adf3efb9e0d745f57160fc1b9fcc3adfcfc5f32b63b93f3526ff84a277ce64755aef8e0bfb30adba8f7ac3466f6323ccbb464aeb42c7f3d81d87f3a6f6f9e129b6eae770609c82e35377a7b48bc29b6fbc46efa4975a83f6bebb0f6b4ce958db9c84dc60a3515ef205e100dd91cd7cb525b9c0fef8420fda974450a11d40ea3b853c2a311ee371b1f31d15d420c0f5630bdf7732cd77a677fe54f5d28bb091d9b327b2186148416b59c54ce62e6bf232cd33b75516852f09303b84920486b091072f635cef16c0e753c750ae06aa4b89eeb4d8a7db9becbc754459b15a96360763cfb23a84da5970fe4dc8f454d5d0b081459fcfc5d5bef625b9e19b83537b52c6b8ee1d75c9892dd4a052069515957bd8fcaed62856c3d54f892d91ce705e69d4c8d03c3787d31e67b8fabeb093f4e2f88c4b999e61b04b53ecb97b1b4053550bd6655e76c88d5581e88925788cfb2f4c68983f542253cab77f35de221bef39e8756f4b512dea3729733a9cda046973feb9b35175a17349c','sync','ak',0,0,X'9e8592af94c8cbac2f09073b195e90612e9e80db','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(10,540009246.64887404442,540009246.64887404442,X'3c585604e87f855973731fea83e21fab9392d2fc',X'e0238c695e5197661c44e400525566a3b238b704',NULL,1,1,1,X'52d7905d087d8c90f678d08dc95225a110fd7566',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000e65cce4228b2285910a0b006c58d94cfcb829043f41f5ec0e7d71bad2fe8baffffffffffffffffff1d6bffa39e12e66de043dab4a4191a377fc584c3366de16946b5bb02bb9381e16448f7c96b0ebf215ae3ed3c0d22851e997c3672fa8023b033387524c9bd01f6df646aad91edd3d5eb2956152cbc863c25cd6823c6a073363279e0ed65d0fa133e74d1c5037044cd65715ebc4bf215480300adc452faadc93508a47c91bddeda402d88bbe88e67a2d9b14508066233b44c0a3559f73ddb533010a5c448ec6976e89bd02930acfd6f544b7a0e6ab4d9882a8b4c578319b081db2c7410962a0e3fbb3aeff82574193235477c67a4e63072420beea1d5bc7665afa1f2f76a97a13f999f7a2d1d9226b2f83a72347996e7b243760bf58fda4b79046959c61b2d39d5db1316053cf37aad3a8bad735eb54882a7d14c64d382395ed7ba6b9dbb9ef51fec11abe36e8696c8ff6467b87ce24c4e38e662cc4fc3f82eb3090b92f8b2d1c4bb09dc9f554e3ad27109d6e2757a4e44dc3a2c156efc2eeccf37f286c0a7f143815444fafd0912b4ad461fc28cbc825ca84f8d5c68e468837c4c428e68fd4a718874c4604fa314387aec3f89411975a10a4391c92a0ab7a1b22a46c92385b82574770e4de226304ad6ffe21cbb3b7d45d74a771f9b412b6316431177264cf01ccdb568ea7b80c00a8995bad5afe39c71400c88e8bc728aca964caffa28f9a67ad40c7b23fa6e1c19ac72706a3b5c4b6807b41eb63910491d9e5b9b9360d0fde4599c361d20f7e0d4f1ac535fa60be7d5209d28ecfb73a0686c49ccfc9495cb6238b97b4817d46bba40d50bffccf1efe233b4b2a03d0ab2563aadc2880807d620e241fe22361f171c1e5f7b0df1870c45e81c57700f7ab3c89132248cab9fd78439fc14258174f3dd3948673ff9ac4281f2a47170cf6f4dad20bdc382f912cce5d32a066bcbdedf649c04353e21ca089dfeb97c8db9068444b8438aeb3393e646f8e422cdcae9e3073f4d93a5662609755f3aade37c52d996aefcef27566cfde65d86e48aafc4594bfde6552d818c73f311d75c693751644ab40db44c77842ee81af35a0e47d7f906103b12b16cbea2b2f503be56157b02a357318a6f9e27db0146489876baf4f6b57df86501bcba60fb00276422571df9f0c648881b07ed139219125d5422ede2cb7b846c3084029380e54b1e3cb372486ec13848350a7019a7ed54c9b0d1a654a3102ec75f484bc79bba5453b01d1688b860cfec9f2de4adf7be11c19cca69ffcfd0ee6d94446f89cc91d9665f43dc9d8f473e09b60263426bd5f45a80b7d38261216a14355d4365806a58e2ee5f4fc3570519e355a039fc2965b1f50c3a4f874a90fa63bc9fee9b69068cf706ac6f07c6f776d57b9666f885c2c6adca2fcbe4d19a20d5c89c9929659f43873b6f2ce16296710d20f9a703903d82f2b2aca908c7df8c4c73640858528f4991d740314d0f2630d17b8f7bd9dfc33040ebd102fce8976203690232215a5e85e05628a5d74df0914b113ddef4b986aaaf8c2545864027b0dc10d7f20df06bba7b732be31fb92cf1b12599d2aa654ab17a234213b45350ff97769add404600368712d5f40f6640e9f4a1cd43a6dba9dbe8df83ec17','sync','ak',0,0,X'b11a5e4479be7474514b85339907e6ad87474acb','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(11,540009246.67430794238,540009246.67430794238,X'3c585604e87f855973731fea83e21fab9392d2fc',X'8a3c27dd0b49b6a2781f838a22b08adc3ce81161',NULL,1,1,1,X'1ddd508da6d6e9781fda3588051503051b71fef5',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000252c36c18abf3264b71946dcd50957ce931034c00bf70f3e4a02121e99c4ad9cffffffffffffffff997953bb38268436cec229174cef2de61b33c460510ff053c5b7b413ff78efadc966f6afdfa8f4f7185744a11a4d0ef165cc0bd15696076618a296a7a3bdd55b4db8c20a3c12a2ab73daddf98497d0356b7b6eb6ec78dbb4fe67e26a9eda3770930644b038a77bd6aa759391f29c865d9438b2065d2c505da9b35191cba115dddfb2f47304ddf830f8549ed15b2d920895eb1cb3c29218c924f57dd7401c6bfc411d0d93dcafaa0b01da9249b37a04c001f2f2d65bf245ae276f45571ca9d2953826a43d4d65e3952ca42348687c8460a2f4aa835ec2909a6f15c013ac4eea850b157786aa83e17c91bd4600e547e3939403fe3a34575b40b5fdf8cc2f3cacace103bb26da62035065adb6bec536c526fa0fe10c3969fb103438761c934e86bd83e895e714d2f5d26e9469385c6709d15f26f0ef98b0503356bbd2054ed787ee902594d56f5a5a7b530db75e9ac5836ebaa7fcd231f034f7d14e409c744bacc3915456aa2f3e1427d6828f689c555aa37c64fffb56e48f395bec602a4ab6caa8c0e823e0dfd45bd56a284d9f9443069b16572c127fa191591010ce5714b460454ba536d85496c40e749731c2d6081eb9eddf78bd42c4b92bdfa68cece0ec57dcc3c21e67778f110397eb06ba4066fda376d57fc31d0bde24b12c89dbc0d83926770cecc1ba06721730d71b0fd11fa518d8fd6665a770e6d1770b73aa860f21588778f551aa0af79c27fb50c6ead25e1ff863294e33c87d17e524af416a0093abe8a66aaf9beee50485b899124ee897a94d80f11d30e0768488aedd5aeeb123bf70e06052a6493cd5a647c49a935ace80d3244c156f254952b7f6afa2ad725819a11a884d5889cebe2b51d28e5a01ba531818b8d757e556cf59fecb499084c490e78940006a722c74fc7319e9eda569dfaaf5b94aae555d2e74ffcb09024692b5b8496afbbeedb58626c9cb04bda22990a46ecd1ad49b1bbcdead4d48809ea735d5587eed78efbb90ff88c2e6c8bfcf10d86046d1867c7bc7b345e62b084b704bfe528fce33a9210ff89cbff4468861e8ecc8a7513630c25b6b072fbcbc0f5332254ab5dae732b5c0ee0591313a9f172eeb1edebb9915287f5d83c0058e700d1ef58086d77c39b4fdd187ca3fdf0642a9ab57beeaa1b399c7f7ac4eb85aeb0a88418e2891d3835b6e7b30402f1c8a57b08b30c3b70776f48e392a3e28af25ad40a93ac599e63f82cc84e5ecb9dcde3fb8f8454a75fff9ae0b801e57763aeac3ebf4263c545b5ffd6f5bb950bf695c5bba0681227eabc159c7c7669bc7fa7575f20f49b5f9adcb27a874891e4ff68927908ec4d8bd9274606589e3f816b4b150028fb10433e38975b6dbbdeaf4a8de03e8515c90fe880c83700ffc562d9402be28f42cd96874bb6a5ee1893f030e33416ffcdc26e5f261b7847983170882209f80bff41eb8723624eca9ea748af81e190b360a173418630af585c7c9573a1f2c9332cc1fd8893e8d18ab7ae5c27bfee48e430a5d0efccf5806403b523436679bc65fc7957b520c2984c821382763becd2e078e5b245b0f8ef2628817f69eec218c6a9a841921bd95a4','sync','ak',0,0,X'cadd9f1646dc72442cc10fcb357f7f54f270f790','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(12,540009246.70574796198,540009246.70574796198,X'3c585604e87f855973731fea83e21fab9392d2fc',X'99926c00cc6487bad3ffa563ca6959256bdaf622',NULL,1,1,1,X'68b8756a797c8a826b13de6a7a29ebeaff03f40d',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'03000080060000002800000094da37ec2a695d8b8e908460697a45078fc562a4d5e901e4cdecb748b61cc9c2ffffffffffffffff0f78c3c81b036eca6066233142cbd2ecef327235c8b2b1b0105bfa64be9820e197ffec179d246732a35366e417ec3c9e2bbf049a2fe3f40f433915dbb409a429b576a018ad807ea19481e28865ff8abf3e3e78e237df1e13cd30be553c339a4638dc6758917f5c54d017a1753c5c93ebcb8ebceb72f955715555c502922a499591c2ba33165ee3eda901b8f45a911469ffad40faf563323456d6a1e4aaf1b88140e6e20d903f386e9e485ea73b349b97a54a65b8b4a4f873e63b293aa3f9d45ef2c8829a2b4c2ce875205432c4178386f22270df6cc34cde1a86970cd0e9d7587105f1c33fe4b0007a5c358f0c451a296eeffe53f4cf385c2d36f8915b94c91d2ebd8480211d6cdfe03e61e60bf276001a16be472d2b652d87f4f9abdfff8df6ebfa729b5cb3b1e0e52dac4f4b3a671d0cce46f08ad35d2b3531aa9daf84a7d3b77e7cecace6a6dc671fff038f0b8083b08b6098a1363a59b7b681b304e06d18a4e2abcf441c31ebcf5327e3ed27ee391cbe1e6c1caec6344c7eb9552f4727e0c28b1172d15d915242f0ee7d85576a1f9ab2ff67eae65389fc538d0bff99e3eba958a452b6921ef66287b102f9996ce9f1b399ce1bdd380b2c5b1187562af1f977b6a018a2cd96e5ac6a02ea4d400f1838835825a27c175dc19726240226ad93a121d849029b1570a43ce762e8dc58b5c36b924a23100c9ac2d8745a2f06679e12d13de76d25a92b4d0f2c4e1814ab32932d03837969fa9199e587bfb63cfc4794eaca66374d30cd2a59e154960e9c2ff31ef6eb103912b63510efb96f91648ed07ca21fdac297d7729e6bbfbeb3ef347d47872cc0a0b5ec6a3af3a49a926009e376e8916086464b2a17d7004bff908edebbbafb7d30347a789b1fe8f89c6a310769c5c322553c24cbbfcd616d06137e62b4e16957a9260ec0ac132d1d9d56881a3660172f3320641e55d1f9332d3bf02f9ace90eff66108e7a0489566d65e5996fc57084a23949b5f3ea4446645265ac7b66f2461653622b16001205cdcc1e171eef71856a5f210a1d3543366df16dd3b93406caa5673eb1254974f94fdfdbb04a88e5ec4c18206a11df909a60d9777a5a0ea8951aa0eda0e1c911530776aee91a404c7b8f00159c2f1e9aed4f6f7098daac0a2e44129a2ce7c019385c8a63518e58bfc3fa9c25009b63fd045b748d9f3cc7bd61e052f6bb10554378b0d7b33235a5aafa0ff367cbcee0a51e3c258560aedd39edde4f4013acf5b82270f98b498c91886ff36d99ac44aedb539481889f39a055b9097d726f7f6bd7522c2d3e0f157f4ceff80019d08d196ebf89eef006889a0f6e95c445ecc6999540230ec27b4faee9a5495fe0158e1bdb1e0f953644611b1aa872baae09920c433de0ad3c54ebb16463a4f13be9aeb513b24bcbf88327edb2e6211ac3b29152c894ff75cfcdce4323d75de0148d764bcd4ce81651a42ba18db1b98f5e08702ef5dc144397f3f45b766b967f80ad55cd26915d83bd332ed32993d095bc48725436a6a21f37bf2a431f920372095410b3708d88c05c185a0be95dd4b36041f6a08e3631401326e1571a7db267b','sync','ak',0,0,X'2331cdb16e45bd3843d864c67d0d4a2393884354','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(13,540009246.73491597174,540009246.73491597174,X'3c585604e87f855973731fea83e21fab9392d2fc',X'1cd61447d253b48953bc8aa52d3f64dee114ca08',NULL,1,1,1,X'94f5e9aa2bfc33247255010863960c302c01bd5c',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'03000080060000002800000070a5634ad60486ba094347e63156dbe1059a7d9b65bbf824f33d2978da956a1bffffffffffffffff9f9f96fc298ea78aa9de2b6e43c00e21f05793f4c8b16e52c4625233087a3d33dc900e08383e79a9061871b833c61fe3c232de9f029e11667f01f9c3ee7a4c7c2c45e00d4d82c4e0c75748981f0ba943ad6a9d9729deefd5abae0a413e4db7a22caadc9233fbfb2acb2c76ff1511d0f60fec3aaa45e65c5ec6ba273dc9cacccd144b1cbef951780c74be134b39673db9f4966280e007d5db7e2a9aee2b5def9b3be4253a9073a3676ac581cfbc4c33ce926204ea20085d099767b4a289a8222438d051bd85ef88f076bb7f82d8313f94952d5e2904f500776042ce5b62905ecd52e4089e9b4c452c033eca496453a1a6e48569a33490101adf95cacd509af108ffef97626503c8dcf51ee4045370d07b21febe23c5537783cce6bfd426457bd1fe942d8432979f4d8d2321f3274c1935956511ce54bedc9787a813c8f210610433b9e366b66794897e58f1fdde488cd5720de6a0a95020d538167cc386477779527c18fd8f33f632b348747ba17eb28d49cb9a8cdc14cee5a35f67682724a45271965774673a177c3f25596df5916331a8dd218d2428e07e9003b6f6252aeec4b1ebdc3139e629012e0d7d5292cd0d4a8431a847d2043315064f9f12e4499ce656346bcf4994fd6864915e88ad0bfabf4b930cdf8d295c75eb1ce3118906b4cd81eb8cbe6833d92ef8dfb2bb98237e47dacf23a2e9ba32fd92abaef3338410eb9772356f8cf2fb0c5c4612815ef04f62ca7043bfae05b532198135d7e24724be3f0910689af52227360a1d65e30e90e798049dda58662f5483424dd244ecbf42c40368d1c1eb655ab04fd88043087e14e6808228a3384b75faccdf77a585319837095e7d261f1b8346915157ff89503c0ecd3b3ffeb7f765ea2ceb77221d11b49ce85eb6f318a9119bb5cb00f6f7a6ab2809a86789a3ff10deb0fe181aff5f0832ba9f372392ce6c29f21642386caf615e4d2fad860fb995bd0100b65db4cb883f67ec7d7f497d207c01991f3faad6b9e9efecf2f6984ba47e51f9768f326db93cadf092e21b8a3b89dce4bcf891b5af9558c50313b428772ee48c6c2398b204ed2587ebb9366907d1d72d88014b1621143d9b25c4afb540b1f04450cc04200a300cbc9ce81a0c73fbf033d601790b93d5f5691c2124d0a9fdb852b373ec2be84b8cefd732a38d75162006e6ac1c96def556c694378b79fb29a9de5767db6059f58f20c2ba26277891f2762aa676b4ad61c266e7c450bc1ca49cb7a654e128733e0d7ff8b433cf4d3c89e26dd183f85882deceaad655ba09653dc2588cce367d3fc2ebab2228e3f57e36c05eaf125e47a5641cfbd30398591b314af327e3966e5428e1e2f41ba45f6b86560a863cefcdd5da288e0dc455d66812b8481ab6bee2d63a9ddfaae46441c329ed00a4bc0a48fa6d13790384b716c8661339f455280982abd7135def86649829b3f6cc9916311c07ac0667b6af66ceae27a2dcb0d83b7c7caeae84e33a2ee0ce7dd1ddef2e79d9ecc2af17c19dd48cb4d8c6b836f37892893576d7f9498c5c057053cf5fca3cbcd4c988c4b8f2d80f96188c4283c4e760348134c78c83','sync','ak',0,0,X'3cc443ced2bf56033659abba66111a35d49f8909','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(14,540009246.79443299768,540009246.79443299768,X'3c585604e87f855973731fea83e21fab9392d2fc',X'd6d71e32ac73fbfce32b8ecb609562ffbec8c808',NULL,1,1,1,X'b00e2051154eb453baf26feabe2950ea8accadc0',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000ce7c7cadd473c790759959afc4fc014f9218eaf3b59b026d2af65c8a2f6df0d6ffffffffffffffffd8f7ad4b6be5d80e872954a61edb4bc118857de425f7f464f69c91caa411cc563c47ab511ebf639eb87b37944e0f5200d9b9c22ededb8617fb9a57c1be6a706a790f0ad145c759070ca24577f9389d592465e9c5fb4b348efdc9d0b0b5a043a2a388afd28f6c0a5053d9ab4a81e33aa906f46cc691ccf80ad9306adf6574b68a0ec2cc6545448a092b8e1920f0fbd01d1008b0430306e77485fe5e7d5ccab2e28b1ac4311f9009601ab451fc7498fcc2a7dfa6f4fecfa92c0f44968ad4c69eb9bfac39215de653c6ed8f764f86349f9893383f41b733c025bea01ae74c8e78ec9ac9fb15d9e061e1830f8860436dde2efe75000a42eadfba4d555270fa24c37c29b7ff416a1a001c7c9ccd5f0fc709a9906351f81008a182f4ff740bae00e74d1869cac785889d4dd34208bbdd16ab7be1c38e615743c023db2dbdcc1be06b6b79adc2c42e4223fec7275733c51226c70315b0fabd54cedc14e2612f80a4dba4824fed54a5a04363e333ec3d5af27505e5afa1d9d96fcbf57391ca67da157b5c21846ef0ec97fe2669b72d534606551a8bc44a799478a5efad61b224173000a1a773013114a8bacd5f2393dd72f40c3a8ac03e067a9c64639069df8a1becc81b379c93624cd7c3e579287757dfae5553ef31e638fa8e315adf6284c8077e6361bdeef99f73f89e12a7d492e33ada87725edb0c2c0c24e49ceabd61372519e6ffb389f51d01b3654d9d47aacba3b7e30d465e3cd87ff4f4896cf9cb3d5530417c80367f2a457fead9d38af826517576957cb0de56b946ddbe09a9b797639090435d403f1051eef6bd3f2da8f2f659971eea86d00eb84f5a89231acd741c531e228a3a5fbcddde0248d893aa59cf1d809bc92f16721330c683173a4c4e50d73b80904316bec24cf46d5e00327dc61c2bfb609444aa8e0bcf937e9c0d585d917e70208653a9b20186ae057610bd41748f9fc75df0c56304466301d610b3c58bceb7164cf144bd521658bf34bd099e957850cab44b3d765952b4ea9051df32e023946896b3be627f81b8bf9e357ba90167a535b5503b9e7eca7a9540bf73573b19889a86d58e8f5218c70eabafebc0e4ee6de896f4af1178cd209762bfd3aaf6cb4ccf9a37b0948e670776f7c352e8e01e3c039b3ceae1a236998b166273322b3bb5884a8262f4b533fccb77b229a4605a8dcb7c3b5992c589d113f9d431fb9356fa9f073e6f96f4b9c00cbb56d34b6c09c9e9067c23038d0d86ae555e86fc87c7570b4d4ced4a4be205eb9107a04fbca047d0abf6c811a42431b943d49d0d5a2df83e8904116e1e0b316c3ea2b47018e7b337c80f57ccf9f841502e5564f69d7ce0f5b1900b513c2e072901b61980420529e02aa10d5c8e84f05711baf4dc095a79588fd336bae05abd054ac5898745a6460359d6e45139c8d1aaa3cc019891b03c66845ae8f6591b7cc8d8d64f0efdf75f2c935081d6f51d2b70ee0bc88dbef7f3457d40b8794cd48704786554e94d2d5c7d9e6edff977cdb4da2d31a8416ff2a1bbcdca177d6b365b8d1dd5bca569b8ada36abecf3fd5bcf43a559834e69970d09cee6d6eea4c','sync','ak',0,0,X'ec376cffefd33a8990c84e35e5f926cd2e90e9cc','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(15,540009246.87818598747,540009246.87818598747,X'3c585604e87f855973731fea83e21fab9392d2fc',X'de2e183ef552d8b9b32534d4d438f537da3997e7',NULL,1,1,1,X'e9d5b00c90767132e38bf7b69f4bd5bd34c4f3e9',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'03000080060000002800000012e00a3c32c30bf8286d63a9171e05b0998f03c0d0214e825a160eb684be8f8affffffffffffffff98db3b56e2efc9be0d3c63feed615842a7b7093ec6d8cd7205bd930940ef5ac11ddd9fff55f27aefa4f8a89304887615e7b0e65e5edef868af3ec53d5e9b88820de08361e4a42fe3c58f40fc3fd02d424ba984593f92ebe451ca54dc44de7b09589e8c386efb6d9ffd32cff2efa8ab91260e1cad30ce00544444dff46df7ca238817c40d0ed219cbf32daabb854420ddbaedc0ff59a94c496a3182dd6669cf1281c2ee600356948bc0765a1c73d869a1138bb453b3862ced8d0e75bfb6e9dcd4cb78a3c87531eca102b3295237e8152d50e5e746cc9e17bf5adaa4eff62b59b013cfc32d15bb177f81dfd297992fe6206907cb5b6d3bbd070f169804a65a24a23b7607e10acd6a03b598fed5a22ba824f11730f1b1a28e6484e937855f496a960171c471b0e9911427127be475f0c7d2b3ff1711a934890e56db9a8e6a0e10b41a43b472f4e96f789c8e6cd5275bfa7a4b4f186626b45d597b66d7c57ef418765a749ac36b196983866870ca30c4413e5b316cb89fbcaecc649c41cb93482c7eb268a87ceb61cbe6a809dc9cd024593fdca7bea494d56d0802d3f1ec6d1a286a2a23cfaf913e921785162692d3b0ecf4ff743d18bffb564370340e0d02722e4e54d475878adfcb50ca0e0c60a05af809dc9b1f9a2eda2c9fd7b198c2f92f9af4380bfa5062b6bfba941405c9081cce03cfe4bf0f3ab6c6cbb2de68c7fe31df6003537bb8088f620cdc36612c470c63c1494da4324acc8330c66c336ef5b64e75e00fe590a526f679711070f42ebf5f0e4731155b4f8a5adf2eb54ffa57a2f963c71ece7250b961a186f5b7402675ff0c043b7b845b970260064f91533ef7c667276eead846eb3edfc910bed2dabe6131e5d666ed059b08ea9d588b4618967ec7ec6fe7e5bbe75f2e004e016b8d5513457f6828c944f0e7721262207ec0fba8a1c71cbaa96d319d244154d2e089d9f62c5046c5be9a43928f0c492aae51d317635786c9cad2b2e79faad8b9600d2b4d88a87bfe84236d57b8110f0d10ff858e9eb099e7f2d22ae785036dc4f022c86758e2c8608ad2639b10be89cfb04f31aa1487c3974144540c0e17ef79e08ed64da572cec3e39f931b2eb78ecb234d49999499ff2afb80f8d794ba908cc85f4e4a64ebf818a7a76fb231353d8dbbb4b66f18cd507c5dd5982248930e3c43fe49d9c81c2063a808677fb4b22b57f635945e97c434e80e335f25696a8d00bd66ee9eddde08deba16f4481107c94bb102db408744100796cee87d6373ba1fde645183813166061905e25837c24678cffa4eeac8c2826ba94a03480bf7d893a8fae9aa0692f8bdff11e0aa4af0fcb981eccf997291b476ab63245ba42c8f5b19279ffe5cb1c706283b576ce6bb7eda10585077886dd36b7ca9919fa76330901c8c8d0178d0714b294b32feae5f57e8cd56203da19db4198e46e7af7d70c1106a6b19382782719c94c6cc60b6ec4dbea595827dddcb6e4c1753a8a0f9c8980033ecdab4c4cc6e054b126476e2909b3037f70e8ddd9148bc7f1725f7f4cf7d2da45918d0da09119a491ee9f9e7e3b89fb0ee10fa8a9d8d937a5b173d','sync','ak',0,0,X'e51577625cc24d8a92a0d52f0710f23a63ad36d4','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(16,540009246.90006196497,540009246.90006196497,X'3c585604e87f855973731fea83e21fab9392d2fc',X'c727925ff3c0bc23e34770128d8e6e8c888acbfa',NULL,1,1,1,X'f42e53045ad197594ea67e54ebc104ad794f39b5',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000000ec371220d8afc8dc993cb4bbf1f396f9ffc0d60cda6e04ac177550568437cafffffffffffffffff2d1b99be501960d66d6142881d265a9c9f8c3b873cc468404386ff83aceb55b97395db222b1db1d6f18c35380cf0413947cbc19fe2ff83a4add617c637a39ea1d4182226dea74da3edf07d69807c588059caee4cced38a85a74200c932cf8c7983c2ae16ff442702d031b9c9a311964f949805e67110c948d61b51a49a70ea0b641c8ede38b07c3d837ae099d0d2c503d036204edbd419ac2cdbc8edc2878208cb27238fa9e739d692208bf2c0601dd82e1a80745273a5c79990537c1363888fc4a3a1454b350ba0549e76d08b32c88a3f73888ec3742cfe4e9a77b2872e08709dc03ac3effb15e16c6e4f649e2981df8adbeb903e4dcc870be0101704473bff9e86dd4c31830c5818277ac7bcc37f58a4a74e4013c2c07c4f02f080ba924a41bc6bf77f85b3f9dd0e0cb5a2629b88e3850d7bb45770741440d41c77bb617b6a866de40289da3d9c354f26b46ac2eca03e5650cf38c790450679eed7d5f0b18778ca4536d9b224fd57493979028be627a05485319cefdc381bddc6e5d42e675b07cd8e52e589bbef6e17e99b59d8ea196ef55c31fa559fdd60a0ce3020a2d4df96336845569e97dfcf75240980d925d13e27e0af2fc3af104594d6b29c281599433369c7fea86ea69bbf877f3761abe62f1fad7d201fd9ffaf906f5c3a87e26cb28606469aabb27c1452480dc972765d7ccf3a94ebaf35e77b56ed688f2753851736016d247cd9ea10a3e22232bcf387f9739c2f5f75853a06181885566b662059a346c5f216717d43cff1e2fffcf85314260ac830239a87308151946ea1b9e439336bac8474ec5c03270728493ec3141b29a36b11bbdfe86e6a9900cfedab7611c4f823dd57bc3dc2871bde0d3da2ee284dea18c643a70cbe46b60e5f3180434ab56dd6a25e73ef45174a1f52f3a38d43f160c0ea274306ded203790bd40a8807fa7c31b48d1cabb22e10c9b16290fc1e5cea6703793f3879a44f5e35f09bb6bb3d101f37facf9f4d194f2e60cada58e40ff6b07a067a4f0098eda9caab32894d68f4106e99eaa455c18e75b92b16c080de340bb748ae033b05cf00df5dc07ee80462810eef675a77f1988a5ea0c3a051296746849244a2ee98b92d856737f92bc401ea3dda0137728c25309419568a36e72f1c16290d05339e4e9f75743282aad178c2a2f060f55beda8af053b662226c22a8e41a4e4ac613d4ef1849866db8718d73f89cc2a03ce1cca7038e1b3fd2a80a9e3bee60ae6b7620b75546db19387fa7655049aff44ef29222184790547695bf7e2c8f85b9530605bed662cfe2b4783836deea4172d5b52a9c2fba2845642c19f334a6e47ea632c9f57eb1a648a60169503f7ec865cc20acb0f77ea2b99c1d3636096f7f67a15ce3f76c4acde9366fd1ec87df14665104114418fdcedc247275f2dbe19bd08e1efce078214a2175739e560d6520abfdc32c8cca062158ec14b4e306a0920e7bafb878fb7ac6f169993314f0a0da34447dce108bfaf0f75f08ea302273022981c0517d7714f413c3e237e42f00589a56bb0906a8af684a186f11a6faba38d3b432bfa4a744e920d6959be8f4f28c8','sync','ak',0,0,X'8feda9df7a3732a248294712fa0d545497057d76','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(17,540009246.95946598053,540009246.95946598053,X'3c585604e87f855973731fea83e21fab9392d2fc',X'95c1942ec25cdd1d06cc5c1964fee94fa5c9d034',NULL,1,1,1,X'39c7f4b9ce90d7bf91bc71f072dc98841f12f208',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'03000080060000002800000045f3d0cfef9c4bc8dad0741804555b7be39e7dd41bc6d8ccafb9cf5dacb223b9ffffffffffffffff71f762ca54659c29e922f061122d2037e0c9f302b6792a608fd28b7bc4e86620fa3a3f6cbb8df60f73e1a7927e455611c053f5822723054a7892f14148e6c7f3aebc653b7e76584f6d8d0b6243cd381b2b06b27a2e54eacb7e06ef36c8c30ffc7ea70d76398740da3bfbbfd4bfd0bf0ed97e602773d2f1cee500d2ff9a729ebccd28dd80bcabbf59654f11ca351c55da15a3e1493d43cca94f082b8289d51644916a75c9cdbfa5b1199dd7a0d7a5bcfc6509f4c7624836adb3f043c4da983b7dca4c0959bd55b1af79cafb86e0864ccbf3f15847d89f6e9f05c8a94af180d29ae641a43585ffb71b1cd4ec3e7cf9f1dd6176a0d04258875fab5c70454ca35c47784e7fcc107c4aa62ee08cf244ad9727b18000b59e0224437a7ad0d9fe9176af36fb4ba37a503396a0ed7f81d19fafe4db50a1da71912afdaf0e33ec13f28af1adc5d165ba125a71ec89e13ab035d001920e1f183161faffd06a24a056c4bab384b5902b3d72bdd4c9c32eab467bbaaf74d980144b60391508cedd56107edd965ba709c582193f45a6c805b68e29d4faef6c6a20cf93f27ff1dd516c5b59a607b9ae0ad53951c2bbeee1821eca555876e9288f4515e974e351724d78d53f2df17a6a3cfea8998cecb3a043b0d40aa24977fb3630c5d0f9fd439c86af4a6fcdf483ccf3b1c029d0d0b85e7f3442567fa066de8c79f103bd82bcf84a60804a92084a5866aa4ae4338061dbbfd842c6ae049b9430c2f149b975b9553be18dec3c0997507ba587d241311fd3d7d3e43abe72e0fd4826b0ac29093f0060685653a5087834bcc2296e45597288a34cea196b305685285bad0f3c41330880042cea3fca16858507e14edeee7d3293438e0eb184505599e0cf4701f6143f5003a22e77f4049df964af037e2c08996768e1d4e8716151f3f085786b2b2a27eea0130763c089a039fdcd68accb3fb695de4d1ed6809d035d0b3bc3774c4471c56e393a0d618b89717882a203c0945805e974fd3e88903e8122e700fce2416ed66cb50ae631927986fec2ed57cb73700bd2d5aee8834dd42c6731a4c2068030cb34150f23a385314677253ff26db15ba2648e139d7fff40b1d5170c8c951488146be74b4246e8aa3b1954662e81e346432729f973b2bc60ce2b8f9dfcd535aeabb74a4ce7e95b83050f651c0b0b7dbe75180f4e569389a31afc2d39404a81528aeb06bab88572858ab7ab089748b0f49e1e40a796a997a76b5ac9841b025ab535673925bbab70392056109283a517cc9b66885d2a9f05cd4fb9dc48b226da16da2bb3e5d6fa994dfe66ddbf27843bb95c69d5f619f2f835e5de4a406bdb9bcfef5209380ac49a5ac74dd5e097ca5457fbcf652fa704311aa0cc95718aa12a32c519494ded2e22e585e19f057063fa16b27226b5cc5b419a5946ed864b95f563da507bb5c691d3aa6835e975234c2d5351004b28f761fc257af30fdb64858e01129581043e7979711d06812627a67b01c0c3c0d63977dc6d29513f666f728c65fc2d22042db747bc16e1ebf2f56b5bad81a588d53872e0672eaff67a6c79eb2e0caa65e4af7f00ac3454afd0cb34','sync','ak',0,0,X'cfb198fa5cbf210ba4f4b9aa532921045e6a4c37','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(18,540009247.00499796865,540009247.00499796865,X'3c585604e87f855973731fea83e21fab9392d2fc',X'b018d2c8b2c5e6cc4e5733ee02972e5f1852cfda',NULL,1,1,1,X'28a63458ee8badf52d3a68747c618cba5ffb8a19',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000007b538f0c8b0f1b7b257673fbdefea6625276916d93ea21b49888908f4140d313ffffffffffffffff51dc340e9ee93a6c05d693843483be5481157a35b4007b8de3fa7075c9837f62dc2ab6e44cddf731f06dd1c23069349c9589faf90844f743826db3567f199810bc715cea72f411d9711111f629b5312d283cde3195efae93e19131ce52da52046568403c34b6d384bef1b3baafa5a19f39da16b2906386b30c08dfd84a6fdd2b59c2d719f94c7dd77850353cfc698b9e1e6a012117b07a1a4820b952298e38df0759e568a7be11083230a176e0ce922d07d2ae3fde1e220e4c11aea70da56b4f54133f2198beb928a179990f44e5bf5a88b32a7a3d64f83c0dc14b586d330a022093609a6816cdabc9ffefe3f6330454034617e34fd1090dec042d0810dea915b5b859517976c183459495291c18034f937cc0b0b77f94de3c6a39cf616ac6bde0f8a8d4fe14fe0d87f920ed472ead87ba65da24fb9dfa87a5f10bdc2be270658a3013e358133621d413de486c416bb273403a65bb362c9da609e7a9869ba81e7e0a0aef08cbe02d2cb68761481753145aeb1de6cb6f568a70a30ef77cc14e924f780b7307b0f78ddbb8cc98f674c84853a6ba7f55d17a13b3553a5af09fa2bc83e22fb6d233c54a62e5be62fdf2b9309bfb4a9f563a1538dce21c2c3fbdbfb6e2d50ca722b47ee036504e1f5b51ae598cfe8c1cb662e75ff565a09edfdcc3c5289bc4e054c1132db6473586073701627adc6887e92e242eb7c782a19a1df7f730da1b196c03b75a360f0dc6d598ef8e2a72e187f150939819d654ec6b9fa5c1c8ba276c0afa03992beea44eecfa4256598f8ebb6cfd9a701b293ab795be68f8e29c2c99cee9a6629e74943db0132fb2458cfe99a0a9490fb76fc3494fe6fbbb249993c45f723f7c91f4472744676ad2ce8d91dfb987e106eb878bd5221f1a6157a38649db491ac9b3e6bf5bf637d1d06b85ea88f3da0201cc766b41d08b7ff94512e24b5711f915f7412633b37891de9912dc79a6e9241b994051d69a668cab8b96db8f9aa9ba3e86e822881e49f6e3735c33fa67ae6093d3a7d1c41ebfddb6244e26ac0397f080c3c99f5c86beb549db9fda4f98a94f22967343509ae14250e98aa50b6ce65fe35e9f525e42a0900c2a08c1f4ed33a5d0ec7f70a843fa779eb0e3180b814306b4e247bb6744d3d46ee234dbc77cb196f5ad4f763eab5622791c36820bbcb21b4313baae9f4f3718555faa5cee44461ee906a0fef58a20cec46e81ed4946d022f308b48268e91f430cb5916953364a3236e6279ffbae6de0f84dbbcf4f1b1a1848feec46f847bed0a1b8d32194f3dd2f37173447db983bc42e196a4f8c15e5cd534a1a71957cfa7357699b14eb641e4f1cfb7d04448b68899dc0262c8690041dc19d6a5f915a2c69bb30503b4329a1d439ee7ed79e4bfa2a5dfe7f4db31facf4f40525cde343475a7c56b443d28d16189ac76992f6e26a66d83270a771d2dd3bef353cbaef622495a4830411707c5c7fae13bd132523b055089ce01f914e58eb316d5907cd94a19d7237d5ecd230428dd7311079297ff848a18a0c5bfca1915ddd003540143107ed740bb49b1a3b6e59a564862cdb0d30ab2f949684a89291','sync','ak',0,0,X'00322ab0f66ed08e824b78787d0a5db68d7f3749','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(19,540009247.04253399372,540009247.04253399372,X'3c585604e87f855973731fea83e21fab9392d2fc',X'85f1272c37315b8ef6b3793378efa3d7feaacee5',NULL,1,1,1,X'aea3aa45414620fc26ee5ebedb6adb044e02f224',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000002a26b2b67cdfe6e9a4cd040f4ccd8fb95887df6cce59964ca3434022a69d5908ffffffffffffffff3442b1417d53973c0ebb28fbd87653058ae0dd46a80dcdab52eb0269460263ce8bf95597d5544d6a988a8db929b5daf28174b21f7bd05ee3cd7445c6db8d606fc111ce1515f51696260e2fe771d975a4cb84af400f8a6b592800010fa1679058d0e0549b05e10ea13a45bc1f9ff564f066a2c7093398abd51a7daadc1529c897593f93a0361ca43a51a948f9bf2ddbb92afc2b5557229ed54413c570a5d9d07d4ce0c3ae5a1b384146e67fe0e080cdf0d7b97f8c6b4bd38338e4ad0040f1f2b67bbfda367590f80189df7e8c4bcc7398a7823e8539b2ebf21b0c01e8d7a3d8a646b84f2092f8aa37e79816e5f0e0939b72c56ac9eb07c02b69dee7609f744fa9fd6048b85f59cabb8747904791535f9a87d1e8419aeea6d828c7f2115eb2c1354efe16648e1fddfc026fd6e4b9ee416858d4a3fd744b0d2aba839a58b0891485812dc0bbf3894a3425785d88052ed946077bdfcf2d475e5b897c3ba167d6be56b68e41413a6a8ddae15cb93feb3edb5eeeac671d958a9cc09b7994cfb742a5c5ff8f66c031eb4f28df0f966e6f88c026e37bf955366b1e642627a740cda0aae513e9533db6cc3bca51e033b04992741dab39693d1744e85b67d5d7d111828c3d71aa76797ce912bff8b23ac92871f3d970fd682083f35ce9b63a977b27f2170d0bb8af50b05542c6683475dae9ff559404c5c59f2d46cb08ab09b670d33bd77dc0facad74e24681ab19c8c126f276ad9476ce31f4a40333537776a4ffce9d16fe72e48691fb572723278c563006937a1c52e57a6cfc42871a873bfdae0253660ecffa45d6c88d786d2e77e00d1a7295a442f8a867318024118c7986f34d96dc2ea02496ddec08104efaaf8d87d89bee13f0e3196578ad815856ef2d0a887644f158f4f6a6317a90c77b3948227ed3540f9e1ca7592184a41cb2096291845d1251c57ca73a91814f91c4344bf6aa2e4218fccb107e5c2051cd085228d04ce2fd3f5a20db9cdd59d17b2f553ae85ab467bba484a34efd327b11292f0a37af578f90a001c684990c76d7c0d9b4b3c87435784ee48abb1bb3a22c09de4b6f604ec954e4d1e9e9d0219edad3beb5a5d3eb5e60bba096860c56352be7fa8d5130179a4101375b5623139eaac2c42a5e0780ca432d45794313a051914d269f7383175fb33d44519a44c41b8562b31ad86beba430b633a4c423c9dbb3015e2fc009fa5a096f521177e00e4ed91d668cc4dc0fe843221f90398d786da96700a15b63620c1340b2946e619edc881a688284348c86a4e7fecda9227e5ecfe0f35a5a62532e31eaa73904048baa71aa50908150da1bda73822ece105f29c1e26e134ef2bb5c96cf79d632120159eb68a8ef1f156edc6121d6f231da2f6d94f2b200e6fae16afbd61508a74280c41f3608509556914c88fc9d78661a86fff8c7b812afda974cb82fa5284ddbc03a9c279e053ad4447829f34a5d1bc3e9e6ad0501276ac228fabe9d49479031cfe29f424946dd4539d72a648660b50c43f41ac3e7c9faa2e2a60ad933fbbf923cc0d4940be2936b301bc99e1f8166a4dedd1994939df5eb7669c21aa209d3b07e1','sync','ak',0,0,X'27762b9c292eebc71a0d051fbe3987fb4a711467','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(20,540009247.08044397829,540009247.08044397829,X'3c585604e87f855973731fea83e21fab9392d2fc',X'5d309930ebb5e6a23bd5f273e0196a01b121d601',NULL,1,1,1,X'3118b0467d90e3646a8a0dc0f4109c9be8eb4a5a',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'03000080060000002800000008833cc64694103851bd358d479739ce17f345a6631674bd03d7395673819730ffffffffffffffffb7215b0db81a2e576188e9111d97870382755dbe414c31fd9f98e98a240231c0aeadb71e83fb0b6e6e9b263c5b6dde20e64929cb040ace678018335492f447c55d71c8bd4f56c0b9a65ae23b7f2ab8eaece99d320d5ca2234c9b3c118a0ce3ba6ff24fecb800391f3ef2e3e067c6aa0a6bbd377f0cd1b9ce1e2eefa6d8d60c5b8f47d0f5b58f84f884cee928ae208cef902369d096ce627bbd4e847b74cc511601f267fccee84c6e36b6b6bd3f5d1047a68e6557df3a7d27258e264aab78e8eab360bb48f55114d552d440d566a4f932d3bc573ed5a7dd0e32ff8ae91e5a37c92d994739dfb8c4b5976cc1619c5fcad9528ce32a5d15ccbe5568fcdc47eb791c2d206619a94dd546a5788e61056d62845fe24a9ac594a81b7b3c83e08cd6202cfa016ad688391a6c7a690b507e29abb941eca6a409418ff7cc310e7cf5111afd9765464fb981103b8469c915f4b6c161ad609d3d6304261fd2c2c3dc9ed0eb241aabd987f555e3137f2e44d1ea5ac948ebd7749182af43dfe8bd66739b9de4e00741cfe971491c77bf8554a73eac5d977ffb4ceb7d60ef8ca668e57fd8132744cbf98aab90dba4f223459bc3aac39a3f43f6fc29102b8db5eeadd929e69d8fa50a74fcbf34840da377650b5682b043e0475eab81dd00dde09aaf5879be7dc21011e5f9d8609a8ad8edf45c23337eb82ecabb704e24277def615247587eaa24dcfd98ae6421f62397bb7ca1f8ba15b8a6394bad48387c38eb823d7b7e2e309f34cd54872b4f4ed467943972a24e25df8275f5c81c0756ff17db6e9765df739a7eac287fd54e269522adaef953fa15150f3b0a6ffafdb5aba44103f7e2bf8e77a876caba374e3fa8408eb268e608b0d172524ea14b7c2d878c134e5c5b4bfedd85acda451e73b5f26d05ade767f6b49e6e9576cef285f093f703934ae3f70ad4a7a763dff7f8e7f0a1d94ecd58b4c4bc949c71486f06d8f8ce7992430bcadf269d106ea02b3981c4359ba98f6506863a0cbf5adca2b6b764816e419eadc071d844ac31221606f8e74f5b7539dffb6c447b874a0ed5dda8ecf92247ffa8c19926977ca7e14936afdbf7439ef2482e4d8818b5ef52bd483813f1e2fb017351b09e92f9ae5882c2c2dcf59641fb325250652057255a908f7f77399172dc8fcd1a2ed5a02691bc6271137087e8e259ef3772696ab85e0d2650eab1986d01b37775be7302d1b6dcd60c14c4148567f76c76d9672f6361e08f415cd5baf9bbb0a47eeaa5fdd9cb678b742d0373ee7c672322e03c8d67b5baf3c315d9d080b47763ec8ee895b50b7536c7a276b84678ac55e52faf3701758a598fc4a1627bf4154f10fa516985da47b46f86c2c67a7c1971a1d33ec3da49f973efd97e51673797f94cdf2c82031a3ce44fe4dd712cac9022232f7e0335772906ee5d91547ed4edb68607aa913e69a1d91cc8e42d14917e0cf37bf70ee527e6e4ae3b86bd14ca355bb8d895fe25d7a3f7cbe7f9c43c1b55d8efa6c30e88c624f8dd4d1ae96850b5900923e39a369c781f631759ed82437895e7bca3cb4cd0d0de03697a8c37eb48f6601db22b68d46e4e1e46','sync','ak',0,0,X'9bd9160eae87fac9b111ed46456393c9cdb13e30','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(21,540009247.12179398535,540009247.12179398535,X'3c585604e87f855973731fea83e21fab9392d2fc',X'3ac8effbce88c398e9efa76029d262d3c702afea',NULL,1,1,1,X'd9efd5793aa25b09cf99c63551014c2637b79f7a',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000842ce074d9b389977a96105c788fa19cee9071cd5cecf8369d77fe3a89bead90fffffffffffffffff9e6a045db57f17987dc3c7c8d96d62fc67816fb195abe27138f3ac1290074cb8357fdd6830ec9057979b98ee698322c736748cf67577ae84e4a6bbb059a424ec24aa9ee562a0898aff5eb876b64eced3fe1175a2f01aaf3ceb008e951da84cd723ae77af6ee1510d5a152ccabd1c4977d394e4ef260439672dc054e5acb2baa4bc8f1ddc1df786cda94ccf39beaa46d5d610297b7ba76762a337029f93ad7724cb555c42c5c3988535f71f50a77987a95743e021fd335e640f62eeb9378f71e1d03f50437c7b8053e5f39bd434dd640e495fc9f0d43702867288424e97f247d02a7771faa6a2b3dd58c1a485a1ff0746bddf0e92946998f5bb7e069d6d5399f74007c78d31079283cb00dcb26b6dddfd91429a7baa6fb328cb9fc3b030773494b7506d28a5b77843764d049080ba2d3608bde8ce2356e408711b8dcb988b2afa677dc781acde030f44f45fc8aaa59907cc87a9bbf962fa6cdba1e3bca26e25e130030831803979daabbbc801df335da78e4370c81b10e29f193a55dc448fc78bea090365dce7dc9e37941dd521804cbd8d24126e449f01f1c4a1365c8910cc0ca0739245bb23799e2bf24ff3c1b337f03816a74bb138b1a965a57e032a8ae438035ca17cf27e3e3299e1a63d4fb9a8a64c252e9e37ad58a662739ec959480d3b444ebdb4a7d9ed847c1ebe3083e8a481c301bb45f2124d8c443c2a7d115d839516f0f3f92472d28e5d23fa9c8c3db9bb69a50248d71d9b1926e9cc6ecde20daca22c0cacbd8c61b162e138393890a14b767fd16dce34041e5b6c31668c3126510193c88b1aab157abf0252b3c19ce19f6b3b62eb8d8576015aeac8936e5d6bebd08073d45e0d50362a8a57f5d712b7d76f89e89e86a0c3f806f68d9f6105e1810f55939ba869a451ee89eb4c00b3050035f14a7c78f986e59af37ff4ce221891ab6480347f6cb0b7773838f2b97ea63e2a29939e8ea7c6269782dec2862b1535bf94662e8a01d2b7e2936c0c0927e703decd132f390556e1b0d9ba8f5a8c289c4ecaec69fd7eadbaaca35ebeaf2f16a5bbff9eee1355b612802adf4334635e8e8dd62954e4f9ef39ad09c77ea5f3e21a86b5d618f38a8fbe257581fe35e4e471d06df02157d8c611031c1dec87eb730ed3a251bf0ce227a2c7d2019602ca0c6d9ffad49536001f115b8e5fffb6a7a37909abad6782661b9fcf89a9efc86921d996c9dd62f8efc8ed099effc2ddd19533d689ec13277140982315c8fa588a8ba9af071d9ec613b912504f17af96fc722c5cc21294f1b6b697b5c38c0dfe3a10456f65a0d6949252b3a6b064c59cedb56966a424fb451e919ff57b6b45c4ddcbffceaaa3bc9c3c822fdc2896a05260037e48253b9c44010bbe8a01e33323633ff68f3c822b52ee475efa3d8390994b68c237f6f95dc0d8cf2d57f5b195cca455978812f26d01615b55bd986364703bdae0c1edb955b142b73c7746fb82c7ed145044675618f2a697ff1b64ddc65336b7b8682695283f944068bd920168a48c242454ada236f0e377787d0fa4c73a2c3a466987242f61e529d6a002d3118b7b9c3205510e39fe509b6','sync','ak',0,0,X'd174b86fa2498449ec83f43b3c901ad85d497a03','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(22,540009247.16436302661,540009247.16436302661,X'3c585604e87f855973731fea83e21fab9392d2fc',X'957330d9e82f1403efa5a03d4edecf0c4820a289',NULL,1,1,1,X'a34fe8a5828aa708591faa49ee0f0402483ddaf0',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000384251995b760a5128a43f2c03eb9727c50f8066c5a0175e394012bc49e3f646ffffffffffffffff7d9760b597a1b516992d3037fd2901a926a2d7ac2b188e461af0bc7d0e8455f9d4cecf4b604a753eda7bc6a52bd36f704e1a56e62c15496b0ceeb90791c53e6a1cfd3ac3ea0028883e6e4b5591c4a81d860a6873d26bed7e91622b9f43619390a40eba24a95e26655f3f19fd8d3e254974b6704ae4214d2ba32dd32eb0bc70567262e918ed82af0bbf1a7c1b4526adfc34cb9dd0dc552d5c6dcb779bcc0e77d8639dc89b4482b16814f7a0e3a22bfec66d6468967cc20613e716082f5ccad130e5660eb6aad9836089fcd3ce38d9f9e4e0b1dfae2573354f015abc84de50abea832267239c682889dfdbaed0cf4d33c528fb57c8b21f4d24227b303e21364963ec2e15fbd642d87866479eb89ce1e615672e2d96ec990b2128b9c45c4ebd5a07067a8b8c19e45a4305e4901aa1457289044db4df3e1d71bf130913143608bd82b63dac78a8d2f472063bc13d26946fd0a6246bb696d67f7e66fe1cb22eb387db074cfd8b692f34eae5e2f94f63edec1015e9a32aeb0f359f5f400be20a945545fabe7e6dffb8eaccf90e03ffecfe1bf800f5141ee7e84af4f200b71a62cca9a5f2c5c585a4ba3a0ea749e56e72de9027b683af46fadc4eb6d1d50de3b5a7bbaa1d05fda00a488d9e1fc8a2bc0a774d1c7cbfc94c18f6986f83decf61b393cdc0a9fa9a604200d8af62f5690de6caf4357920cd48ff18107fa525f3b860b34e43b2d1d023e8a6a65ec2b7b7577c42a07b1fa3d5565af7d328399db4c5f82402d63bd5c66a4fcddc44238bb5deaa7ded022e73d491bfae8149c1f1545e1e193bf6d593017b55baf094a5e8486544837cac127ddad0395bcff758aea15f03998364a29e6ba29c2830da8e6a34bdac46afff3846ade81a530f9101bb78ab7503eef1a0d5b5d547e96bc4175699ead89ee711fc68d65cea755560dbc2577cb2417cbf26508ff46ff9c770dc2b791d506731b65abc02f92edfca7fc95a9a6bbb17881d35454aa8ab0e2197a73213387c0e7f2f5bc01c04ec97a0076ddbeb83f8d0e1b81042dd6b8216d517c43393110ff25923de6a44dd517ada7eca4a4e04523ae3bafd0022cf78504b3a74d53ead78fff458f801a474512fc16228417dcc21a65512a65abfc7a0f703fa22fca005f3919329fd3cea9ac6f17808f61a20f59e84830092fb4b93ddf6458d3f2156f2a4e5810eddb2cfdf6a57c9129f77d956a1acc961dc81485b4e088f99d3634431a380b3e68a1e542aed32b2c7987cd0ad6d0b9d177c4e09d4198916710680228666374af619270c5a3111c3f985aeae5d0427633e2f0c602ee362e8721fdd012874f2ebf8cd13486e895a83286309e737c857cf435d5a09638dcb775127b231b4dbf1bfaaf486b06875ee6620e166678c4da4b2e9aa392e6aa384ee2d11574bff5f173176935c032084fc5c49f84adda28a2f0046329bb52d50834ba8dc4a8f727895bf8ac8e12b976ba60f5dfb48d34beb3f55c7860d54982574d9026101d1f913be312cbfb7530a65a5cbc8876a1b25db0d3882c28b04f83ffc53680c17bd3bfd56fe7dc1dcd68a70570bd079464e12e35af57a20f3cee82674','sync','ak',0,0,X'9bf4a29ae10aaece4780711b68632d06b9a439ac','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(23,540009247.18998897077,540009247.18998897077,X'3c585604e87f855973731fea83e21fab9392d2fc',X'710c2658f862c7870b58d8855fba915c1b1bcdc5',NULL,1,1,1,X'9bee8e45100a88deda6685f204309fcb347e367b',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000fef063a3238856a5f2d40ca5ba4b77406a8bc4a1436798c8c46f779c99634104fffffffffffffffff8ed89a8568414a8a56ea9690a8d289dd420eaa91acd9a4806576113d4cd35ba821ba47b30da230a50df303249aa090a0d272a2893811e3c154c5db81a5e72b82a5d4e25adcf8ee1c4e7df92a2b9acdf25f5d430f7875bb5b90f9ca10b4fabc8de7612b8ce1ad7f20c2391fb448951b809b7554c96ac044b96b986e76dbdd4161938241b27d1faba9a622d226e8f43807093a477c2b63f1c0c72c44b1d7b62b83913349acb3f979ec8f5b2aee4f23263725a4361e5a43ba3d15e5f2f04e1db3bc8b091a7b6165c13c7beeef5bcafb9c8b8d986916380ef3f7e246251535f9944da2a737a30ad367bed889b2d48c8dd3174c5addf73050310b4843acafeda10b7c565347bef6715461a2fea5f836f10deaae4f798f726404368342df83164d43b9b840c520cab92834033d22828bc9a4e9d25930b1b979a88b0b188a00e855c7fd3dfd61916fcee50a8372b94782794f085ff2533e47ef78e42e7b1104beadbfacd291504d9d71887e1eed967a2cb9d123e58f8d71e2984bf6d00d233329f2f5e2eeae5e295f648ed6e989c75efe8f8c366b2f8bfe0fbf33646095a561e6f5b73762a2cde6068894b35936b551639986350460245e77e38d2ab44ec8ff22c003cce1e82c83e8849a5c8c869a703d6a79d9b234348cc242e1761cef2a58418a2798c418139cf2ca7c2e4c15233babb0bd60558bd1466096d715537c5ff28808d0f2081405eac186f182a37f837c49c8e454edc340bb58df7d59d41749828a7c742405e8834840c6dbc6b0f9e8610071dca1d4fe385950791865665ed6058825325d4e768a9d4241a5789694b3cd0b5387b18c1ae1aae7bddd74039d657081a40dbe5059fb936c58dd6de71fa24fe12cc361a019d3e978edbeee17249e189e9bf8f3cf810400ad01fa015e01436152c9ce61781822b11be786984357ad39f89d1300454fce146bdb39b95b6ddf249f9dbfcd7b1315a244342a6eccfca5d0b51b42d3f42d016ae55c93ce73a9b50d3d0b965de86e433e9e95606e5c1ad85f21163c8656852b34770b3cd16b4c4cc99127aeddd387758b71e77db5ae6d41f824432742585447a2d83f42b0c693e92d7de03fb11f11b72bd14818942b2ca2cb15f480bef4ae05b64b89cc3d57da35a82af42cf814f550bb428c860d01c48a0809f5985b124d09187fd57eb6ef159043bf6d13568e72f285e6c7db673e9981ea08fea387ba56bbe1a76137cfef95cc8fba2db9d919155cc4cbed1069eae65156f1c2cc7ffa7a0d7ef7ec2eb7569b2077798931de2bfafd2686acd29fd7e14ed72caf0667487da296f7476f09aa022508f499b59626da8776bcfd7c1207768779d6fc47973f6d572d8571441d80413582df4377fef8fdda086570fcab0e5b94b9a18829f4a11aae9ef7c638a1e0d191dd0f511316738cfd81d0c424e64f8fbc08566086409e844ff346e093945a2f8d855188aa23f3a9ef7925c4b344ca2505da5b09934885fb1fec812afbd9db5be2c623a9d348e046d048aeb93eda4e51fc3eb535fcb0759cca00c2d80fcfc2bbdb0db630128e9869ccaa4c0ef5cb91f3ebe13210b65c331d397d61a3b14','sync','ak',0,0,X'56bc1afd7780d09b9929061adadb3c4514f2118b','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(24,540009247.27961099147,540009247.27961099147,X'3c585604e87f855973731fea83e21fab9392d2fc',X'8fc97d86cc2fd379f724adcfdda1aecc16e79290',NULL,1,1,1,X'9b9df5bfae51d08338d2fbe56aa394ce5c2fdb33',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000a2ce3044c6956d3fdfdc3e9c643e327199813a1e173e33bb4dc3da1726670ed6ffffffffffffffffcd5078b4f8ee84eb31b5fc0cbaaad1f8b3d5e9df7bdbf77f6b217486e96eb6155765ebfc7b30e60609b28e8ee92f85c8c6baeed66043e91ec9a16adaa3306c78d9719587e41fe2c50ea94949940a538e9f268528e2feee3789616d6e61646f12714307a3927b958e22580e0a481337c4eec05d913f0747a8273780743ed5d89d94332fabed1a77bb0301a864d92719836ad693a625397a572f8e42eb69b5baa14ad832e01b9405c2ba0a856cb69f604bbaa94d7bb7fd0edbdf2cce4345f1c459e3d7376c0fdf23aaf73515e87c1f2152c525be00beb0eb93a30907e3e85d023fdd59ac06e446166fdb09f93a0e0a9e6716335d1a96a733ea35b9d33c38b61d29358c35211e968582b10f74c00f5443fcf3a3a7c1dfb609f20e24d2e9416e064b5b3acf5857806b61abc30ef875596f8eac1a14fb2ecc6f7b741397eaf28327c705a52fbb9ce7618f0fed4d875e856a149f50f98a9785ab3bac6418dc4768164f42a7db0821a8287971b04fc0d3bd394d04b7cd8e42c3dd41629c7a8b091da9eaf872b0e0694772083dc68a1821ce4abf75cbc5e05cc20df56e40e56223b1a33eb48d4aaa79f0eb053fb3c2750a6f91e1338194a2409e32eca214d1ac151c7d594361469ddf774bb7123dd00acbda316cdb0f897f489ffa4a08eaa8136881d59e57d505849142ec581d28a662906bc484d57bc9f0c59fbeafb4a93f162e9a4227f4b0c5ed725f4ea78d1aa28fd626849eac9067d2fd1e024df60005b8d40f12287371914d66201015a0cae103c7b70ba3181a5cb8a5541054e047b76d2b201f472e616a3696a03d5e71268dd0fb041762a7ec966c1cb6d355599b893434138d1a6c10a97641e534727f41ba1d257d5a3b5a7327b838e3f677c449278889c0d5ba9308d26d15ff9f609a8d0a236de4296b447f09b76fb1df5204110f2ca31c57903f15852912678e0322889cfe1748ebc2da0ae3673a90b8c2f50836c3a607413ce0d01a738907f4c58f567ebc378d7336e6c76601ce440ab315486a0bcd1af59abea2818f389af2e204ab1af99f6fdfa076e5bcff301b3371e5e044e61b7eedc28f2f36d5813002fe3d628c33a9d9309b12ab38dc1a2231bd4da587f4f1db9059a66af6f260f1d87302ac3430ef2a43e89c3c6db38f95893798eff4cb068fa9e8a88ec87f1f64c5949607deb8d61c60149c509e5ea75ac30103c9cc369261384de168140b16f2185b6c6d6b0303949fc2e676b4b0b8922db9caf876dc317f564ecfcfa4650b3873ff2415ff57a811a94e41b5493eea5bc16b190b8ace6fea6dcd019f5432580a07b09fa117cd99e2f275f29139e80e431f634d122fa06be5a52ba88374e9389ca2701f1133be4ea3cf38c871bf4dacfbc795cc8d8c59053fd68832f476fa9ecb99f1a78becf7e63b274ae86db57a7fa853beb1859147b78ccd6ebbc1564b9c7011010d07cccd12ddea92c23f219415440c2987771f946e63ec7e9b7b929a92932f3e870e43063287d93d591881bb347f8bcb41efe557fe11d76970811004d0f3286d921c38bd4903fd813f1d9e470b704ffb38168a8c41fea449c42d605ab0d9ea','sync','ak',0,0,X'af1d6e44dce0738fe366984fe06db8d9e5fcf007','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(25,540009247.33149302005,540009247.33149302005,X'3c585604e87f855973731fea83e21fab9392d2fc',X'6c3f524d5765aa8d2bb9a1d88340101d08852482',NULL,1,1,1,X'0f2099865d8dacb7580d9a26b8bab208b06ff443',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000002a5bdec7c55cdfcab8b64fba6d7a4f07ce020cdbaa81ff44c49751fbe9314f1affffffffffffffffc9d9659d857f364b2cb96bf67b900b7371a312bff5e900c537b283d81bf4f189dc57abba4526842be69d114b903441b6f9130811399b4dc04a1e6453407cb762bc81b6b9870e1a32b798744e704ccbbf5d4e745943931e571ec5b8cac1d203c979060ffdbd00526e448d383c5ef68220af4479f0ab2f3d7e2fa0c376c2a0f14c5f8b97134485304c9306cd7b4efb9250a1fb1cf822273aa348b726e7b4d8942332e12ba81700c27896a100d24beff4a38e2c519c6b03890a5cadd415091003c51819abc642259942f2a10299296904535059fc6291cf77a63ef0f3faa785ed1d3ea894f156f2297cbabeb2affa882f3f2f40a38ae8b1629d96d9602c50de53fd213f61dbf8308d3dd4e30b437334845447da7402933e7d34d68ab3572a3a98d553b5f250fccf744db801733322f593ba4cd0bb25608d7903ac7bb7c9645085d356d7fd58ae815d83171a3290e4b289a77b78a29a0852d004c3feae13d105ec0aa373de0878978fad0dbd0c1004458aa848f8d7847d2d7787205dee3735fb37231ba603fe02ca6d8157ba54a59d4caa54586f28a2fafff65667ec0d413f6305419a38f77cf8f0a73ee7d304709eb049e5b324fd90243e6d9f5274243b76832cac7d4ad3cfea63772fe5db2f71b24c6d5877a0a1541da10cc1c195900ab47f6c12f1918188cf850bd96e27fcfb0d16a7a5d36771db0f64262565db0d2605f91033a8938309cbf2a9326ac514a1f957665a318c622ce9bb3886633e250b61bf5d305e34a86e50d2401b494092de18711e14431a64bbbfa4da1b091b0cc081e3d9e55f44ba1c5a7273151031b12ee8ccd035b39c450521bc7f20fa358bdf5f44a5b24dea7ebff774672ba35e414539f3bf53b64cf155aceecf3da303bf359ac47773c22f146979945abdcc49b6739b93685f1723ac0feb5a77539d27b8e0f4ddad92bb8b26534f0eb74211e3986a5a5f8dee790d70f9ce780cffbe779dd4b66b9a64fc6ccf6fbdcd4138cc53720a4e2c4a1c5c8d705061b98760b96239896c2e1cdeedc325c8872e46f2a2975ff147ecc862845b7156a373ce5452ae44a39ba743cf6216cf85046de4f62415bb5afd06c71f139a5b9a214191808b05c7b3563326bed2a4af2027b4f34865f5baeabbbd383cee9bb924540f90b43670b156b2e481409fe762dd9ce7b2389c611bc050358af484fb038365b099b857ab5dfbaaf3353e5cad55b3f1f55c1eda242ff880d86f932cfcbe00e946356c4355b26dbe8220b6d13243a606f747bf628c95af9b8310af421f15354a059db9ff9f7b2d5c1fc8bc951b906270bd733d4b75a1ed428c922c7d51c0db920cae48194332609b9a288db30afc099d124bd5b313373fcfa83c22b59d1cc66a63cb5951a865b65e634e21fa79d1e0c040a0fb77c5a418729b1b0529cb38eadbcda1715c509e886c9de788c74a4bd9be9c52f7e9ff22abea7e43ec1469b48dcb4d66f1b5e3a18cbb1e804be99380ccb42c302094f008f5757f9e3be5f959a4904fbf3de47a52d3f8906792597d3261cc9c543aed43c6d52e96cbc0d5a75677cb12d951dea620af5c645833ba565cfecd2b93d830','sync','ak',0,0,X'f3b866ee440d3a13017ac0545cc5cc15ef1a7a7f','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(26,540009247.43573498723,540009247.43573498723,X'3c585604e87f855973731fea83e21fab9392d2fc',X'a13c665b1d7a66756287e5bfcda960f5193f903d',NULL,1,1,1,X'e3129d56ed171509107139a75c5680598ad5b73f',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000a5da16429ca05d84a9260efe276bbb71ca85b8ba9e7186bd1e46e48e5f8dafffffffffffffffffff4edf62f7db218f9a5ee690f42b777e7fba1177cc020fbcc4dcf42fe68e1a5e521a92662bb0ddfa836d6c987ac7dbfcdabaebc5f8134e94caba7bcff2d4b7b6e868cec3af7595f34f8f1e53628084943109a4dc0b7931649d5d9bb3cfcc9529035488726a4e2f02a15774c1be1e1bc72dffa7d8c2969f43311e8036629bde37f77fae972d2dd5a48910a425c0f805cca3a27dedc26617f7229cf63c4cb19a3eb2e5118570b5ac8213b066ba1752248d78a9866501abb7acb402888d7ce48ea607d2d3934cc240ff436e38f39b466ff6766aad7cb190097c279d38fb0e741a50a689462739af2e6da1ddc4f95dbfbb9dc0be6e6e862f02e08db7388aa561e0a737f222430b1136cf52b7f4fd1c9e61e0f03808a3700a70c093dc9d7f41e6cdc8eab7d427e18b3d7885e7ad41b5a665af34ee9c616902e2dc29216ffbe13aeea1768b1800370263b42459a60d22a7e57b648a1917be1944b3e02ac1ad79bb3b283f71555bc0d93caf8b4b6d9e3e6ab5eed5737ca0566f22d48418c1c5b789d3472b32e52308b21461fdb70a184096333cd4edb4de546e1e54af321debb263cda290dacd9d47efbc18f408db262f046afcd6304a50e16c565e07f3686532349d5e47045aa234b925cf90c0f63dd0a6d9e1f3928b06946ccadbcdf0284bce0a9c9704596ceab544d012a4f2cc192a841f61796aad12a718981ff3761b3e2f000a52250ba574c6a37e3a3f177d1e62bf570d2fe618779080cd712c85ee23053d571bc82ef172f1e239d26ddfba7822238faa08f0ae029a570f4aa1e5d03d109b6f0cc84ed2ae30fe5d213b7e3958033da0f8be901b3beb67c5dfa974fb788426fcefaae0251572bac7334c9fe8f368d0b8fcfb5cceb065b14d1f7f720ca60fd3fca303b51f2154b7b0426a545e2505fdbb436969ef691e00511ea671855ec9fd8fcb147f469416f892b96eb4b8fd44795e48b5c90bc1a5e9af43c3197a11a4fc88ee7965baafeb0e46d907bb12f8c50d1dbe8569c2aeca0eabf5a9b01d41c529f70291637c8f91823ed9809f8bbd46e5bd6aec44b0b8c245c8ad87d0de0c93f9ab0de89200fba6581e17f5239390db7b1e7bb24170c958ccb171b3e12297664a95c4a7330606942617b1655f545bea6332e76a66137e887c2676397d75cbae2d1789a3c47e81c898d55e59e7563ffb6aeddb818b51f49b27800c76e2b5389135b96a0cbc5ff2ca70cbd182a82a72d6973023f2931d5acd23ed251be6838ad9af485798c5e23ad7bb186d190e5a557454a331ad1d815f62c3efd871802659199c536b782302f756c56382d5a7ceee9290001647f5c14b7fceb1c58462215d78948527ec3cb3538531a37ba951dee8186545b4ea1e565e1ce73500db8c1539cae06ba1323d02e05137c6a07bab4bacdb94780215e4928920a9f2d579812495558bf75dd780ad977946ed89d055a818ffa9d886767683af67e21238d3c0a87d33ea633a2458331ec8c36910078bf97f80ef8c82f061772e6c7670063ee268020d8c4f7c4b9456e9d02afcc1357abe8f688f1ea9fdb0ee26b1450cd184e03afd1c96c6161ab2a634110c17','sync','ak',0,0,X'45e395f9a296ffce30d5e163a478659aafec9550','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(27,540009247.51279902459,540009247.51279902459,X'3c585604e87f855973731fea83e21fab9392d2fc',X'61877464b2d2af5c48e1133c86224f9544d915f6',NULL,1,1,1,X'363309dfbe8b48fc943cfc5a7e326a4deda4316c',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000d01cd3ba424c3579b6cf93b422a9000a9dae2b28f30ab53a649840eb4e03e579ffffffffffffffff34bc6e0e54ebe68109ca84a04e26c0378c882333820c745ee16ac9fb8db6ad47b45b0d0f4c080fcee6adcee407a1b69af65c19b4682047dbfd240a962b8db1e90fdddea16e7d44fa6e0722d2862c33fd03be806af0520cdcc8e9e52647560a651c7097bed6d4c60a449cc7d615b5c5278aa420e3ae6a5aa57b23aa57a68591d885e748a999ad487ccb29f10c33a865500698a338137dd2f2a56999c856e72e8edb20ac4ae09f2406fef15c83cf257ec54274b2553623f047538e47b6a5ab292d22c999a7f7ab07ad08790bc460facef6df2e1cdc763f402e0d7cd63abee159c52e1f13272afb97485facea9cd6879cbc13a7769e6e9521246dbf56a4b4fa15580b73ecb88df237bf776044f17ae3db10ef9680777a32bc61ede8f3a994f667ec8101cfd9c2c50444f14fbaa5da00d61e2e6bd81c5aa7cc6bb493e31719a6c5ee95ef53583a4151f501386ef309f68a2930d1dac3d275f2ad472721577db211d95f4e9d88f7dcfde0f4e1ac6e49b72bef25b424cdc758cac33b55b9aef64c333dbeb10f9acc600273ac867b00ac25d0e93ef3e4684b102751d95111fd5cb3922450c6aa07cb07508fde267ea965f0ab6c031a5cee8b71ceedeffe6bac4d83534653b01f6745bab0d90c3bd4dbbe498cc9be8f13b8fd51f8c5f69defe98b4647dad6a761578d6624deaf18ed433178f5b327d696f3279fa5e1ff4789ee05adeb066592125ca39a763d76a8f9f7ebe4423a915e46efc0e5930aa5c944c25967399b8356e168d3aed9427e693144a63b6ba515e5c27e038e7a228042955ae2ca21bac1b053b63914c04d7fb44df6851dfa9f63d1f0270a15791de513c7e63bb1d59f997654c9da312d8caad9da74e37ac5f77a184596e44d9a209dbc55819b08287cfda5a247cbef94ea371b3849aee7266bd6340117f628bc23f3dbc82ac6d6f874ed7663fc7f153382bcee72ea73d4f3d55853c5215f744759de890a139deb8a408da434935a135dab36f1066d9f9c6831b75b8fb65db413c680f7d2d54f338233891fc8243d06c5c1957159ba73c66b10e6bfe6faa0d3e9118248b031e41e11b81a9dfa09f873b037fd3e65d76971f2698d8a8955b49e2ad21c1413e78d2b1ac73b0f32a4ee44f369ff10606370b316e762611aac73236b5862594ce98238aad3d06544e6d12efe5574b717f7ab450912a8fb00dc18eaeeedffb5e7226b505b657401eb84b3e780b08ff145d4ca773f8bf5f08f6067e2ba06c4a0d97d2630b5c90184d0ccaeb3d7cbfbfacd20a772bb4cf2ea055db93c51c6f6b925850526fed869f3127b2718af544667c6f9c65329883a41f9c2b59d007dbd1bf0a11e66ba6d7d25cb71c6e4316436677d9cbbfba4e365515c5a8706796556811dd1a6f6a30a27675c9b73eeb266b75f9815f1c1a63e7d92ac01a2430855b1045967c20388cccf622e88c31083d914bf774d11628fc470828614315dbdb9170b360169a0c65ab7dc1eb4c3aeaa05e1bdeca1a32c25ca21c520d7da5fc2bc976e742dbb4eb2b68a67c08d878c98a30aaacbd72d1761ce7b14b8c83d59ee72c30c940f36f9071dd59f57257d76','sync','ak',0,0,X'd8554a7ae56f7411a7ce8515718054fbadf9e87c','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(28,540009247.6053160429,540009247.6053160429,X'3c585604e87f855973731fea83e21fab9392d2fc',X'7ae3392d2cb9aabe4368c004ed31718e60d6eaf4',NULL,1,1,1,X'35048287b477459d153daaef3b216169fb8eb8d3',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000f1f9c5b78e5dfbad069152cc57cdc051b774afe84f7f04b87af37bf8dcccfce9ffffffffffffffffafbc13265a3115c6881f13864ad7832a97e22219b6a37a2c5e215d5385172637644d357dcadf374161b2e668ab0659ae15bbdaa748621f33a803c6eab17f19847a7d67e27ef14bc77175dda3e0ef7e81f5b67d4a4e4053f955eb0acd71d466f78624ce637d42582ff22a6f69108b99892eeb3bfe7fbce212d429bc03fb70478f43798e40fe94dd46f680e26c0af4c6c73f4f645c2b32dfd1c3288e686807e056c7b4c6e2d721a836d62e90f3020acd74ddba74cc1879bc46f43eebfc61176c32e82cbbdde86772b7ab6a1637f2dca1bdf96aefc8906db21a7d9f65b55a2db4367d599c54a3b46e00388731c91bf70953035d0df402ab3a5d0419a3a4578ee36fd580da4dc3b6042f6908081cb10a19b58519e3f0736f6ba4f446db078dd27d73b37a45a93c67aeb32cf0b792f3758dc05a40aadbfd2559b81ac5a1a8ff5ef37786dff1e47487150c3c79a049a6cdee84c7a0b09ed70381749bc1e7cdcc5d4e0142e8ed6871b6fb7970d18c28082d6013a56799eb72978b87aac1507f8bb9ad5f2e9d9d97daf4dd69be330bfc3a711eb6b758b3ff5543fdfdc7c5d4edd5f25d5312b869aa342f82daf5a503a6b51fc906a693e28e529d05f29af2a889c08baec8a4a45c358ba1132f0655134cb615e9ed1c2e53072de3cfcae661e4e443ce5e24bb3c9ec891857a98b0d78c14770c5a4d330777d7341d884a345bd416d86a6d2d6709b65217f70805501bf13cf111f16018406477bb4c04099f53bb5f6e7e6b15ceb50eed28a3a0fa0e082c81e1a6ba55d9b9925e096f26eb52df4e45fec5e448cfc082617c9b9744fa69dc1f7e3add545139760c7be1e5df5757f9d855b994a629a57c382eb4ab0397b96eaf0fc6582f5ab46dd599c7e5a31821ca3da2a1cdbbe3f00b1fbf2b5a7b1c86be0f38a141ad8ca87db8cc91ea0ab5a027fa7b98109fe46092b4eed1586c293c816cdf7383ef2c58925271941ad7693fd527c3ce2dc404d8191be7c50dd34596ef749440ddcb21449da019b37d6cd744918a200af1e8e93468c912d9c33bd5f12fd31235f468735b2ae2fddbb9b716345b789c07dbc1912104fd42b5ebd4f8513e3c1ba8d236c9e1d8ece71dc82c239fe2b8fd7747bb198cc4c330c02b5349d4df4ea88a59718fade0c06504ae8949521ea7a503877c698e84d9a2d593ff3b574cd41c06f20e8eccecfa71ce7cfbba99959fa6a10fefbae7d15604fdc8d67862eb853bd696b972380d073feb6e3b1e89e1198fed59e76364735cc2d2ea5bf28cda4e03fc8536eb876d506ffad4b20c72248ad858924c4e0d47700a1d849e9119bcf1a2177236f0278d374ac182d9bc79a9e1f2ce63d3ae13893f8e478a370d08f08e7609b8763d1b5f6212a29ed05e5dffc3a73ae4c8fcd575bccfb0ddbbf07830c5d288eae4da8acb5af3f4d47d2038f02db44a58f2053a04eb3e1bd6c3908b8304f4f1e1e00b97f41e8524fdb008627fc2d940a7cc4fc09965dee240ac435127236998637f6ad3252d22f07d01f808a809e42c03719646a4ddb6fb554aafc8c6ab340ec7df233b93f0385d23f962efab4f72babd86b0ff8c636e6889ad','sync','ak',0,0,X'0a644505d4611c840c5dc53d0343bd5d703abf5d','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(29,540009247.67837095259,540009247.67837095259,X'3c585604e87f855973731fea83e21fab9392d2fc',X'aca29d0e4c943c6b98a80641a9d972484a2b1f68',NULL,1,1,1,X'f82340c2bc035a2cf71f837c2243ef5ef416a412',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000000867586306762ed702b49db58ef2b32869966027b21fa38fc3b4f92dd1583157ffffffffffffffffee52c5f4fc6885ce88f2bd1d34d59451aef21aed3a52ba0020f5f9784849c97d7cc44b9156b6320c34369822e99d74aaa6a842c685b1ffb524f6c3fd5212121185944d5298d37fa36bfcda1a28d4a387d8fd0b4b373bbfecbd687c54ee7b196abd4440c37b13597bbf16cfef77d838a78d19d22f43034f58cc7bfe627e976c4c3be71b0a398ad80e1521847f9d046dcc85a775b3784a0445fc9982b42f8ae02383476392f7ac7f753b6bbad9e3fbcef9ce65d98ff36d9da0e09cfb46f82381613cdfe5043107d6ce35abee3486e5aadcd7e6501cd60a62f9370dbb578c14c0db45927474acd7746936a0bc14ffe46fdcdfb77fa8dde4ed29a3ebc3f43463f281a76e5daa99498b22493fb4417b4fe30f683ee3793af1b53af0984bf432730cfe410283aeb14fae1f2cda55d98d21d372a0df4b82cf7e1700263330b44c02e1b81807a77b2a2adf767a27e42ef926b6f058c938565d4a7aebc968d86b55153320df19b6018d647b883c9b8c7ba61ae814e745deed1eb0ce4a80978af148dc2148be0421739eefcc9e8e8fbdb8031a7cadf86f70aeabdd211cfe7e8a7550b5c68a77da0beda45517bf64afc3d1365a450ffb84e917a007c3bbd14a3b6e2b30b65f4e3dba836a8b986a1f906e06dc56aced1acfded02f7fb883a96b27d82d1e22f0013314da60d856975316a6be3a57ebd2c3a0ae12c5c3221dd6d12f6febe74c0442e58b793202b8331bbc28f5f5abaafc70abb897823c7474f211ced1a29b78ba1f21da11b8ef5cf0d4dd58898e0116aa3c2e5f53b3193d56ba24f82eb1fe7a4db0771c0798b8048b5561ba1f1d2ef8514a502ce784da46b39a304c90c80ad0e2dde5217c3e82244f51e30700575b8c13ce30e4df24c79051896ce1213b9db6a4d24bd01ddb0e44fbb1b3e522fab2ac50364d47d611b388e3549c0a138549d5cc0c0bb413a4108e1842ef9c4dedd1396932d1969f41b44c48231a696c5503cb20ca253c9d3c1870fad9c4ec487c266ddb74f97b85543ac863049ef9cee235319b397f254ec682f493ce0e1ef1d0f68fc40ae48ed7f7e8257f9c3a78d0c94c11811ab81b6db4c13ba33d82065d09e2f530c926e9c335b45db3a6ff09cf2f448c294b6dc6f17a38a9afda51813a1a76f8873f324bb8030afdb4161bddc0a07841a3ffd5b5c9e8756237b2622c2a1263735854546a3dec4b8317a3571e282b6d6a3d47227c833102c0127041be5008f3335edc12a9c5bb408aad568dda2438c3c71cfb9f6f077116c4a0baa053ff7d93f732e5b6a04a0656698f9fd74592a33f0807b47ca256a8c89b4d02e8c16e36f1355d963363b6cd458d654142878ec68762c24a14b4c16b0733f2c658e0837e646dee2bb95b6a72bebf6dbf661f847dc29f2f51b7ccbfc9aa8d39a6d04d89dcb6f2b079906062a3b3f996d1a9a52bd9c8772c0507e384d8eaf6e36b7f6c6a57b83a3f92183a2dd73428f588663fef35ceaf042ddd2b827d033a607c1a6b95f903fe3dbdd397ad336c31c65b784109586977859f5967ad677ba62f376ef13aa45b7838d7108157dc42a7931770952041d4049724c2c29a5be7','sync','ak',0,0,X'9a62a1b9229c383af39c199bdbcf10b382f55a9e','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(30,540009247.70696198942,540009247.70696198942,X'3c585604e87f855973731fea83e21fab9392d2fc',X'5e5d549e52b459dae5c4caefc0f48ae4bc693c2b',NULL,1,1,1,X'ad2af702eb0c7fd45ea13986b60338b8c5ca058e',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000c0a7d7efcd8a20b86a43d43afd009b9482ad1989af4c81d87fba6c7cf55eed2dfffffffffffffffffdcd665548a5803c623fff5d0e9fe39d5c5cb9343d756568c262c91eae5f16ce0a8bc58879b29358006d20bee303e137538d05115f1d70717ac0fc602e0ddf86a9329e7f82426e039193a0905ea78961c7129b6fd10fe3067b54f2e43e449a9e2c68f66797cd88a2a60c75eddd12b7530f8c8bee6be2093ba896be7513037001c8b5d16e9b2775fe08de64af87f42e7eb99c5d8ca8cf43752afd5f7686ea32071235299dc4d706589c7d00633cd2f92e7c9c13e506dbdcedf2060b5cf8a278a6e20b5a91798887f545912a3c836885684b3ba72e13963eae8423ab1fdb4fcc1e6111c9dbd9cc496640dc2fcb75a3d5748e3d9c20f3873bac5670c9df2599a0a4666924c8b6f490d0c9a12d3cda9a3df508d7fca79bf3535e027a971d2730dc24617f67311080da889d7e8c8fbfb8bf67b2ca9d2c90f84737d502de682698f69bf7405afa9e7b4bae3972ae6b887a899478489a03761e7be41e9160858ba6945f03acf7242c1695586c9efbb8fecddfcbbd46733628a8df08205bb3e4209f106ef92eb7e0c3fdeceaa7a41523704cf668b7592a2c71e5fd2d94a744f1d226bb5ab5c025aa1320856a8dc4b071d6f78ae0fcd1baaff41d51ab44354a96fe3be7202e1b9437b283961fb761e370266d98f3e429b39019b5d33cc4422ab004ef63278ef480b562c5dabf5ecc84df7f0c667f9da011c10f2e6de591f231e6d42fbf6a3bdc7102dde18db8f8626a816602d7045916170808da587a133dcc94898b5a6d1cabb9212260cc0a71fac4fcbbacb6d3d69683cfb037e335f6327ff215639ff033ee569822eb98c4b636dc68dfdb0b31c392d29b97294e865f07a93c5a58fdc22b992647d669bd85947a044c3bf828ed35c7d77d1b00bb965b03c58a2178082f4b65396c4f5aea93875d7f26ffdfe94f4623ffef383f819ca8a6158f81d9fd8f9073f18118a61dd60a0f231778c1c8874f148a61b9840f81b26532421b91116e03e2fd8f2fbd16ba1850140832d325ce8380f715154dc61784bafef0a7439117b9558057473aef1e2b7424b3ad45be88a1fd673874b76cb195783de8563c54b7bd0caf36e962afc742acbe3edb13c680dc31a9aab41ca739b54d8a18f7a990d816d970f6e10f3f18ab1eca1f97d7ebe48530d2ff6e1d43e742d21005f5419612d5c53e9ac8fb8d7aa823a3bb93c0be37a2ff36ac0034d9195c717971e10eeab3fa4e2b85d6c8622efd4349907549f4ffacdb1f299b29336117f9c4ebce8371a61e7997292bad9a06ddd6ecc44fbb3bfba9632f1d1fea0768f6048241616e6c02b276251fce9adce5eae5613eb95efef83cadadcc33c3d89e24769fc78704fd04d22e19f831ce9e56db9d51bac88bc3b37b7571cc73e477f7f5f7286a4003f546a2c48bd40c79e606056803540b6dcd2ac6d6971f6a0a65f49812254d0605064eba255a8fd88060683603bea2f16e8fee29e91226e32b90033cdbf359961cdd6083811eb2b6347bfa738bf970c486e98966193d6ed00407ad584b335cc374586077b045a5db3539001883e2d85a95bb9e9c5f78d84b5ebc3014270cc665ba6a60b08d0d1a826cc5','sync','ak',0,0,X'd0ff386a0d6ffeae54265e05a7f43660d779dae6','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(31,540009247.7490609884,540009247.7490609884,X'3c585604e87f855973731fea83e21fab9392d2fc',X'99fdfe59349928e9738ad0df3273b8af98c84667',NULL,1,1,1,X'869030dcf5b3d97e2032f936ea0827ec50b045a4',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000b2b9b6ab92c3c0e383b37c661830132ffac9b1525d453aa3adc86b822719f08bffffffffffffffff00c5a2a77ee31136d60b6e894656722334d4f56c64fd30bdd8606f29e7ee0eacd6397a69a800a64b35c1d6ec5f95e36c569d3a4cff9a0466a03785ebf0276b81e9c51f1dbececaf208ebe8cea358c0e3d10fb37063e47957b65db94ba40871e7996b63585b1cb6afc93f6dde168302ef36e92476fc2946db6f347600a840c7ce8f2baab0c780b416158320cc4cf946e4a129bee3fde53459c9a4bf492b3375c6e7be31532930ce4bf3bb3cfa2d230f3f1ceabd01cd4d32a97f47873ddd068832b61fc38d39df77e7334013692361a7b85349bdd73c1cef75bce1a4d859e512a1def3af789e0437cf451787ed146d50123e542923289e0df687a6f22ca68733f9ffd13f33c71aa62b39bc69c70de2b81c84cc2c5b20db3f7f9ee7f080a1bfd8bee947072313d91594e9cc56d0ce10d9191199a89e0878c1950c958dd63903d093cbd5821152678891e71ed33adea6906368e1306ce41598d9c53c0bd92e741fdea1be9c6cced2baaaad698a3220ba4265f91e97eff4ca37531c9c8ad925d9beaad62f20f8c810145eb3c2a8cbea790bf8fdc0729fea17ed6b21b6fd04a4140509edb099f8c1a0f5a7af8cc0932ce4e5c8a278fa6482291db646723011830f0f72d629f4e634fd52614dd7295f3fea3e8065cb093d5a7af287bb1e600a18f62294a31ad05a0c057e35e1ae22d8987b4ab197e5976022999f3c9fb12aeaa93fac4e350c4809c6a3e164c46db4cb21a0f29fa3c0bed976faff43d886e7c1a43f8d1da2c1078901763a6c497122e1337d771ea39015669a2db7be45be077b5050e45b78ce37c8a65977868c39388cf97e914ec697a5b6eb9bf1bdbe52719f638faa94063f7a7b21e80086901d75accb43505deec25842f70309c27d33fa74139b6179c0ac321333834a34879cb51ee173bba2ccb97349bc4b89c633b189a77e8a47da70b84554a3b75f9cc65628b5fa4e9ca1516cdc41136e6f5a9c40e8e56e39c7c3f15c781e301297e14182bb142f9d10bc1efe465f19da3951bbc8d116b06ce9f12bf77142d464b35f67b50ba05b909559f84109998a4c64cbd67f70b7a8ac6424265f2e33f6fee7b01f938b8e992e5dfa3df14d3b6408b0a0847977f0c62f5e65b7fb9ce37a7b928972485bb96e2b17dfe47527dbe6076ae78f513045f438733ffdb3b71fc6b6ac3e082094c12d778fbd0f836364f06e3c5e0c8146dec4642fa63f25543dd325d197cdc9cbb00795e45f95835722dd5e3dc63561022f6f8663f8ebfaaad5f28787feeaad959b4a9529099a70bbcd173c734879c248e8dcc33dd11314f359bb2e6f92de3e658ee6241eceb74f15ef6f6bd5bda23dce52999d68d3f8a8c6d46bed1918908e297d56ffd25814a0a618b0a96cbd7d9a012d7f513e2cb39448becf572bdd3c8bd60f5e7bcf9ee6b0c1e1edcceb96dd4eb5899eb8ec9a7e874426f6ea8fe13305c9316a906358a757ab9ec3fed207403c596bfae766318dcf291b679153773c4c5374387a6320d5b4771573fbdf9164fbb6c874eea081dec2adde5d1a9a2f001e56a2f386087eee3a5013d7fd5ed2f53f629a60abfbacc10404fc0f08','sync','ak',0,0,X'baf41f7fcfdd65e78feecffb5dff2f802563b55c','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(32,540009247.81093597414,540009247.81093597414,X'3c585604e87f855973731fea83e21fab9392d2fc',X'f237c1fdab441014ec4c677a3ab26766601329c9',NULL,1,1,1,X'121ee0b74c76e0d9fe804489a301ef889fbb1810',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000002c8748227f882683f39dfdc22e357cd392786a8e69cd8df2fe94a01e76303de0ffffffffffffffff2b2802af13fb8f488f5ac063705e387bd545f8a590a19aa460db02b2034ef4ffe244160424db7c64f46a52c79096b2c12e246804c581a5aa88a73c9ce5300f5559f6a4cd40118abbf229cf7abaf62f060cc72fd7ea5602804cb26e96e072d447b44b3f566b30f9b0726c520ff2fb8b1e908e4d816cac4be87bdfb3ee7162b440d5a73876d1e34abcf3bdb2c4c3ccde19784423382c2a55f40fe56a294a91c5489d5549337066af2dc9eae522090da0c63c47c01c4ed813dd364e81c14e771bebfb6687a31e9530f3f7e917f8bfaa033a97ce476619125848bbdbbad5459673fa28b39890da9135da25c78e4f84836cffe6de44b4596bfb5878ee143e3e3b2f8b654a05070e953dc4b56ca6b974a67fbba2956760ddfdd110bea5c5a74ad9c892b2b2b0f1043a4d7fffff8195e79992acb5b559684e07efa9002aaecab405ebee1513cc3debccbaf0a7946006a988b638a68c79cc9fbd17e80dccc9e4e61c4c3c89838c26bfd14abc8d0050432abfda75d13b86182b265ef1d223f6ff15cab5cdbe775760c05a2cdfd162e3a63b42a41bafc2804de2c0cfa723b95bdd1d741c7abd2e6f06c9ed1a57e55bfead3106c1c0634b54ef68003d9a219a0a75abcf9269da1c0e98c7df7b828ff169bc1c242a05af0e1a1a2f33db17917b1ab582d6c6172ecdf72b99a3fe1fb78f9db3ce2b0095e4b0d36ae95da80ef9f077f55e05e70160e4ca48812089389f9562fd3d1abd59c051c3aac00464a9b13bdf1c52b1c906d23db5bd6914ebd0080db4faba33d7121c21ab9db596fafb7675bd4872ac98f1addbe6d868122ae993355544ec8c40a0deb6301181bfbcf17c3d8098ce97c9ad172b85f5b78f7c6c5b040ab22e91b00eb8463107c53974097cd5db90df4feef29e065427cf61e4cd9ca247a9ee8f06ac209cb49759dec8d510b6e2546315c0398ab1a6a5c6870b49db728ad2e50a83687cc43e09c4d47f8925a19aa57de8db81b75bb2d267a3876c91d629fd16f9c0ba0380b66506cd8046b0578ffaefaf4245687d83dbebf61f72d8d6e3233f3460a977f833e88e2848c90f62fdb17d279b2b6b4a464efce4e491f33535783dd4bd26b1d0cde9a68bd8a0e78665099a3ef347ee6eaa67604581953e2ec3a3749a8bc59b70278436ba6808538bc3a8f618a930d689280c484db56fe8ba1c57c921f894b3cb5470c838d0679fbbf429d4de085332cfa4bb9846a1466e33d7997156d34a76e3c774525cf02c7574c34556d6c169b7bb432d28ccb20d4a2528c0b0af897a0576700e355e9f7b883f74fc7c375612c461574da55bf91eba52274bbfdd5150cc5d6bdc1e9da5eaa891f19c19d73af538dc567317e573217e9ebc75f0331632cc06d4fd3825064ea29674aa23b3c3f28ae65f6edfc63cfd9621bd642df503a64c0ccd19bf28ab4d462d5cdb3684764977f94b08611ac13814ef60ebef44550cfa4da8406b90801a82b095c69ad4da0e1c6c2602f8ea694e6e743c72f09c9f13c21cf1a0ba53191297f00658943a381cfb0428b6c0ef23cb945bf94728873d4a524ab795a8f144abf7231f3100da7f59302e91ee1804bf','sync','ak',0,0,X'6a057646fedba9f6c541f1590bbcaf66e1069458','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(33,540009247.88870799542,540009247.88870799542,X'3c585604e87f855973731fea83e21fab9392d2fc',X'f8fdca5808fd57068b26a631f9ba3d2c34536c88',NULL,1,1,1,X'de8c1ba3ea9c4c108db296178124d4750cee0828',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000000d4c1ebe16735ae5b2ec21143c7b7c7f9ef5107126cc507b55e40a3bea6bc2d1ffffffffffffffff1b9f5dbac42b7587ad06d1b0748862cafb5e635567c111b10fe9ecc48468f1935b1ae7e784936cd3a3ece172081041d69534318aa161cb0518f8d1b62b9e7a51f1e5d41dd204fa6ef1a825a3819bc2b4fa80a0a578cf41d16a4faf4eea2aacd75baeb3e122cd18d4c2d9eda9e059c411ff1d51b46062593eabd007192018804d09ce1b229d0396b1e60ed720cf69778bd1ab4d43c5f253a598737b84ea4bcf60958ccc3e617ef4acba75ed2e422c6445ad540ac0a92237dad20ed8f43fb7d67f1788bfe321dc5b34667ff6d5925d6e2517d9240410e43341f48a65d706fec31c34fd96ad28d26e99241ede416088ddabf6af32af27ec2c6d51680ea2e3f1417c0e69bbf7c72bcd5ef996cfadad94ab49cfb98adb559dd9b5ab91bf0140eb5ce7a56a23bf232364b9140339d4303ca535bfa5716cf7d0462029184078961d0ebdc6f797c98ef4c178dc4c1061b3c0bf3b34cf3aea712b09f6c93cb1534a67bdd3ba2827b60a4811b04f07c5b9ca377d31b16c7799171aea3ba417084fb26ae027cc829aedd452e2acb87d35d2b3c916b1f4efb2d2d6c5c302fa729bd4180ceaaa8916f56f2f5e1fd4b7802d14461a53ed1cf6d7e4b46ccc87aab2d5976ebe16dd66b1be8d075b4577e29f708ef889a41c4944176a91103eb9238614d53a76e35f05ed0ab5b5a013fd4ac33bbcd40f832596ca8b9d4bce993271303f3c3d8b6dfa719b5dc13f95ceceadcec718b27bcacd404045a9c7a18f81f8bf8d4edccaf432f82f6298d5d7f1da65cd53c4d22646449103bd0fa2d0d0528236fdb765e35f7178bfc86f4a1d78abc03c9363d4c30f43f178a92b16ed6a968610c2d3204db655c7e2a8d90c92c77b589213d822488d7faf828bdffafaca742af10c939714e601db58ce43b8b33348d7155537b3f570b3eedb6cce27dccf3004a6d0a5eee0d03f6c8f2248bad1ca64b5faf1593510c900b95afb463a358917565e9416d2ce9dc1b484f1dd37d5642be17d00c878dada819e5e41857893faa21b8b35efd79e30326365cd161821442be8381698496c5b13c26e2d6c4777f97c1a81b439c3d8473fe0fc381a23426717b95b46e9cd531a0255bf3041532c7a601af01160503a183fa9ccc900ff42588a1809746b2a0c9146d166f49eacecd6fee0facbef5fd88198b2a6554eba422f02bbeee83c4698e41bc65693bfcec67430563fcbdf72dae662e4db23fd1544a331322f5ccd21ad4d73e9ff29c337cceae508f8739b474468f4c1988b4d8cff22a15fefbb067801d5a159929804d2810aca1f2e10a1b3c590bf76fc568c23eced837f4cee3dfe6c2a69bf28bee572862115cd8906276ae059bf500ed01342dacffe0529f94765d644da6a0e6790dea97016e090f92b68df498f063a8ff66b939dae2f8b116ec721999c5487e52f3c578a908d6bfeee5a77db543608f74f38d6b0ea9e4cb86452485f785eb766b9439db3164bd9bc571c165e1acfb53c542dc6106fd3257bf0c162207e8e1d4027c50421a22cdf262b11e33cf93a5d1b45e32c1f6e6558c5abc09fdd997000e2c3c2b1caba572ef70ea42fdbad22b91517eca04198','sync','ak',0,0,X'e32e69d3c70375ce8d7d98861ebf2018f3759786','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(34,540009247.98529994488,540009247.98529994488,X'3c585604e87f855973731fea83e21fab9392d2fc',X'4631b17e5ce00604a8d3b2b9691cc27efb471d7c',NULL,1,1,1,X'0c973b023e62103d7355e7b1c7d2e471f99d0060',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000008dafa7a607a34f3242e1f7cc9845857dde8ff54d1b52a8af0adb23ded312818affffffffffffffffa9f17f7aa133bf3720a0f3f7c25160fb603358406770b46bec69ccfd429c3552f788d9f1e12718b6752283d7dd1ee003f25a6fbbd3d7c6e827c080c4945bf18bf11c3001699276c56509b44e3211d3a0c223a24d1df9224964fcaa6b409b5d73f0e08db1291f2ae97f0f9e53ec8de6def45bc8e4d1258ed7d0ffff95b184b4b47d7c5e2f477066898a21c829da5b8530bab6c83254c0fc4ab6104b1146e17740b393fe805cf32fcec79ebb7031dcd07aa5f7e94f296df779bcaf0ee84a0ff47c2da484cc1fb29a2f47733da9ecdc83bbff0f67cc5d7b5fb0c8543d8e9423ca97936e124a3448861f183dc03f725a6941b0f4a9affeaf4f3d446f0f8045b5fb28cdb7e3dd70ac80c931656043aa70fd5096f8a530b0b3f1fef0e8d0167f1d6c85b45bcabfbb9e16334c7d0605b15d83828b77174671a593eb5262c7a7a6034af1e05cb5d5a0876820a7a62ea192c35e96a3bf4d194c4b9e782c7405b8aacf41fe2d65ac4edd536bb2a2eed5ea494b41dc98458e7b7d8d158e55247c6b0017fc0ead0eddbfac25d40a78ec1c1704605253b0a689570b0eb9380772dc635b90f9172fd253e266b2e67f9dba82f5d1544c0746d7722bd15dc912f0eafb384e6b2cef13e37053d346b3a37d35129d8e8c8dc977b9b465c376e83bf5ee04364befdf0c61e72c3262dd04380252de0a205ac1b58bde11c4d01a05e9319862e1a31f66e7e09bd4d435621af7179ddc918542345135276c510d45c2d8405107df0984e2cd52825515ed42579720bffc8f5a6146a04c58dd94b50445c3cf9f985558652d469329381e2bc44466caa9f3ba29cf416f926057c8edd561b86539e583c610af59cfd548ab1fd4fa2ba2beec436dd946b7be16237fed49212ff385d42d3fb457585c33a31f9f31753d46aaa9244a36defd0b1571f281fab1223ff1b2b685331bb635bf5737c9b142836f375f3ce4cf8138cc51abc197fafec4db427a2b9f8c98da4587dc4953edd1628736634128bedf9393668b330548717a0890c08da36382cfec479336b94abe6a6bf114ff7a2a59b683d0724658ac315006e1a6d26be760d524d1b5c7c47737024608ee7566aba270e0ce8d155efad71c618c86047d3ec8c7d897aa51bfa2f74edeeeb9f25ca9274e4861d0e91a075280cebc2a883270ed273328cb93a004b0eb8f90050a8f9a1bc796f85db1703533f96c557ba989321e9c392bc407aca57fc3a11285935ceaeda4cdd3f8546894854374c42fa912327ba4909093220890f2a251b9c6456d2a5de09e6734dc0099dd9ffedb25f862096952a2ea59cc48771f713efc272b1ea02ee9f544cefbe2f9b855e960901a5e0ae717f8bc1f95ee34d5d1f1b5e7c58f8235124f4e17cb2b8d4a6fba1f82383f5770ce0d5c453c794749f1248990d8901d79ea9317ce82e53b34ba975d948386569206a2965b08aa5ce634e2246e673992d28a6d54d54fc9653e4a6728329ea7789809768bf0be2a53bafa3af144cbc49c3fc8939085b02b79b63b4c70d4e3a33403d4442a4a2e0b37f75fa1ca0cdb76a3ddbf6d11ce8aa1d30ced53a9e56373c0069725f81a','sync','ak',0,0,X'5e7d9ecf48f7aad9e82e8e17b1832a5aaec3a4c6','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(35,540009248.03348696232,540009248.03348696232,X'3c585604e87f855973731fea83e21fab9392d2fc',X'2cd4f1af1f630ce1912f0c46a5f745d3f8940129',NULL,1,1,1,X'76d5ab1128ef898bc3aa8e4babc0bc1cf26c479d',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000cb615bfa42ac19c9eadd5ef99020438ef69390016fcdad5519e9ee45d6a71bc0ffffffffffffffffe0119fb8775b7047fb5fc554d0671e8ceef729aaed14b63b3cf6c61fa813d68e7c5c0771dc17ed19d481052528cf27c66c066ae5f9ca1c6599f3673dcb453ea1a1e9f55cef4c4ef4f7de6045e0a7f13393ca08991826958a13047b2b5290b7f42618841b6fab42c008173d831cd2438079f43d21bdf587584e8cf84b6cdae66a4d371f7dfb984d6e6f873acd83d86e2becdf86bdf2df404a2c0dcf16827d52cc57c854c943cc18e0e00042c955ef66837d04477d2b1fe0e69a039be00c608944f2359d0fa785754dd8bb3b060c48b441e5f4b78b2acc04054788f13d4d8c7852125ccc30c69a80440f6c3ce30f389fb3ac9b295f9c190bd2884b4123afe9afebdd7eed7e16abe4dbc82c810cb51789768422d2efd9aed574c4c13e1eab0d7ca18a8b80b4880a9d40ef1eb5e475c65d4047aff89e7c85c688281d124a68b3ed661e38270b0c5b9ed0fcf7b8f3000605c19859e23aeaf3275125204540885b0bd0cc880f1496d5b9bffe9af1f838e8ad2f8fd4f65cbe3699375048bfb9c67b9f3ad9e59834833f4ae5563169de276edecb7852acf8cb744d791e98041fbc32af75be2c8b34877171b92cfc7508f4cd910b43d5bc56a3159ce6aff2f799ea04869a6034f205c1c29777dec615e6cd897350cf023b10860afe7da96f637260a1f1ebc93a3ce152e13977c284a233abeea1fec6728238a934c22936bd83b5d28ac85782e73b1486c640758c87ca94665c131c24b84164ff2b3c7910c86d7d5968d7b07331797ace3eaf179795497bc36163b7c7bfb07faf092c61f1b0090e79d72fda60c3fed29dc7b827012f062d4939c83ca01465fb90b9d41d21ccba2888f8d37fd6625d57a13011c093288c313b99d4f26b87783dab2f60df87f07899603ce4efb0b0a6cb9fef19cc15f10e2ba16f47ff752a3d9fdec02997595e2fd5238e1cd9249844f7c3b478625bdbcfea42dd2491ed8cde0856cbd3533e48423dafaa0da6b68a366e51ebf878a96ecb25fe8d83a8878720c90d9d6c42ef5d51eebaf99bba5e41d35488b5cfdba457386c453ea11be0991def21d867946dedd986071367f7edb7fcb588f83300355beb248ff21498d5188863e499c006980ab76d5b52492a8158d53849db8382594b51aceab2b51f8a2efd396453f66f21817b80128593e35ebfd9453a9f8d9048c1a6da1e9a7cb018156b42198babfc9c7a17be4bc3c51b249eb4f229a019688a6bfc48104091492842efc2700209c9f89203d3dab21e5ad7f4fe163e923b210c2cafe1bc1e3cdb39d4b0ee92be19820c5949f189cc8915fa19df8a039c4276abf5c48cdc03e50cdae7d1428c51231001b3eab94c73b16278026f66756d7b574e0f15821527304f641dfdee55cf657eca1dc13031349fc640663245f3ee1663b9aed40f5cbb5b0d0032d56ce673a7169dd594efbab8f9471f886eb77e763ee3dddc8730bab68132288aa2d7a0344048efb8306283a3379ec63ef53c56d21691f991e67ae09cf0d2765505363a47b5a59284f525cf1b913dfdb1e715e84805360da49497700f0bae979b35913652d7fc138d001140e177853b335a9037fb5b','sync','ak',0,0,X'718bcc07c07b98d3a275f2812f930b1905ae3f6a','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(36,540009248.09169495105,540009248.09169495105,X'3c585604e87f855973731fea83e21fab9392d2fc',X'ba03b2e1909c9ae7375454fbc6a2f4d66df94aee',NULL,1,1,1,X'44eb66520fe8eafaec370f97e1d7c8467392740c',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'03000080060000002800000070d6c7cb465aa50d48662388557728b11a99c5064b3f0e40e9c6d5e4bff85154ffffffffffffffffc5d4aa323d851965846a677bbc0a989190f5d53730894e18dd1fba06f6de5a0c73de9e5186fef65c6b953da4ae3ccf8cb31cd5f2bc553e0c1250ff6ce83a75c707a1170379fae5c12fb38971138a31fcd1bb401978e3e42612fc7ebb5b01c920ac2600881e70c730537855905ea09915ac3a2bcae4880146194fff63656299172746198384c5a9af8e55f74eac0573f75e5554fd3efbae004daf2f6bfc08baa33d893c323f5e015a4d656b1b01b498ad0827ec95025753bf0c37be8e8ef7b8c2deac45b7517f0eff752265ca7d33aed5a9fd7add7dcbeef393b6d6dfc3461342a5c5e9646c110847a65e2e0f46f07585ab82750095918e9ab998c476d14df8fdc73703f5a99af6ceab0c608cba513f0eaf5a2904867eb775889290cca9e30db526f97f9469635f90833ff653c06f76106b6826c7f2bac972ae564f46c040ecc06a563a914822d847ac9651e5f89e139a33fb4c96e22681ffb8e90d1d4984b2d282008991e8ec497a3378413e04d4951ec0aadd25829ff32b01651277d6f150116ffc54be50122a2e9311d0b73f354eac31f0c05bfa488f380e10faaee9a6a9388f08c5cb3d1120740a5d443fad97db970785f6adece9592f83744abaef1216b7a365fe4a3c83d5a3a84e920e81d184560badc95b77dd2e04ebb18c2ed7b0a6d4dd2abdcd8663afee5e69bcedc493e6d4370f9890068a1588368594875c9b51c2d4ba2eed0e86912106889ff42c18a460137f67fe229a7af35c00d0cb3e9ca3e9143b8db6bcfaba35bd71da21d419b5be5e5963aaf1f8a24afb8b0ac115f45d350bb80b2b6a66f822e83c46a82aa0af02c64fa30fa5d9c704444758fc9419d574f0e49075c8bdc6e781359f5bdae5634f75a62e3d7b4117dd13ec6b029a9687067b05be25d185e4be3e8ba61599f01db4695675f232cffd920d4f29d35aeeec995d6346b22af180c783c7f831b3cb0e8ecff06cd64303a81ca6da54709f5669a2100c8ae90c3d40186da47ef9219d103f65edfa054f6ce7e4caee61af3f3c6f58ad6d0bae5ac72c9364c63e45e8e66f52b503b8d2de111260936776aaf9e7628b274caf4141cfe34fecf94c3ce7abdf8edf68cbd2e09e588563256727831b913565608101ee86367d180b927a5b34056f13107d7aff5e8e0c9cecad3487627275daa58e5614200fccc6706088cbd0e56e214d7597af2f9b88c42d483efa06a5f8a181bedc481e233bd9054c590efc7f42765465c2f3d3a69c0e8fcfdc06ad23b47180654e572ae1f8b730c8f2c812832bf1098c1918401fd6169d18d41696bb1e07f50c16cb0fc5a7d29d79cb7f439d0c198156cce1b136d051bd4983c3f84a7721effa255df0e6142b07d320370c01daae3a9cbbc86336ad35d6f3ad55b828550f96c0f52aaaafd1a60c4a1f166dd34b7a70130d5d575f3fa6ba112b4542b98793404dd05cfbeaa1537de2bb05ee84de2831e5b20988da09a9d6e0b0acd3845b2a307bfb9b760f86388bff3e3118c5cf2ab03eead50c93265ee6e7541fb69e3dba4c989438862744638c1b0257f58f21cab9500a0bc3362db3c152c9cfc461d2ce6c72cb5e5f','sync','ak',0,0,X'2459f4c51dfe9cf662d3402c8b83c67a92334b00','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(37,540009248.15771901609,540009248.15771901609,X'3c585604e87f855973731fea83e21fab9392d2fc',X'aafdab94f36402c0dba1213feb30fee7ad111d9e',NULL,1,1,1,X'92b3bf04c33dbfe2f62834d7eec13d41cdec487b',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000c838ef134dc5d63841c3046ea569bedec1a8a21be7c2ffd312e50e447543f7c0ffffffffffffffffd68a1e0398c2b4e3c553cb7f46318f5874c7f99c2402d49f12748057b941ea879ec637cca418fb23de0f448abe5f40e301eb6a577d7b20de8c1df692e246e884ee4add20f1ac8b3db77d83e5287a8249977a4518a595fe3763a02fc9bd8a672575ee12945945dc9b5da42bf0e5cbfdba893aebfcd7575d111c519d7f4b6200ac4e55026c7164dd6e3f862551080b3403eb28d722c38e0fb85a982eb4752821fba9be4cda18e859584045847d680f4a7aa420033bc98f862b12d0ed7fe6ee07bbb485a6d37d2d3a9a69a8692b711f87b5f634f4945f6626a8f6a09cab1bacc1a91627ef51f3a7f29d7af8d1eeeca48a21f5abe8c0e47cdf7663a6084f6bcb5680590c5dbcffdd864f4c4bb041fb0d04a82bb65fad168a794355b27f5f78c2e0277466c8b7dc7404b72a3f79d674fa444ad8f43dcfb5f8a05439a852e289b6228587982e17aeff8b2cfd176bd25e3b92a87eea68d4651e0923c7e07d7d91513b97bbe0759eaa6ff9ae01d80d33f4d0cf6668fce039b4089423324d0915263a279eeef36064e0993da4d0995bfaaa1ea89270999a9ae5d05c2b6b345cfd2ec450132bfdc7115e3e0fb160bdea18e2cb18efe08742197a72bb36a3a9392e000b478153b428e40d936bf64ec4aa9c7ff8bf8399608f82c7188eedcff44fb7210264c07e430cf6b258895aeb38d9780745a810a807841ec846b2e27280ae52a791fa759870c66af989b9ae91c51c66e0a013d190cee476e70c9a8fbb830e5b330590d71c6a9a578a920fd9e1916a1e292c03ad43d2837106aa704d523201222f883b7f37cec66ca273c65ea216a48eed86a9552ddc2026c12edc73aab06b774d64f8b6c9c046814913669d0482e3d5594a76218639e1ae0425969bad413835cbe0da0676e1f6228dfde120c4235f188a0d7787d09c90df73d3c30074cdbf376a76861a8a5967f8caa8de1e83406c964a1b3c051b9777b7bbbb3dc0a1acb95b48a676a7a9f169062d071e5daa2f37777822477545023c61bdd4f3f7b99f738dfa121f59e97aa72bf4134363c110a3588cd41ccbfdb438ce05a4f2831a0538324df7a38be19374851e06cff1794e8ef90763b852ee442a9a4ccc727629f7ce468422a38e6b43f2e09b2d258c9ee2ed90ca08925b295767b127917767c7ff7a721ae60eb6ef9252b8d3bf7d6ebea865588a47865a3aa3c35a9b54d51ea5bcce2bb3d65d77fa9ce73b5c5a3f2c541985faa6391e483583aeaa8ea9d7a8ef4a943715566543e7d82cbcf01491a148431d8fc630e656307d43a0e98927def40eab85cec89ad15f08a541ac3948d66e997368fd5e4f866f16de30cbed52ffc4a81bc4fa547fe946513b751fc3446c4c44c7bdd8f1cf15fbcc27916f0736f5dd16945a07cc75e89178b8048a6f61c6c69b2c13aae6048d4fb57b083915b5c1c588c4001442abaefc7c9c47bfbf89ccb42c7be52dc2a4aa39b28b6fc40f5ab90911f4367dc9cc3a43d95a96a5d586e3d4393b57ecbd4a75f09ec8938d00ccdd3ee98e2699c385b4ecde1eab8f74f0f91cf8402dfc3c1dcc6a8c23a7055f14a00596d17f0a06949113aae9c13694c6','sync','ak',0,0,X'bf5cfafbe2347bfefed68b0b82421d7dac283969','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(38,540009248.20999002457,540009248.20999002457,X'3c585604e87f855973731fea83e21fab9392d2fc',X'7478d998e42061cf5f6a7538d49a442d3dc813e4',NULL,1,1,1,X'13d6f6f137bf024bb8906cfcfd3c893ad303c67b',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000003f759a8d8fc3b11160e10f0f547b041f9253fc9dff8cf9ac0d2364a7892d7717ffffffffffffffff386734a8f4d42614a354517c3b5bfbf694d2a315e18585009e04867a7ef752893c84cae14e4f54d173f9cb061a35545bae19cdd7591e9873dda6068dbf7df4487a27c17d3ae69dfe3c6f4795e22c9f33a3e2b609eeac777f6030f1e0df0892abc7136e82140e1a6248574688c09cc46dedaa89b9accad5f0d7b5c057440a95eaa38555e8f4ddfc9be6cebb985c01893182128257a2e39f9663fd6fcc83ca43695c19d912ef7baa8af392b7cf4286a0d85f683db091b616c7f68230a65d0c53e4e95a147004f5f3e8f91456f31b58ca095e8e3bee897297fed0fa3d6133aefc6a2cbbfc7d0ff104e9c56e220a8ded2aea60e47edb309995a188eef31332133cbf844ee9d6b3590731a7c16339a41bf5d1665c88bba3f7f8efc46665892c6ac8dc5338a7de2669d4b87967d14953393552b4a09018ea2eff0027e29b0bbe50d3978a22be64a7c390ca4ba612eaf39dad5f202056647d42f2d7afa8c6fe064e2eab1ffebc98fecdf60522ce8b8d3a39d9bc2cf05df47cbc1cc9b27c5d25294d144de41a028501f0a25f38caf84d0799dba032c7cb1d72a855141e0845dc5ce23b9752afa727ebb18f41e11de7b90d0ca3767b34280c22ed059a2b897592423b9fa4f4519613d3244e7aae1151c3e9382b7ad9a4d188e9943b263d56d669a25c73187c8afaa0f5bc456f55089b2d1d39a7ab997d3e3341a0a69730ce2bac40a1fa48dc33e9a5d84a9f45a666b729683052e7670168ac550365cd33a215f32a20bb64667de8f0013c88e9f9e38f23c49625c9c403db233e6095b11d2d961e50e245e5c67a33cc252506482ed5dc1bd8c324fce5ee27c3d9253dd9c7e57106ccf4e221aa14940f143c748896f1cd3f74e59a39576fdc9347692e51dfe4d4ede3c0660c48d9a6c2cf26cc25f989f5e16fa0d153591a60f85b699f3a44b7451dceb6ac5fbded680cc6495c34672d106355d683deb03541d3f7871f48c325c6444a8836ebd4e0c92caaa5914d11ff6eba33554b7b02502da560775725ca51c43025b48e7d6b5692a6e431acafdfbaffe6f86c6e111f9015e47b8b11543baf1020eb34967aca74a264002cc52bd707fd82fcd971e9319fa294ef736b632483d5dfd42676b66a4ec4df63a8316498e3197657c4d65f2da0ea8821443ea1796468b458f65d00ffe4814978a3eaadd36261e3f00af65f4890af576576c7f242d3fcd0d02ed1d981150a27220fc44f2a47538a26eca5ee564d68f34a333533048c59b1d72187cd94079bfea235b66b464287c3ade48f8c5083568b1be7c3372951d75ddc7cb6de210b7199c6908791464eb4de38b39a24eb999c554752ee5e17f5b5a6d1a2d68b6bb218bae75124293d15fde62945efb51a624eb7c7ee51077985f68fb02197bc87aa07a5f8e7c3dfff2609ae90ac9988ffcf59ad139fa7a1168e3eba3477752bbeaae582b85a6d0ab5e003a95c61b89c8f7ae1db4466b976c5d5985491fa518bca2873ab708eda98f9f0b0331fa98d85691f7aca97c71aa5ff383ff19feda2165d2ba14e6004609b18ee3034b51ffbaef1dd1e57a2958679818ab76e9da243599ccb3a672a','sync','ak',0,0,X'365aec9adbd4ffebc74782a5f1c64baaeed8912d','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(39,540009248.27032601833,540009248.27032601833,X'3c585604e87f855973731fea83e21fab9392d2fc',X'6c498326893a1920377c7a35a5206c03c3b8f130',NULL,1,1,1,X'd7dd2a6f5887a9291d26a99b1076a2986b05b062',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000e33b7388e66bb46179ba96dca8c26259ae0fdb2159966c49e295fe70092fd6e1ffffffffffffffff90455fed1f24b4c8448f624c87ec8101aedaab96985b56a256f3364089a425cb3dccc6346e145db74d7e3d2690d488f6f05dc6fa754f2e860b937cce0ca0c576adbea0c4fb60731292e09478a3bd2e7147e9ac31b9caba970e4e4b430c054a4e044de67edc0cb16e3adfb254799581e299dcb6625b325536fff1072361a1da178562336d438db1fc5fba80cf83a20de8f315af7078ca7e69c0f3d924bcca25dc7d25a90f6cc820e325cf4f186a4ba1d8a2acbabaf841c10fac073b9bb83450fcd88d3ff8fca9051207c91143499ab6eaaa4a675412c3bfb9ce6a96fd5b83bdd7bfa8542e9b6c87d473bcb8f43577d77e372134bd0ceb6228598f37ce2f3e43466544273d027c655ff8392cbdc727a43013cd710af5859294a359332481e30d9707aa1289a83a2f2b9f8ed5626d5f2cdd41436c10c58be3997022094614585a04745df15752dc5bcf8a0fbc3b358d4cf46f5849f17a34ec0ede99caba960efac82440da532958894f5142524b252a561b3bd043cf9e594cf7fe8c9f557a44eaf036e44bbdcccd1068a9ab6926e60c341c587ccf9743bf2d88ab6da50b1ce619cc2cdc19789eb72851d862526d8fffbf31e61ec36eb50352d3f6e7a92abf7ee7df4191da21d089c6554b201079dfcbf5550da7fce86ac59ab090b66bcfd361a0c0b12a5a8b974cabe8bf2a54f5c11bdf655623a6a1298687c83d0a0103c5b2e6e7853cc3b0f7b89bf0774730154835aeddf97b86388190f95be4fef8a5ea1a66d82c7d3dd44f9eb61b9a49a87c6a355adee6d277a4329ab0ae3e208fed5908c9728777e7e4baecf3b1a278b1b91de6287be619a904f6a750408d67d96bd057947b77d4e3939c78496dbacecc5d8b2c03c4a23bd8823d318e83cdb7eb0f9156d5772368d6f26238d7ce399d5d9d7fc6e1d324445c5f5ca2a98e8c6ae2bac66a591751a17b2099d6b8345e95443f60ea52e67222893dd06a92e96eaeb522eea80169591d2c8c4745af5a60707acf22fee3c4d52b1a9c2f6f6670219ede56e4fdc41e50877c05f1bbfed8f6ad2e7214437f02112967440038d213d97a6fc0a8d1cc25a5e7225c472cc026f5897fa24817d0adfd36e3e21ff0027d629eb4174d0b41d51940ba8e68631f54eafbaa733237398dedbb0036c8855454802bd390ae91d792e96b23b40b13143dbef5874b8756a49b2383e6934189e5065170c7435bddc4f2049a0a449dc518609fd57b1488f1efe1579da2329cb5ffde34e0f37e69fca798dfe6a994b34ba6f9f6061cd533df63450cf444683917ba5b57b04b4056ec3a88062fe164eaf8e048c4a66ea400dca106ba19211a86416c973ce696f9f30d2adfdaa5d1f6229c2e8a2c7c6e76becc728e77b9d7a9b9d5011645b9cf453ec81e104677d085cba7010be48078809a033f9b005403496f15d3fe0b723d8162a0f395b6323a375020ec11d4dad9ae3369fb593606cef8ceeb3ededd57f02e7b6272f5abb015a286ea28d71acd2ef27e5a2ab5448d0b45e0f9f99a2ba388abbd88c5a9853054058944b0f04a1a62a7ca93b64132b827a115989a958753156ca6873740859b6721b107b237','sync','ak',0,0,X'a945392868f0e61f716c61bdda7a40d759a34138','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(40,540009248.34564304351,540009248.34564304351,X'3c585604e87f855973731fea83e21fab9392d2fc',X'014de7d3657cabb3fd84c5011d5e4a67c366e8a3',NULL,1,1,1,X'dae6654459a08dfdbabc1c0642ba1846cc3fa42f',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000826ed464ca2728a956a1a00ba15a8bc193fe7d92a52fde2e8854a75c123691e5ffffffffffffffff754addfd88e8a105cccc90f47988567cfcd03b752780ffdfc31c0c244957e36702a7807a5fb4baf3bf7f7f97fa023490f26ac5df7ec36b4b8fae4af96ef66ef33bbbbf7add42c6fb999a531c7e304f0e1d51f13b99ddca3e435240f9eac1f13a3b81985a8ec9faeeb00c776b6b4256d01aef910aef355582b3b8030fbdada24da300e3d3af922134da432216101af38fd6b3e315a1f52a1ab8b495c1382a461c67df78d77d775e994e2c303ef41564cd46368178744a94ecf0f40cf1d60bdea525740c3d3a5c3093088f5b3ad3a76426ce0688dcca467d6517fa4a5682f72468e8ebf81ed26e013048c613d134e507daf8d1369eb420446fe2cd2c6ec300b5a944743a4a89035848dff70544df26c45dddb07a141c0655ea1c4196a72434bd7c93146e4ee573d1018c39e3549e708396b5c1c52af0b32d3530ab06321ab33fbe53c1889fa99fb9ee04cdcd09628cb357537d145167980b2aab1d30ff63df5744cb5bef6410e60e30d7cc4ed29ac119255c9fba07a29e0544210e0fcf7d4192852bc9a53bc2f90ded6fe01f03809e63de14ce882d01e8da80a9927c0d826353dac7dfebf6c5b1e9b042258a2114dfa67e8f87e85f7d12dc27892a11adf20cf12be27736896d8a90885ab2cb595bc9c2e7725807c8c1ba8a5be8572d0f0c0f5c3b0d08b16af255ae438a8d53413a828972694d8346ae4707a5241f3d38d7e2040c98c759cf185f28c30a93b1c773353e7a3ee5d5ae6898510a6491c680068c4cfd853621ab11b47abec629e97a81e0e72858c3e4bb9b2e85589d9f53f67b8cbdf6f06d1f2b6812f2fa0c6833acc036e5dd16949250c9edc899f688da3f2f1805cd1dffa71cbe80cfa187ab284895662b32986de9372c8616c09b5211887f99238b48717748ef00c6ba49d262c4b07ed9f2739effa819b75c0b4e1b07bed2030d066941114728e456e6681ba6e8c1175f2df2a423772f03b369437bb78a8065eb412b4d6ac7cc382d47942fdac3fb362c5920e2f480e376ffc559ca30cfbf387edf5c27e7651253a587925e2305b35f9e138e7c76c89b1bf5e53f12934e13a591e68861a9a038f02303f4d9302781ebc7818293f13d420825c136576becbaf510752992e44f40b9663f97be251c05ad3e54d1b07283149003dbb3006afdc8d25c172df0a01343843152087412f2b4460738c03b4844412f7e7de9fed7e658b7bda2a23b3b0db01abdf23f1d75130356c69f0347e17dcb08fcf91b51b298e89975a13f6db8e755a6b565e75ad69fe34e6123359ff53366111294eaa0eb08dd2626ca6fdd444fcbd3e94150f3ac73169eb484d8589222feff21c8f074568f64d434663c953ea0335d850a6f05b01837ae3ca9d03f06f27aa4900da9cad42195a4dbb7bd81f437e731348ac736b195dc9764e4b411d364b27cc5f16dcb5fee40036bc992a328927d60c68a1696d6f1f4244462eb03efb365a53fa8e712796fecc29915b57227b54dd981dc6f319ee699544961317989b094ed46dbfe8f297e8768d8c08375630bf099d5910f8e7570abfd3e00495e2f67d21c10197a7571f9117463b3dd52debe3ffa0e6f6f','sync','ak',0,0,X'c9f75feade79d28b7a393b23accc1a230c6d0de8','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(41,540009248.39385795591,540009248.39385795591,X'3c585604e87f855973731fea83e21fab9392d2fc',X'1100dfeba7e2286479b530628c4fc8eefe42ffe7',NULL,1,1,1,X'1a8d191b0bf7c44ff48077c9fb60b0b1c1f7d239',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000825472c5a0c7a8e0ab04ec38362c37676fe200bd33f7846722bb3edc3d33af50ffffffffffffffffeec520dc689dc6e0f163017309c82ebb27096e45783b665f9830b06405752369d508c72772fc7e6db5f23adf2b00859b08c5d6c1131fc536cb3fc869c1309a5d403594069f8cd28a202940ba0226c2cb9d7ef88a486796c0601d7b40c290be79f9a9185e1aa1f5c07d9cfe06a6d76e545d0c7cbbec4b0de463b38b7b57f17954f0e812f62222fb80c5b54c72c077a031fb244cad23a2688fafcca8371317b56f04dfce21731c81f5c704a9ff13a4f4cb797f85fda78e989f13de7626c02282a603240fa43cbbe59dba9346a7f247ad4551b2dbcf75a68ade35f2fe92b96d176b13d42a1a8dccb0ca6982c6df408a74dafd2f0ee12a0ae6f6f5d2e251826bac696b434748d539237c66830475ff83fa079181130c555c2a911ef9e0d40702985851727ec8622c047cb07825f30bce5ecc77926de91c39741922cb664089e5968a83cd68eec4a1622639e9cebe9a2f2abd94a68fa3688e52626f0a158063d29d0f1744a648b55e3734057a758aa449e09efd2cb3e12fbe0a65b5e76f546b57fc602e76097a0488acbef698f430518bd6cd264f4ab3e64d47fbdf385bc849ae0b018d1385f7d7741fa533d4fafd7c98025fca1b0f51237a982c65b86de7ad832f18d0704cb30ac759d20af15839c73ec213d37e33b013f9113c9966332df23a38127ecc042748d317926a2ef2bf665122746090d5a6b7e2aaa204331ece082a4af145040dbfae3a743d73e59397507cf6cfd8f9f6600b52fa7aec7c372b6d2b22cd1a5a1aafc9a4cd2ffe03377b744f958c5757939664cb854eab81249372fe1b9d054b2af8a6a48a5ab5db55af2722795c9ee43d27a563a64bd66a8f2689e0b53acd6bf82a5b2be6aaee8d0a1d6c0d2679c0e5fcf29529daa56e32d68f173061dbb62c6f0e59eba801bda1590eb78ed1222096a9691b9ca8763282fc83f6a629a853f8801b9b5622e74dd711d27a92331a9d100c1705089f642eda0ed1d8f41e6e2a0ed238354c5700b29fc02948c133705e61a77bf9d093e79068359015300a40a5a8d89dc6d956f17d1b6912e2879c2b05aeac69561f2342623475fd63dcb8b689cfc3a2598be1ffcbb539ea0793d7acbd58af4892da7a55b45440429b4093b237331b77fdff7a58ae14a43ea0ce7b3ce57f493f2b72a66908fddcb372d8c3962ebd365cc7f62910f98f4bfad13bf198922db67d040a859683bce67f4146b9f61b2440f42f5b8a2155318c5d5a9b1088b7f5c590f50bf0edbb059630abad60535351ecd2d4a29a4238836a55c858ead13a929913ccef78e5c9903434037079ad36d27c5f95b54993328b6a2a06b901428a396d47b65f45b540eab021e23abb7a4056b427244b28f3455a3b831e51f9061af5dbdebfa57b637a45b797fdc3c6080b5eea9eefe10ff0b95357108b69e3487a6df34a3e4db028ec5909b210384eb17e1e9161d67c927792d25ccde26643c1d9f438f33642f99f09579704603d9b131de8bd88759fca60291b81edc5eda00fbcd86fe16fedd54ee5b43f1d81743b0c9c780a12cfabcad27732c91501925da18f288993df692025d86bd0438d5994d492b96183c5f0','sync','ak',0,0,X'49654b3d29faf2d84085c746734d588315a7202f','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(42,540009248.50240600108,540009248.50240600108,X'3c585604e87f855973731fea83e21fab9392d2fc',X'c4a1f453662bbf3ebb18128793afad059c129dd5',NULL,1,1,1,X'e880819d6a52c8d1c80c09603a49d410137f13f1',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000d59ee11b1f5f3fca6e7fe9e135ccf9c88c9971b504d88179f30c51ff4a976097ffffffffffffffff71328dacc539b19e6610228340d74b8f206cf3fba2a125b257ac15ce68e80b5b7633824b5f4a78ab0fd40a0bc458e0d1d0a5ccf355e0f4256785050aa0aea70e9534df0588ea46abbf3cab4ad72cb1965d664c897bb7a8333bd9fb9f8ec1ea3b11f0f56cd95db68a0ba1a6090a8b5519097a92415ca02cb2c8d318a668a317fd4c9708dbdffac3e8862dde63708bee6f441095c8a6d48edcead29e4cc3bcf2d412207ae9afdda79eeb11fc6d37d26836e11b5c3bd9db8cce7b2059b1090bb63d8601a1413f0f03eee5576e95a0ceaa8a83d224f5f22e518b62c8f9a3a15119f3f9ce4adb1b4cadda8975b64640c9199d6809c3ed15d646acf942cea77a5f8d25e61f17208d424153b1d9920f2ce5996245b367688289c919f3b665c8e62100b6932d86e029141f711488db1d0a643d30209968816ffb356e50d33b83746fba53d253cc5ca89d84bea2d24a490c0e71b6b938a8a4c8f143e0ce206a58d886e912e40af3a4ea3961819a7ef2dd64be75a34c1fe5600bf9f00a2bacd7b2c7d70a49d4cf6d1a89d8ef96652f9c408e3c2043113abb28e7125a100c911aeb811cdf8520c7fba3ee5c6cf66253beb2f284cb162c94b67fc14043bea99377c542ea63ffedc06acd4b399a327a5ca9358f3ff768b14cba3127cf2051ba47f17dae1bbf595d930e96a02a44f1c4089ecdc3363c50165a371069936e6e490e30ea1ac08d99e5144978b7e7a0e5b623163887bb2b456c16af4958f13650390571d90429f28f1a405ebc518fe4152e5c7ee4b999fea962879b4dfc2f518d3d278f13363737f33a698893c8801a683a0fb370273928ba1512c9a56d40175b2534c87e6edab6ceb08e14900427a925eb5e1c199757ad7ef00a64b3e239fdd5e352aa8e8be9e8948c6c3c3b52da2633161c1685e27799d660793a0ac8f0abdea7761477c5685655b4a6e5ccf968f663efdfc3b57a0d066239e6d474e11d046d61b8557ab3e0bcc6e8e6b221e0aec713a73ff4f8599fc4c7ad8f7232efd0d37154b0cc4cdd73e73a87835a9647b95fa8688d4d4064095d4a6da57bd94f8de3f748e2aef2de10a308a326def73f30ca23871ea25e54dc243b049c14d12ae995121da2345b9e02234f54c0a798c9554d5ebbcea7a7da4adf0b83f04e8b218786ead26d83eea91700a37940174dc9f0bef8d94e0069b5447134c2231e0fd00dbbdbb0f5a04e1e177abcc50c6d0d712eabaaefabe33b1471940135036aad96e2ad8f43c595df8c6ad4c19e3a8878b1708fa5f16b7d78ba1d557ed1f3d5ca496b81bf740e56d6674ccbc8fa25e2a2e1d5477b5dc9ad376305cb8c248f84eed420bc6ba2d3a53ef050489681c6d3d0fdec37939a57e72374af900381c7ff255a6dba637f53a67d804d5d02b430e24186b860613b2192da5a06f38d9df35675b8d65dfbf3fdda83d69efba854fbc64bad2a350de535e6cc5d1b825e0bcfbfee681314e7759abc3785b0117b9f05d382e78d142c610964365023708eedcd8978a7ca2562dca7fef6ed1de708d25ecf978d0397f3177f8cf06a591e724cffbf0365ba811dc8587989551be54233423cd36118','sync','ak',0,0,X'dd63841f0f9503f06cb72731db948d1ce0d60f92','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(43,540009248.5388059616,540009248.5388059616,X'3c585604e87f855973731fea83e21fab9392d2fc',X'8f2a41b73b30f3b029e935864cdefc8c6fcc1703',NULL,1,1,1,X'43ab1e4d92b3ca044f82071be19a1e6df4b3fc1a',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000007cd2daf7eebdd3c5b7471dbdd8bf07b7a78561e6a33032b77e90ecba0eed2d1fffffffffffffffff27ccc3ab6eb9cffa0d9b3c8ec701b21161fffe57936561cb68b3a74bc4a7a01a20ea9cc33465d56d0446fd27ad735343b3b5501337b604cbfe636c6125eefdaf2a27059757ec334b95315d7f56b33db100616ade57534088195859452c07983a068961bf44d9fe875d8b7803e894eef174d5e9ea3bbd92c2870f3e47b24e9d053688dc0e281a42e399b29383737416adc8af8feb5c5f045d9e1fbf17020363184a639b50d8bf3d4ab643fd5a2fcbdbb1ae30b0f98867d072311be6531b6d0d7d6f1adacbe23f978628c6fd9e150f19f18bd5de4a9022b041d5a1d5f4ac857ec6d9052d55c7603f338ecaccd396885ab783ab8218c95712cc84b4b590c3de3f09decaf4416e5c2b7ec2102cd579b36fe7aac7030197bf297eabfb1d1ec66bc6858c2bc92200c696a827ae5e50a8fcf6dd19728a43dc1ad53b1dc3bed561e60a08cbc078552c563b04e9c7dd239b22eb2f8cbd1a7f2fec2aa02548abd8fa3aa576c517c410f6730775faf1aba8cb8b3ce4479b3437d4569f552e236c60505007ee44bf33187049225de953abfbc7806cd5631651edd32f801d92aefcca8f7a6359df2f868af218bc7665e9190d01ea150488343bbb49b44d2f23ae1721cb851981873b5595ae4ff8e54f5334ec19ad68e95c37cf556a376b12df3373400c1d5c34386c3432826bc8c044eb6a3b30b9dc1405a9a2bc17e2e1f6cbc4240ca09b7d5f05d2499cd5953e0dfbd7c00fc9f075e8962697a4170c1412050ff615e89d77896d8dd40b60bf8ace95a5d4116cbee09b8286919f1e3b658f40ea836d2605e1731e3cd61e213dc3c6bdf7f244867522f1f96d8cda8b44e3bca0e0ab09ce884a49e863573bc29d7bc4fe2f9a316ea45b87981a3eafd2db6a8850c72542e6b8fcc0c3113a176457b620695af7ee9c74729f74029b9a0983b75d4d044e880321248ffd87ece2e004b194eae90c7f87ad387a6a8b9458b3204133e953902773b4bf0741803053252a30d3d9c8bdcd4e8c092df777fd549fe95102fbfa92df3eb22642c8a1799b10c62a67e9249e89d93826f9de33e74fc7f97aee3ad9cb6740c226b884753357de72ebbdef9cce69ba11254b4505ffe65c6f6c5cbaef7d1c069f81b3ecc9e5b1a582a73c50a94a19d4739eb3e7e69b240f3a2a7db0d448aa426695dd8912df55586d196a2c24cbd61a0efe33b3502618059ca495701d7b44a5924118f3b618958f825d657f8c30512d0558dca36132d44a57c554443adc30621e1a0b06c9b19f030eab668fc681d593c849c6b3602f35b89dd0153694a4b88cb218d168c8be799ad1e955484de339a9eb3b8d958a930089abedc90f811c3399049752a7b79b7629188be26947ee826c5bdc4e353d31f459470210aa913de4a7ed70f8eed052b389d46c4691b5fa2dc10053e4b96d64765b5b0cc3947bde1a06c7587ec83b750dd8dc7c7a9f2eeea52083b3f57d3a32ac919de4894c03205e5a527498ccb5c9d131bec045c2f67020838eb0f681aff3e65cb3e0e0d26154272f56d9bca00075229d5c0097e3c9efcaa3299e89c5667f07be46f1e4a88f51b4d3d171fb7487120ccd1e62','sync','ak',0,0,X'772f831c8f0d2c5e705fc8310b68b49dd20d743a','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(44,540009248.59195899964,540009248.59195899964,X'3c585604e87f855973731fea83e21fab9392d2fc',X'84ad88d2e855b268a74aadef0df73b058c533650',NULL,1,1,1,X'6c250285bf047a5751399f34470399c03b75061c',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000000bf32371f6d6a94b775bd10b2406125c909cba179ba9fa39c8dca7795cde06b9ffffffffffffffffa9d79c7b40ba0db6f8a6534d750888cb0a9554e5a004b31c8f4f57b8f1dd58b5c00e03114e42a789e0b39c550e07cf46b5e36500bf2d2900e1de973364077827a44a1b0e18f8a1c25e3f12641cbb73c775b8333ed4ee3ae597206ba98aae865abcee1cc4c3ee69653710743f79fc8f939e2b39749a9020176397bed784dfbb0457c5c7849c5ce898aeba9edf81b070b1292854c0b53bc343b37a31615b5ef74581c00470818c513d068ad150210a072042a858316b32918e65c5c9b8b308057a994c24ded6a8a7f809d7db771a71dbdecee7ee7c3ce7b9d6391a26040f60719b4e491b742a1e4088be098cd960d4e3bcda19c5c75a67026aa57d7bf0d0ee25b5a6b39875d0dc040164d6d872627a34d56a0b85e3607ffd71ec6bee11a1b61db3ba2e6a3842942ac46ab7df6aa8cb76b4551cedb9839c887a156a93a6cb4fe091bd5c68efc9cbb1c867f73ce9f59d10e77ace546f7348cc28aa28da1069a39eca5cf8f27df041187808b6a3ae966ca3434fb0e7dce74d4059cc28a12d40a4780832fcd35ef47449d45e51b40f9ba4df43dafe465ca424422068d35017cf2c1ee0b319cc1d5cce568daaaae70eac630788dcaf79feec841fa580ae72aca01acdc8f06bba16eaf4dfb93bebd28cc1612b7d7ca0424817212bddf7305106f8a8468a9010bdcb73fdba0344ab0c336291e2ae31381f118845efbc531ede2c4fdb31d2e48de766f51c8aaa6448ccefdec4837173a01fb1ebda0e39c2db92a7694968e1bbe7ea11e3fdd9be65ca25697f8c4376f2c736e43fdbac696ce904a7b6f0b8610882480f26248ecb428e39d14f9d8d9facd83ff4c921ba188b1eddd6b0822fac2d936957f197e206fc8204477cd456b839fff57b522d313c74a34e5f53cca080c600f82a427d5e1e3452b8818fecf451780c824acf120a53575f9062a9db62c74c1e9185758b124f852771fc68d62b8b0e76595eabac0d89c3f49643eb039c29d244f5c9de4a363988ae53c0910a04ae34e02fa899c1971f20c32b361ec70a3bf410fc361dd25c79563e398c02a582e3895fdc0005f40c5faf79202099c11904c1096e5f55bbbfe35a25640c1254f890156218999e48b689fae0699f2ecffb5e24d8c4f4429e038c418ebac402639e76ee6348d31eef5cc3aa0d2d15ab82402a4aaab59e4923acb0c506140cbc9121e2b7fe2c4292d4e7ad57d54049e7042bec591271a150645a493e0284278750ef9e8192d799d7fa1146853387d9690c27958cb52d9fb3290c7a69798ab25c687582d2e0275f6c630c463fd5815a8cac6eb58e103c3cf96178d26f4583d232e8bf9828305be2e77a4544d2fcab4a897d62ec081c6e0527e4a976c88d53880f248ea0ec930460e54f499cf7d637b57418b1ed3ba8e80ea7c82f6218b534b2914ac230b3ff306619745785911689dfb5f962ae6fe54db03f0fcee53523316362c316b0517deab0460e7b9b44d9e4647a86b612599692ab6c4fda34f6cd7d59f754759432428e8bb2878f7f8536ec95a828f33bc2dd0cd1574ef5dd9b0e243db6c0316ff2f262e4b00fde2708e24ecc170e4a2945c24dae969b97','sync','ak',0,0,X'2fc5c1e61e9e01d3090974c701256e78c5717f3c','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(45,540009248.67277097702,540009248.67277097702,X'3c585604e87f855973731fea83e21fab9392d2fc',X'f30eb1e9a890195c52f60709a8edeefe4715c538',NULL,1,1,1,X'38f1fc5e9d8dcafcfcb5283d5ceeaf86527f364e',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'03000080060000002800000008fffa9d415631a70fa3e97bd0cc834861c3b63e0f0989d1bf86c0b367fd47c3ffffffffffffffff4c10e49d13133b4afca137c14965fdde264d5c6c35d9e6e4b2f8c083bb0722c6e0ece1c6afa7bf185198fa46c25dac328b7f713576d6f71a59335dbffd0c9bfc2e2ce0b296633dc5ffef7326045e223f06426d40a47540d8deb30b57e2a9cb99ccc689083a93e77139a7fb66d11712c83ef0f872d2e6b22f22fe6b7e8907322e23e27f1931c367fab27ce4e91f0e36c860c61ec6f8795d36fb0515f82f3dd3257d4dc3fba53e2fa815b4c2ffba5e392cdf0a0c48c103943db0f8ed7e2078b0603d5f82f7966d0a6918c1976a4126c40a74f427f2dce021555c7e555549a6a420676da2cd5798ce79875c8b5ab2f96238062eb60c33be8fe927d7749f4fb4f21a8077f1fd312e14b8ad92c72a10f2aca022881288cc243b2630d78a4bdc581201a2b1ff6123d49280e60c3780efd5bcb3b4295d4ece13de058e5d202bcbf891f337661e36e230f2579ee38659541d70d71a28f1a1d41c49499f3597ce640168c425439d9c70e083001639da033deaac2569d766bd4301ca432dbecd50cdd85f1b44c667f6970d8ed793242f97948b119ac0a71de0e744c5ea011fc9b367e876ac74663f6790d1cc1970b36d041c57e09b087c56ad6c13de211644a5214be3f0c507a5def884d54f6b596e420ba25cbe3b748a82ee7cf7bc0a747ceceba20efa4e9ce0458c1b27a777adadedd8eb6138152e20788c14541194a99d80b8688560e7c14f54e4ed9ff9520839dd72b686b1407ce5c22d535a10e2a9dca9a8a944ab0152e9799b683eafef583dee3a0d9352142b44742000934e6c02136ba6b634284ec6a16480f6fe1cbdc4bc7256960d245da7a09c5ffe6ae9ac2e4596230842277440e41b503dfdb6db1c028defc544e8fce196e51c3993fa78413387841b373bd9d55e9e7358c1732fa9a202a1d17018d7607b080b3bb87d7ef9871812bd36e72433e89ca0e231498af795767053587239c462c6fbd734661ea0bfe834323813b40a956b6b0492c5fd2913137c7071ccf77a8083e4397d3dfd55525f7a19e95e0f5b278a9f23fdd0d7b130681a509d2663db5958051886c93ca4ac5f5dd90127b2f2a497f516c25549922d8c681f30bb730e0839585c6c2ba1d1c0222c7ff7db1c5ca38edb9ad9d4e92a5e1c9085918982b5e94364352a6e9d1ffdba08130cc10c70bb6e32a5c5465afcf3a52a0c30461b80111a1cd6a4e2f28107902059bc9a0be6d9c2e5c868a9f94db93e042913ed4730702220e5cf22b2e61dd8dca6e8b880d8f2c97616d96236d989f4dd283bd493f14d9c1f7236ce23f22a659360315b76b91869b208a8cea2cf080b3920dcf750cf4bfb7b09219a976aee4815a7a20b29700bfe3ec5a10acb6ca7e561fcd64b7b7e53afc68544ed871aa2b1300e95ec2ac39f5291f306ce27cae5d590486d457fdd0aeb5ca3e2c4a5cf0a612aa4a9c69a3aa3274931557589345bf2f03ef40750be0f360aa75e2d4eeca328d0e913c22c2a33dce5ed4b6cd311dc9a3e7b35ca0da31b6f5855911e2409c79d2b581037174a8a1f1e88799a5cfc43570c3ea010a41478b394ef53fbcdc3c5d1336278468c6cc91d74c6e9','sync','ak',0,0,X'679577bdbdda37b15de9cba129e23e549b1a004c','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(46,540009248.73954999445,540009248.73954999445,X'3c585604e87f855973731fea83e21fab9392d2fc',X'83cb86811c2df44980ceed332adee9447b9031e4',NULL,1,1,1,X'832e0d541a80ff89ba43bd71ef289c78d435b8ed',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000002c6452bb76182baeaae87e602f1c927538057137b86dd9a3f21524341a75dfe1fffffffffffffffff3dfc120ec4cdcfae5ca3c3111377ed552fbc9ab4361d00da5bb528c60a08f7abf757fc3a6d5c46aa8ef73ea15ff6fe52b1684240a5ec9db7a2481a295f476440fb77d93464dff613e23cba9ef4297272c9a4d313336fec9eb1ad435626360bccc2059fa68668951cf0263f6dd08f9fc5ba0e4ed5b5e717e4668e7dcd5b473fbf23a092a81ca6c7a6a1ad0ebd12461c75357b913ab12a0e37b1ad28c390ca5b6508a5cfa98e5b090a4d8dd3880aad5c50d25e79e6e1b3adc30dc9bddf6148a53207ef8f39a3d53cfc302655b1c9acce9a113e51ead4668d7789ba02e9c05e8ecd65f70db8c5a0fb4653f895218c10f871a3acf2e9956f9ad5bc2cc80ee67c40e606f5f90002e88137095fe069c2035fa55151acfafd8d2cddc111f66bc10900e37f21ac405cd2bff4b7209aa454cb3f78f8f152fb9a331137f9f25c8f260a4a63133ce6e973dca7804fc83d8617bdb564e6c8a8c6c31c6170d7661314841a9b180f79a6296570585fd7e7f1123ef822ec214e5ccb404af4257b4d318e6ff2dab782d590db23f8e422005d77a26c7741fb964c9ec7bf1865bdad7a861496100dc414d82fb74d8b5cdc69a4729e0e959ef800760d87bfc876ed0025edcc78d2744f11d855f2b4760a6c8c674ac7d3422228da1fe0f259032c0d6cbc1894c74369fa6f6bf4bafa890d29782ba78d795c280336186a35aeec3ee8b979702c1e322fec3fa8814fa1f902de6f7166415c8a986a1bac8c07c9e7a3f5885454da8c800eef1ea71f9e74fb3098dfdcf6cc9a98018342b77f17f65d72af9efac3dc79649a04be2c9e6038053e4fd15a0ba8a4f06961c34eb50a4fb7231d9c44dcf9ad428f19e2d9ea36c4e4ad679f279949074e8f359a486df12d6457fc4f73c2438525ee06ca0da504ef4882d0c2eee9443a44c9932d437a0c5ca1caa6af4f80c89f036dfe30ac8cf09d4552729c0849ecd8d0c42a6eb260567f61dff894ee58b2e737b15a0869d025b99877c31ab3ae814ac68e2608417c97507e13ca39f8194f75dd43a2c6c9a132f76bf8c3afd096597177bfd6e7477e9e1f7195c0a1351ccf1221460012e8afcd84087af13448ecd58e9fc69c8d3d0d7ac387f39deace14c181af17d3d121c19d9ed1be882f16de4236b255111a4b01be66aaf0dc44f26b05c6a6f4b631f33f1fd0261a5e6f100197c13df31a69d13ab34d4e7d5b6c7cc1b742be71d66b290002b0dabed9e5311c0906eaa3a514cec627b4773be530b6182ad50065ad9dd251bacee41ef3523500f567cf56a17f5641bcce8a44b54c322ac15f73bc1b6a264716ca1d468d7b8afe2f9e44517c0c80d33afd3c1588f3a7659ab1053be61a43e8ffc57e99ed5d250425790e0bb466f682dbbdf6c7b5ba2a1d8c2db340ac26e76644550d4a317c850dda45c37ef03f71d2a2d5c84ae7168c854e315fc23ead9ba35e578126abe230180c5473ff452928f1809fe9b5f850b0fad0e4762d1cd90977c5b2b5eebf5c99480e4d12bad61b5fca96a01437cfc4d82f78b27c52698f5eb3216f82afaa7bbec8d5ea18b688271b77bca1b45bf7f7390457f350ff895d08383e9','sync','ak',0,0,X'18aa6c2f5a8e9b62507da7704d23e9be20024dc6','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(47,540009248.76412105561,540009248.76412105561,X'3c585604e87f855973731fea83e21fab9392d2fc',X'e6aae5fcf4d720683edab9804f620cbc0844265b',NULL,1,1,1,X'd27cb1777d93737af194a9519993b10547ff9fb7',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000c170a23ce3d3cd4a1222c03f0ea8890166c00c93164e1983fd7909aca50e2ae8ffffffffffffffff7b3317adc49eb302a6a2416ccebc3ed650c60e631280173b752976323a8d490396416881182cfe0387f7959197159b6c7b0df1ace555b516d36b9c5228e0b0025a0c7d201b0748edf9998fb088c25e03066c0cb20792b2b07e79e9c02733f40afa59a7f9105c8ac42f97a9e1f4e80a19acb08eb5ca5d0a30903c6f679e4d9be4d454638383349df0a2e4cead880e0832015fe07cbd06375d871cb032d83275ae059ee97c36e405f682bc011259350c85c752bc61ce592fb61de41e3179226506c3fffd9da27132b2cb71f9d49caaf5a1e99f28c1f3928c89bd0188525506cb163482d7b7cefae89bf34fb3a8f866b8f8bccec971bf712b6f9d4ac9d78f30bb0208530059745daa284947c12a87ced30c553a23fd9eed2fb5d96ffd76b48d383e529afbe2e8ea55b80ee31b9f0d8226e6f35ba9992f76f6ab95489ef9c235c099d6e56e5b6b680fc6c5658e5d897135f7db2205710db05eff5c37522eaa673b02a14efd84d014ca7a64f0c6d71907fd685cf3ff979a97c31310eb92f630fe90c49afc2969698aecdeaa4f915cd2929bfe93162c45ec84b17e8b2f12f6cbfb4543b783c7fccf98c561c16ab194cc2c1d4904ca42c000233bbbdf5ddb02f64a49559f8bc2cef64b546dbff37d2cdb2968c1aeb180b9f763e5e29cc7f707c3366bfe6d504209c779d3327b6feb57eb4f886d99018b9bdee2ad48fb6d30268983c798c548d710ed013ff46ab2b14d8a745933d63db4fd182fac03f59cda95be57bf25545a34b08e3549466bfe6963a64d6b0ce010cd71deb6329166d009a7c5a026bb7f6a83886da9d80f47cb76e19a65944d45167d9f8315336d0f88049cc3b560d6607594b809fd8bfd7e061d8d9f1ca89bea2550c7b2f888b262097c457925f8da3e3e0fe7453f933aef93bf37691fd7d7f7acec3ae246a3d93caad8d72585eaaf4328a6ae042a83789f7c2fbedf8bc3a42ded6ad17326d04cf5595bd24ef6c7cff212f4bbbd069c8f4fad6890018450834c8f0b6119f7ec11b67d1228e3986011c951c170fc374a61af04d4cccdc3fdd72620556211f08dd44d75dcf809001f3a1996c523c07543c8bd7c0290c69d93a6201ce6b23bc0dff840bc4782c4ad4f4d334e8b768749f092f0fb328165632b0e466bfe85e9631c977df38587eefb18c960029fcc6220bddbc071b71533cfd4cb973521ea195c5457b60d6a408dc8f2b8045b41591c6d90da2181f08ec5aed48189414e3f85f24e8035e52ed9d0e774a8222d7090bbd3ced9b447317d5c80a2dc51cbe443d3eb68011ee2e5f5e48750da4734cbb4bd6232738263c08697622c272bef6722455738b8e1785c20201ef6665b63f5cf5a4387f2e7eadaf83640f2f07008e122f68fd57cc8973242f6f1b46fe677b0dc2729afb0cde9f2b1fe493bf732b0d6de893cce154768da1c2bf6e452ad94ee7bd1838beb6965506c11084f5ce5b93f35a78f13f1f943d59d03147105c212d9a91164e532fe5f1f48d60370a8342a6a4a793ee7903bf063de906ce5ed1ee6e1c4665af81e6d64d46a56cdac678194e6712365108261f4124b36b8cf4a2f21e5a9813b0d','sync','ak',0,0,X'd8f8ecd1e06ddd14fae661920e8162abd41b0b2f','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(48,540009248.83140194415,540009248.83140194415,X'3c585604e87f855973731fea83e21fab9392d2fc',X'416a44e9737de60ae5c6a67953c9aa481883d378',NULL,1,1,1,X'2ceb76e29c9442f200885895f43473ccdbb99288',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'0300008006000000280000005c6781d080530e1375e46ab826888d940d01cae875642cdddb7314631a1e51c9ffffffffffffffff9333f1e3f9c38f3cbd865a2ec3078250ec6629b85f5cced15a761c5040cda8d9671c6199c476606521fdd74a75f2576901071e9c9fb683be514e51c128aaa77d9f12f36df8b87aa18f2a39af838296cfdf575e84ae3072f683c5885259beb38371d7c2392d51551fbfc63f274e5064c41b4f70f89aa97dc5f44987e14cab51589bca96bdc120a2637b982f79dbb24b1b717a23cd34d48c1545be0d86c0261bf3326259dac7d68e2a2c1d514433c11b1528ed4854136f9a779bf91eb319312249cdfde3bcd236836d722d357888a668145d68a960bcce4ae6b601a34ba655370570c6897a30294933f6e1c1ce8dfdf20404e73cac04698733be9811a5148403eb692ffd07ec6e2faad3544b742f4f905202a59e78d27339dc800d409c1d30ee55b3dd768ab4ff0d7f646f59af90e58b569f7d12dd52bbe31fc9c0ab7b8e99882c5ef86c426c03d4348aa0c9b458edfb69d0f7514f1827bcdb181c77d3e3417d7db2df1c145f5e45766a2bd4fe1d45bd5c2d191645dd644660087751feeab03d453063342b0ed60f4f47ac811d8e3b03592b10990f634a5f5dc00723f47f784870863064942f707928ee8d046d14a2b7e379d3bb8227e254a9a01d8b2c2836ba10b8303e4eadce068391b258b3f0fc9e9ba607e0fb41d2ef254f2a0edfc71dfb95cf56e16fd45db825bc0334c447a4a630ba3323a4859dee02e0eb4f0a6c4b977e7b26014ba32cf6acf7c4689ba6899624783e0c64dcc875121eeba60255ced4efa20de602952040d9170dfb2728ccb1185d209d326f28c60291610f7821adc79ffc4a978a9e211057cc8a476a6f666401b95da1b744cb0384c918fe29ded64026e6b5fce99cb20ab221d737718717153f3dc557b1c1437cff61b0c9e5a9d92975b090f4a49f8e09a01032d76db33f9d90172600db2ebd777f9c4fb265d1885c0a284b636c6c74c0856ec0c0f3e2660072c68e37c25561cfefcf6a17fb7fe883e7ade402d22f8f8c122298b0c855d4a733341f2e911d0898c479264ebc27e06fc859ebbf050db5f93e45d28168debab0e7b365bc71d7353f4a9ab121c382b8c88e7f815200a7335159ad62c7fbfea8edc7a73ef1a487f278de69067709f5440cfa49e361e2ed0e21c9136ad72312b03dc8e7324d79806d587ef5727dc74c3f6cd310239149b72371ba07a2b6d0b1c5e2d3a0ebef180248228c6135911c5fc9815fe33f12f3eadd46499c184fcf512a8de2ab158a051984aece4c7f06bb0b6ae0ee0e6da8c97f30d9169c20b5346e557b5c3858db359a048616c61d27b50d661f0d95e5befd18a6a7c29fd84280ebb3bfb7a45498866972786e187d6e4c45275e884f4bde2d4af48f655e46cb1c3539f1c2b55229ef5b47f173ef603cb8a10710ff97b49815ceffe96207565c82de39c4f0caf19d514a2d914192d60881aef1a412c553bfe481cf3b94db57b16393a5cb55c723aee7f3361a52feb80f1682b9d126feaef5bbac6bd5c47822a156d892eacc94fe2f0d91cea7738bab503b626af674dcc1177317e9e2b58719c91d77b6dcc7dc5525c4000cc8cc36323f0a3ccf46c199f8ca475d59841a34','sync','ak',0,0,X'e400d1472cde60a637898b247a3cfe6e385b5d19','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(49,540009248.87445402146,540009248.87445402146,X'3c585604e87f855973731fea83e21fab9392d2fc',X'6634f5d1c2b1cb7d347d3e9a38ec7f7c5fccb905',NULL,1,1,1,X'427e71398059645d6e9f92db62204320c200cabd',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'030000800600000028000000ed106bf0ae12db4c11621e6d8690bd578ef6f58158670286fb027e370fca5ea5ffffffffffffffffa2d533c2fafd900a257a464d6b3a700a99133cc8e1cea0018e6a8932cefe8e997217f3c23c6c7675025a50c90e7ce733797103387433f57757bd3ba48cdbe1646cb302dcef1ad7cad96ca080efe4762a93b290f43b4dedfc9b74fe2d089a2411b780e2b253f789d905c76d2a4c5844604fdf687e89e2db428c87267dec1a18fba4e50ab30a3a789e66604ae858f307cb99d488d136f89a8aeaa2641a217769646b47cc7afaf7d994ca1ddd2c76b07af4266c0ecf53db58f1f6800ff6fe426f4767646378e91ba2ae9d7228a6e8ec994d41963d15314970bc791df5558ef6fc6655a0aa2d149eb3789cabdd6de95be2c8693e6dd14cfb130a5f0856a9f6863064a0d38fe1a369919c9b8e898eeec286fa04a0f279fbcf3273adfbf3013a375f70117b526d98326bbb0b06aa88a0ba8fe6c45645da7012f8ab88eb28608eee9fff6106e3d3c200e0660190d30728493f1ec08ca8e7692fb94bd3a580f138aeee2dc71cd7d94631acdb0372bf670575514de4f4575d58c7b54f7709f2d0f8be6d517faac1ea1dda117106bfe8fb8b1c218180b050873b9af4a2464aad0385d5e509d69c647684f2babeb58f4ae01972c1f92e5839f6244a3bb7beaba845bf74e3edd6fdbf2c19b4ff6473686fa7a10e86d2053a4a22f7a2b65ac7a13fc60d5941a1b750aefeb1fa34f57f1d2ed3e0e65b15b5f0eb20784fd81fefdee3f8f94d33d74708ef7514c404ab7cdafabc0b6b46bdcd9cefa8d27f99771d5bfcd71a0476e145be30b134680531a4a7035f4aa297c9c74f112fc9c72f40597ce148678a269d0307dbe1bf36f31241270a2812a3ee6622cf98fc572ef9ab3c314866898549cb08dbff09bc9b8516a7aad4f0ec1db11c299b3b9459daddf13c63b51a4c40f882a4717cae396809893cc9625c38e9da0ea382129797ae9900a00a83f6e6aa5488ba51f1ea69384a090e5399f03b8ac14e8157d527bfdb999b4613ce384555602d0652440160dbb04afa8176c5019617be600bb0d2d05c9f8c54681c49573218c597701d0cedb0fb6f3bdef553237e152e98105169b97f504b0a89ef7b5638b677b97ddf3e94b0bb9cd8e0986a027da596a8dbdde42dfd64acc80acc394da394d83b8fe35a8bbd08e3e5284dc12de7654fdfe68a8dd8bea3dc9b640ab67b74cabceb2d2b7e50269dab0c9d5f661b122e818ba8a449d65b60eb23d515c20043ab9b7bc8a1d08bb7a6810dfca3ae5f22f67ef05db21fcb73d2d3769534f78849d6399dfdf3c8408b92eda7a453cd6a494a683321aefc689db232e403a8a39dc48dd46a46bc39ed3e4572f994ae0a2e79da2f4ff36fc25185872ea90776e6094c4483c4db952a5d3e10418c9d1d7c98cce7a2e4e2b1f04582ccb670c8a85ceea3c8041695f8ae1e070eb909fbf6eee0667f2f67d4e3546d638f6896eb39221d2f91144ef6a738cb0123ff54193ed01ef0a89433dbbecaf749fc555ae6bd6894039e4b2a3254074bb03798420e5d85b960a41b8a3649b50a1ce91b62ee3767c58a4fc9334e2341b24592e4309b6422dd8d642ab55c4b45aa4f6b65ee4b55c47d06bf4453cf7f98db35d6','sync','ak',0,0,X'202d96072affd57cca755b6610b5ac69b33cd5b4','','','',NULL,NULL,NULL,NULL,NULL,'');",
"INSERT INTO keys VALUES(50,540009248.93132698535,540009248.93132698535,X'3c585604e87f855973731fea83e21fab9392d2fc',X'73264e5a2eda14e1e8f06b4f6cf1342cc547d0cb',NULL,1,1,1,X'8e5f6694686a1bd054c113e7538bb416db138b27',X'da39a3ee5e6b4b0d3255bfef95601890afd80709',0,42,1024,1024,0.0,0.0,0,0,1,0,0,1,0,1,0,0,0,0,1,X'03000080060000002800000044928bf95f52dcabe33d7e16a7327095662a93ded1c4bc41faf3f6c728026004ffffffffffffffffe012d14f1ab701f72d25a9e2e74ba3bd31bb1719352485685fadd036695d0ef868f06a0aaba70a802486a4f9e8d1ea2f63ce195864547067baf38d87acf494354ec01d90aa72b03dd039cc2135361cb48985d5b5ee5aad88fe46572a4c8d8412788e99344f53df110ef8d4eed7138f671f6dd311877ec97513817f598c51febe4b5b0b6f6cb354e3adfbcd68bbd17f058e356fd1f9ed7ba2db647f504ce056d4186b08d82e7bc95cb23cb173d3d3121b1c22ae6636b58a887139b4e4406a39f5a5ba719ffd5951cbbe34d529f5b892168a031eacbddaf53b80b0a3592eec556d3acb04dd34509c506c137fe4b03f7584b306691f5ce303db471a2b5a7a54af594a5b7f057717cc927dadd6daed6e037e12f3f3bac38a42198d32930445a608558bea544349a5ab2e20949279e828e9b7e977738beabd3dbd3ab06f8af936d24cba677b204552738444ddbb3b118207041f93598db6a271ba936fe32eceed10d4eaa1496816c5c04d55ad57db909be2fda9bddc4de72078fd6440cffc7221067706cb614a906b0d447adc0679f5861c6965f2e8cf8b5af5b2a4b511b985670df87d4c89849abab347fd60172c376b82140808c2545a7b639533a18e743554a21a96424153fadba500a4eecc6409b0ea3cb877d18f5394a5dbb0e811ba519c39538eee8a87dfcbf0637a5ce6c86d7623065fe604ea7d0134a8a3bcc23f1dec9d033e8dfd9428352a9dcadccc21b37c4819dfa1733e26e3ac289997ea4bf4417963a21236e58a16e21dfad23ca73fad2ecbb6df092c27fcb8e0ff0727cecbcaa0acb33146b289de227d6091c00fb865743a6c5c3c4cc4df20e85a90dcd7041491e806d62550aaf587f842df99a170653ecbe451b3f7ae97bcbe7a2b8c905d745d5416a1c5b1a5388bdc51840a236a8c8a83464e7777443c4439e17ed2e3a4c6d0379fd369d18d99f15dc2dbcd5d17a50ee9b6373d5d3aeb5ac259dd513080766316f3f0805012fbb42fecfd26aa21404c71774aa8c28f9fa152ac9ad5d6fed40108e3a6031e496d943d499e0a8b43c2a05f20626aa5b4a801e2a1599d605aa2ca3a175d00d6c65de47f923528aa27c10d58f393c6666116eb5172a183184b0ed2efe8d79723cfec337ebf5cd45d4bac7100d32b62b9fadc32cc2f3e3ee9d9592de987173d81dc8039b8a8c7c0a81787763d2a0872547c9435bcf5a782de938a6e68a47cc47e68872d9f065116726949b741a0155b9d8020ac80518fc3439ca2a6d3ef4e6e588dc0c1b3cb3827419f8dce75bae26791f33b453dda74a96ed763e2ff711afd39baf27f6adf33fd055204bef80ff117c4170f2e73e7d5f0e6f8b4aa5c76793105f5266e6de64e3debe92fa420086fb9092f116c546b87b991ab73d2e486c605cdcdae9fbaa76772676c1fcda8aa47f220c2c7acc765b85fbdcfe48bfb6659b93fd515053090d6bb5b5f73a986acfd3bbc648434385b86855a8058fdd339de9dfed795435b9b594d19632c1f1f2ed127f3ce1152c1260953aa1a44be439bb24659cd277538f26af49b5b366cc43235022afd7847739102b486fc33353d41c8f768bf08','sync','ak',0,0,X'830dae8c17a3805e28c99f99695c2890274ccca4','','','',NULL,NULL,NULL,NULL,NULL,'');",
"CREATE TABLE tversion(rowid INTEGER PRIMARY KEY AUTOINCREMENT,version INTEGER NOT NULL,minor INTEGER NOT NULL DEFAULT 0,UNIQUE(version));",
"INSERT INTO tversion VALUES(1,10,5);",
"CREATE TABLE outgoingqueue(ckzone TEXT NOT NULL,UUID TEXT,parentKeyUUID TEXT NOT NULL,action TEXT NOT NULL,state TEXT NOT NULL,waituntil TEXT,accessgroup TEXT NOT NULL,gencount INTEGER NOT NULL DEFAULT 0,wrappedkey BLOB NOT NULL,encitem BLOB NOT NULL,encver INTEGER NOT NULL DEFAULT 0,ckrecord TEXT,pcss INTEGER,pcsk BLOB,pcsi BLOB,UNIQUE(ckzone,UUID,state));",
"CREATE TABLE incomingqueue(ckzone TEXT NOT NULL,UUID TEXT,parentKeyUUID TEXT NOT NULL,action TEXT NOT NULL,state TEXT NOT NULL,gencount INTEGER NOT NULL DEFAULT 0,wrappedkey BLOB NOT NULL,encitem BLOB NOT NULL,encver INTEGER NOT NULL DEFAULT 0,ckrecord TEXT,pcss INTEGER,pcsk BLOB,pcsi BLOB,UNIQUE(ckzone,UUID,state));",
"CREATE TABLE synckeys(ckzone TEXT NOT NULL,UUID TEXT,keyclass TEXT NOT NULL,currentkey INTEGER NOT NULL,parentKeyUUID TEXT NOT NULL,state TEXT NOT NULL,wrappedkey BLOB NOT NULL,ckrecord BLOB NOT NULL,UNIQUE(ckzone,UUID,keyclass,state));",
"CREATE TABLE ckmirror(ckzone TEXT NOT NULL,UUID TEXT,parentKeyUUID TEXT NOT NULL,gencount INTEGER NOT NULL DEFAULT 0,wrappedkey BLOB NOT NULL,encitem BLOB NOT NULL,ckrecord BLOB NOT NULL,encver INTEGER NOT NULL DEFAULT 0,wascurrent INTEGER,pcss INTEGER,pcsk BLOB,pcsi BLOB,UNIQUE(ckzone,UUID));",
"CREATE TABLE currentkeys(ckzone TEXT NOT NULL,keyclass TEXT NOT NULL,currentKeyUUID TEXT,ckrecord BLOB NOT NULL,UNIQUE(ckzone,keyclass));",
"CREATE TABLE ckstate(ckzone TEXT NOT NULL,ckzonecreated INTEGER NOT NULL DEFAULT 0,ckzonesubscribed INTEGER NOT NULL DEFAULT 0,lastfetch TEXT,changetoken TEXT,ratelimiter BLOB,lastfixup INTEGER NOT NULL DEFAULT 0,UNIQUE(ckzone));",
"CREATE TABLE item_backup(rowid INTEGER PRIMARY KEY AUTOINCREMENT,primaryKey TEXT NOT NULL,musr BLOB NOT NULL,sha1 BLOB,backupData BLOB NOT NULL,pkhh BLOB,UNIQUE(primaryKey,musr));",
"CREATE TABLE backup_keybag(rowid INTEGER PRIMARY KEY AUTOINCREMENT,publickeyHash BLOB NOT NULL,musr BLOB NOT NULL,publickey BLOB NOT NULL,agrp TEXT NOT NULL,UNIQUE(publickeyHash,musr,agrp));",
"CREATE TABLE ckmanifest(ckzone TEXT NOT NULL,gencount INTEGER NOT NULL DEFAULT 0,digest BLOB NOT NULL,signatures BLOB NOT NULL,signerID TEXT NOT NULL,leafIDs BLOB NOT NULL,peerManifests BLOB NOT NULL,currentItems BLOB NOT NULL,futureData BLOB NOT NULL,schema BLOB NOT NULL,ckrecord BLOB,UNIQUE(ckzone));",
"CREATE TABLE pending_manifest(ckzone TEXT NOT NULL,gencount INTEGER NOT NULL DEFAULT 0,digest BLOB NOT NULL,signatures BLOB NOT NULL,signerID TEXT NOT NULL,leafIDs BLOB NOT NULL,peerManifests BLOB NOT NULL,currentItems BLOB NOT NULL,futureData BLOB NOT NULL,schema BLOB NOT NULL,ckrecord BLOB,UNIQUE(ckzone));",
"CREATE TABLE ckmanifest_leaf(ckzone TEXT NOT NULL,UUID TEXT,digest BLOB NOT NULL,entryDigests BLOB NOT NULL,ckrecord BLOB,UNIQUE(ckzone,UUID));",
"CREATE TABLE backup_keyarchive(key_archive_hash TEXT NOT NULL,musr BLOB NOT NULL,key_archive TEXT NOT NULL,ckzone TEXT NOT NULL,ckrecord TEXT,archive_escrowid TEXT,UNIQUE(key_archive_hash,musr,key_archive,ckzone));",
"CREATE TABLE currentkeyarchives(key_archive_hash TEXT NOT NULL,keyarchive_name TEXT NOT NULL,UNIQUE(key_archive_hash));",
"CREATE TABLE archived_key_backup(pdmn TEXT,UUID TEXT,musr BLOB NOT NULL,agrp TEXT NOT NULL,key_archive_hash TEXT NOT NULL,archived_key TEXT NOT NULL,ckzone TEXT NOT NULL,ckrecord TEXT,archive_escrowid TEXT,UNIQUE(UUID,musr,agrp,key_archive_hash,ckzone));",
"CREATE TABLE pending_manifest_leaf(ckzone TEXT NOT NULL,UUID TEXT,digest BLOB NOT NULL,entryDigests BLOB NOT NULL,ckrecord BLOB,UNIQUE(ckzone,UUID));",
"CREATE TABLE currentitems(ckzone TEXT NOT NULL,identifier TEXT,currentItemUUID TEXT,state TEXT NOT NULL,ckrecord BLOB NOT NULL,UNIQUE(ckzone,identifier,state));",
"CREATE TABLE ckdevicestate(ckzone TEXT NOT NULL,device TEXT,peerid TEXT,circlestatus TEXT,keystate TEXT,currentTLK TEXT,currentClassA TEXT,currentClassC TEXT,ckrecord BLOB,UNIQUE(ckzone,device));",
"CREATE TABLE tlkshare(ckzone TEXT NOT NULL,UUID TEXT,senderpeerid TEXT,recvpeerid TEXT,recvpubenckey BLOB,curve INTEGER,poisoned INTEGER NOT NULL DEFAULT 0,epoch INTEGER NOT NULL DEFAULT 0,wrappedkey BLOB NOT NULL,signature BLOB,ckrecord BLOB,version INTEGER NOT NULL DEFAULT 0,UNIQUE(ckzone,UUID,senderpeerid,recvpeerid));",
"DELETE FROM sqlite_sequence;",
"INSERT INTO sqlite_sequence VALUES('tversion',1);",
"INSERT INTO sqlite_sequence VALUES('genp',50);",
"INSERT INTO sqlite_sequence VALUES('keys',50);",
"CREATE INDEX genpsync ON genp(sync);",
"CREATE INDEX genpsha1 ON genp(sha1);",
"CREATE INDEX genpmusr ON genp(musr);",
"CREATE INDEX genppersistref ON genp(persistref);",
"CREATE INDEX inetsync ON inet(sync);",
"CREATE INDEX inetsha1 ON inet(sha1);",
"CREATE INDEX inetmusr ON inet(musr);",
"CREATE INDEX inetpersistref ON inet(persistref);",
"CREATE INDEX certalis ON cert(alis);",
"CREATE INDEX certsubj ON cert(subj);",
"CREATE INDEX certskid ON cert(skid);",
"CREATE INDEX certpkhh ON cert(pkhh);",
"CREATE INDEX certsync ON cert(sync);",
"CREATE INDEX certsha1 ON cert(sha1);",
"CREATE INDEX certmusr ON cert(musr);",
"CREATE INDEX certpersistref ON cert(persistref);",
"CREATE INDEX keyskcls ON keys(kcls);",
"CREATE INDEX keysklbl ON keys(klbl);",
"CREATE INDEX keysencr ON keys(encr);",
"CREATE INDEX keysdecr ON keys(decr);",
"CREATE INDEX keysdrve ON keys(drve);",
"CREATE INDEX keyssign ON keys(sign);",
"CREATE INDEX keysvrfy ON keys(vrfy);",
"CREATE INDEX keyswrap ON keys(wrap);",
"CREATE INDEX keysunwp ON keys(unwp);",
"CREATE INDEX keyssync ON keys(sync);",
"CREATE INDEX keyssha1 ON keys(sha1);",
"CREATE INDEX keysmusr ON keys(musr);",
"CREATE INDEX keyspersistref ON keys(persistref);",
"CREATE INDEX item_backupmusr ON item_backup(musr);",
"CREATE INDEX item_backupsha1 ON item_backup(sha1);",
"CREATE INDEX item_backuppkhh ON item_backup(pkhh);",
"CREATE INDEX backup_keybagmusr ON backup_keybag(musr);",
"CREATE INDEX backup_keyarchivemusr ON backup_keyarchive(musr);",
"CREATE INDEX archived_key_backupmusr ON archived_key_backup(musr);",
"COMMIT;",
NULL
};
