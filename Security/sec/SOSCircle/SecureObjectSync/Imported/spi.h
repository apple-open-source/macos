../../../securityd/spi.h