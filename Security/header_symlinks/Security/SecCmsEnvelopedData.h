../../CMS/SecCmsEnvelopedData.h