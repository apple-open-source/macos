.././../OSX/libsecurity_asn1/lib/nameTemplates.h