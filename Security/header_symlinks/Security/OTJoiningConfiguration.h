../../keychain/ot/OTJoiningConfiguration.h