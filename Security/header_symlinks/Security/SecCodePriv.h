.././../OSX/libsecurity_codesigning/lib/SecCodePriv.h