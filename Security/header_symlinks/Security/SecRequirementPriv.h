.././../OSX/libsecurity_codesigning/lib/SecRequirementPriv.h