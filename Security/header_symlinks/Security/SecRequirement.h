.././../OSX/libsecurity_codesigning/lib/SecRequirement.h