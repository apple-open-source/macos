.././../OSX/libsecurity_codesigning/lib/SecCode.h