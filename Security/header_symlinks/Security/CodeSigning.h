.././../OSX/libsecurity_codesigning/lib/CodeSigning.h