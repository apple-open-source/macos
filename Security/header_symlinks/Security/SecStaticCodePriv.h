.././../OSX/libsecurity_codesigning/lib/SecStaticCodePriv.h