../../CMS/SecCmsDigestedData.h