../../trust/headers/SecCertificatePriv.h