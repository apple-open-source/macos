../../..//keychain/SecureObjectSync/SOSCloudCircle.h