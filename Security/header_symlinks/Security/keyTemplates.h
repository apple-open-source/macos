.././../OSX/libsecurity_asn1/lib/keyTemplates.h