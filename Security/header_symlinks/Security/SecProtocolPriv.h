../../protocol/SecProtocolPriv.h