.././../OSX/libsecurity_codesigning/lib/CSCommon.h