.././../OSX/libsecurity_codesigning/lib/SecCodeHost.h