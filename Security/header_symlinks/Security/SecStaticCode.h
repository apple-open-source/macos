.././../OSX/libsecurity_codesigning/lib/SecStaticCode.h