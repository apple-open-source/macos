../../../ntlm/NtlmGenerator.h