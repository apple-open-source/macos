../../../OSX/libsecurity_utilities/lib/casts.h