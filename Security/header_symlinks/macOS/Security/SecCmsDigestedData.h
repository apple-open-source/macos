../../../OSX/libsecurity_smime/lib/SecCmsDigestedData.h