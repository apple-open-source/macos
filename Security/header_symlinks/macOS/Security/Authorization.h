../../../OSX/libsecurity_authorization/lib/Authorization.h