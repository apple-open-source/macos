../../../OSX/libsecurity_smime/lib/SecCmsDigestContext.h