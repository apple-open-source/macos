../../../OSX/libsecurity_keychain/lib/TrustSettingsSchema.h