../../../OSX/libsecurity_asn1/lib/asn1Templates.h