../../../OSX/libsecurity_smime/lib/tsaSupport.h