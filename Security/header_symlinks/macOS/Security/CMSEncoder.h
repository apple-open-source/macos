../../../OSX/libsecurity_cms/lib/CMSEncoder.h