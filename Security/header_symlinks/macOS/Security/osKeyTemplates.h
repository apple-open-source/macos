../../../OSX/libsecurity_asn1/lib/osKeyTemplates.h