../../../OSX/libsecurity_smime/lib/SecCmsSignerInfo.h