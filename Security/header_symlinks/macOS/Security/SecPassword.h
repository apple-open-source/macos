../../../OSX/libsecurity_keychain/lib/SecPassword.h