../../../OSX/libsecurity_checkpw/lib/checkpw.h