../../../OSX/libsecurity_authorization/lib/AuthorizationPriv.h