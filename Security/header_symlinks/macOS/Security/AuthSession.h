../../../OSX/libsecurity_authorization/lib/AuthSession.h