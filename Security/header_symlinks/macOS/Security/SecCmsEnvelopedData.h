../../../OSX/libsecurity_smime/lib/SecCmsEnvelopedData.h