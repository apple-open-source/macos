../../../OSX/libsecurity_smime/lib/SecCmsBase.h