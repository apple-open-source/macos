../../../OSX/libsecurity_keychain/lib/SecTrustedApplication.h