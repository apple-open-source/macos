../../../OSX/libsecurity_codesigning/lib/SecCodeSigner.h