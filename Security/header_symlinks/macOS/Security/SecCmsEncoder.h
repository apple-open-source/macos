../../../OSX/libsecurity_smime/lib/SecCmsEncoder.h