../../../OSX/libsecurity_asn1/lib/ocspTemplates.h