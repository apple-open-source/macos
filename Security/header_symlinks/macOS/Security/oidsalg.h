../../../OSX/libsecurity_asn1/lib/oidsalg.h