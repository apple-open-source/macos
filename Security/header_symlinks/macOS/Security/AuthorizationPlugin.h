../../../OSX/libsecurity_authorization/lib/AuthorizationPlugin.h