../../../OSX/libsecurity_smime/lib/tsaTemplates.h