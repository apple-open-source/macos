../../../OSX/libsecurity_manifest/lib/SecureDownload.h