../../../OSX/libsecurity_keychain/lib/SecTrustedApplicationPriv.h