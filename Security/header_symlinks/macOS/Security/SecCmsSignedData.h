../../../OSX/libsecurity_smime/lib/SecCmsSignedData.h