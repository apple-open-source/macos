../../../OSX/libsecurity_keychain/lib/SecRandomP.h