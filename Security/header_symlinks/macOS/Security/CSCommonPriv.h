../../../OSX/libsecurity_codesigning/lib/CSCommonPriv.h