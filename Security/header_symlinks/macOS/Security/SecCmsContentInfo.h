../../../OSX/libsecurity_smime/lib/SecCmsContentInfo.h