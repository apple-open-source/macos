../../../OSX/libsecurity_keychain/lib/SecAccessPriv.h