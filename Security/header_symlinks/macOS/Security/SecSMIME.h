../../../OSX/libsecurity_smime/lib/SecSMIME.h