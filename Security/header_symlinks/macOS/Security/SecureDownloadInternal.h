../../../OSX/libsecurity_manifest/lib/SecureDownloadInternal.h