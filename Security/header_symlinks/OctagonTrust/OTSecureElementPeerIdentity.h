../../keychain/ot/proto/generated_source/OTSecureElementPeerIdentity.h