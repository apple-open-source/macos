// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from OTRecovery.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

#ifdef __cplusplus
#define OTRECOVERY_FUNCTION extern "C" __attribute__((visibility("hidden")))
#else
#define OTRECOVERY_FUNCTION extern __attribute__((visibility("hidden")))
#endif

__attribute__((visibility("hidden")))
@interface OTRecovery : PBCodable <NSCopying>
{
    NSData *_encryptionSPKI;
    NSString *_peerID;
    NSData *_signingSPKI;
}


@property (nonatomic, readonly) BOOL hasPeerID;
@property (nonatomic, retain) NSString *peerID;

@property (nonatomic, readonly) BOOL hasSigningSPKI;
/** as SubjectPublicKeyInfo (SPKI): */
@property (nonatomic, retain) NSData *signingSPKI;

@property (nonatomic, readonly) BOOL hasEncryptionSPKI;
@property (nonatomic, retain) NSData *encryptionSPKI;

// Performs a shallow copy into other
- (void)copyTo:(OTRecovery *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(OTRecovery *)other;

OTRECOVERY_FUNCTION BOOL OTRecoveryReadFrom(__unsafe_unretained OTRecovery *self, __unsafe_unretained PBDataReader *reader);

@end

