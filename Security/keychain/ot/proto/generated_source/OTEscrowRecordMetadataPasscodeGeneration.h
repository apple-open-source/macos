// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from OTEscrowRecord.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

#ifdef __cplusplus
#define OTESCROWRECORDMETADATAPASSCODEGENERATION_FUNCTION extern "C"
#else
#define OTESCROWRECORDMETADATAPASSCODEGENERATION_FUNCTION extern
#endif

@interface OTEscrowRecordMetadataPasscodeGeneration : PBCodable <NSCopying>
{
    uint64_t _value;
    struct {
        uint value:1;
    } _has;
}


@property (nonatomic) BOOL hasValue;
@property (nonatomic) uint64_t value;

// Performs a shallow copy into other
- (void)copyTo:(OTEscrowRecordMetadataPasscodeGeneration *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(OTEscrowRecordMetadataPasscodeGeneration *)other;

OTESCROWRECORDMETADATAPASSCODEGENERATION_FUNCTION BOOL OTEscrowRecordMetadataPasscodeGenerationReadFrom(__unsafe_unretained OTEscrowRecordMetadataPasscodeGeneration *self, __unsafe_unretained PBDataReader *reader);

@end

