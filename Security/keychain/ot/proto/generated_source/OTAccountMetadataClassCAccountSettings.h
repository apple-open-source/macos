// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from OTAccountMetadataClassC.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

#ifdef __cplusplus
#define OTACCOUNTMETADATACLASSCACCOUNTSETTINGS_FUNCTION extern "C" __attribute__((visibility("hidden")))
#else
#define OTACCOUNTMETADATACLASSCACCOUNTSETTINGS_FUNCTION extern __attribute__((visibility("hidden")))
#endif

/** If adding/updating any fields to AccountSettings, make sure to also update the OTAccountSettings.proto entry as well */
__attribute__((visibility("hidden")))
@interface OTAccountMetadataClassCAccountSettings : PBCodable <NSCopying>
{
    BOOL _w;
    BOOL _webAccess;
    struct {
        int w:1;
        int webAccess:1;
    } _has;
}


@property (nonatomic) BOOL hasW;
@property (nonatomic) BOOL w;

@property (nonatomic) BOOL hasWebAccess;
@property (nonatomic) BOOL webAccess;

// Performs a shallow copy into other
- (void)copyTo:(OTAccountMetadataClassCAccountSettings *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(OTAccountMetadataClassCAccountSettings *)other;

OTACCOUNTMETADATACLASSCACCOUNTSETTINGS_FUNCTION BOOL OTAccountMetadataClassCAccountSettingsReadFrom(__unsafe_unretained OTAccountMetadataClassCAccountSettings *self, __unsafe_unretained PBDataReader *reader);

@end

