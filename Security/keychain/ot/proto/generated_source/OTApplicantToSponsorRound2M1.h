// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from OTPairingMessage.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

#ifdef __cplusplus
#define OTAPPLICANTTOSPONSORROUND2M1_FUNCTION extern "C" __attribute__((visibility("hidden")))
#else
#define OTAPPLICANTTOSPONSORROUND2M1_FUNCTION extern __attribute__((visibility("hidden")))
#endif

__attribute__((visibility("hidden")))
@interface OTApplicantToSponsorRound2M1 : PBCodable <NSCopying>
{
    NSString *_peerID;
    NSData *_permanentInfo;
    NSData *_permanentInfoSig;
    NSData *_stableInfo;
    NSData *_stableInfoSig;
}


@property (nonatomic, readonly) BOOL hasPeerID;
@property (nonatomic, retain) NSString *peerID;

@property (nonatomic, readonly) BOOL hasPermanentInfo;
@property (nonatomic, retain) NSData *permanentInfo;

@property (nonatomic, readonly) BOOL hasPermanentInfoSig;
@property (nonatomic, retain) NSData *permanentInfoSig;

@property (nonatomic, readonly) BOOL hasStableInfo;
@property (nonatomic, retain) NSData *stableInfo;

@property (nonatomic, readonly) BOOL hasStableInfoSig;
@property (nonatomic, retain) NSData *stableInfoSig;

// Performs a shallow copy into other
- (void)copyTo:(OTApplicantToSponsorRound2M1 *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(OTApplicantToSponsorRound2M1 *)other;

OTAPPLICANTTOSPONSORROUND2M1_FUNCTION BOOL OTApplicantToSponsorRound2M1ReadFrom(__unsafe_unretained OTApplicantToSponsorRound2M1 *self, __unsafe_unretained PBDataReader *reader);

@end

