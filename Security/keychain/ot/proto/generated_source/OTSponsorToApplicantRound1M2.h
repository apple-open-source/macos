// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from OTPairingMessage.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

#ifdef __cplusplus
#define OTSPONSORTOAPPLICANTROUND1M2_FUNCTION extern "C" __attribute__((visibility("hidden")))
#else
#define OTSPONSORTOAPPLICANTROUND1M2_FUNCTION extern __attribute__((visibility("hidden")))
#endif

__attribute__((visibility("hidden")))
@interface OTSponsorToApplicantRound1M2 : PBCodable <NSCopying>
{
    uint64_t _epoch;
    struct {
        int epoch:1;
    } _has;
}


@property (nonatomic) BOOL hasEpoch;
@property (nonatomic) uint64_t epoch;

// Performs a shallow copy into other
- (void)copyTo:(OTSponsorToApplicantRound1M2 *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(OTSponsorToApplicantRound1M2 *)other;

OTSPONSORTOAPPLICANTROUND1M2_FUNCTION BOOL OTSponsorToApplicantRound1M2ReadFrom(__unsafe_unretained OTSponsorToApplicantRound1M2 *self, __unsafe_unretained PBDataReader *reader);

@end

