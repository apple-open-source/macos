// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from OTAccountMetadataClassC.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

#ifdef __cplusplus
#define OTACCOUNTMETADATACLASSCESCROWRECORDCACHE_FUNCTION extern "C" __attribute__((visibility("hidden")))
#else
#define OTACCOUNTMETADATACLASSCESCROWRECORDCACHE_FUNCTION extern __attribute__((visibility("hidden")))
#endif

__attribute__((visibility("hidden")))
@interface OTAccountMetadataClassCEscrowRecordCache : PBCodable <NSCopying>
{
    uint64_t _cacheTimestamp;
    uint64_t _cacheVersion;
    uint64_t _passcodeGeneration;
    NSString *_bottleID;
    NSData *_serializedRecord;
    struct {
        uint cacheTimestamp:1;
        uint cacheVersion:1;
        uint passcodeGeneration:1;
    } _has;
}


@property (nonatomic, readonly) BOOL hasSerializedRecord;
@property (nonatomic, retain) NSData *serializedRecord;

@property (nonatomic) BOOL hasPasscodeGeneration;
@property (nonatomic) uint64_t passcodeGeneration;

@property (nonatomic, readonly) BOOL hasBottleID;
@property (nonatomic, retain) NSString *bottleID;

@property (nonatomic) BOOL hasCacheTimestamp;
@property (nonatomic) uint64_t cacheTimestamp;

@property (nonatomic) BOOL hasCacheVersion;
@property (nonatomic) uint64_t cacheVersion;

// Performs a shallow copy into other
- (void)copyTo:(OTAccountMetadataClassCEscrowRecordCache *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(OTAccountMetadataClassCEscrowRecordCache *)other;

OTACCOUNTMETADATACLASSCESCROWRECORDCACHE_FUNCTION BOOL OTAccountMetadataClassCEscrowRecordCacheReadFrom(__unsafe_unretained OTAccountMetadataClassCEscrowRecordCache *self, __unsafe_unretained PBDataReader *reader);

@end

