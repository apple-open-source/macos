// This file was automatically generated by protocompiler
// DO NOT EDIT!
// Compiled from OTEscrowMoveRequestContext.proto

#import <Foundation/Foundation.h>
#import <ProtocolBuffer/PBCodable.h>

#ifdef __cplusplus
#define OTESCROWMOVEREQUESTCONTEXT_FUNCTION extern "C"
#else
#define OTESCROWMOVEREQUESTCONTEXT_FUNCTION extern
#endif

/** From Cuttlefish.proto - EscrowProxyFederationMoveRecordRequest */
@interface OTEscrowMoveRequestContext : PBCodable <NSCopying>
{
    NSString *_currentFederation;
    NSString *_escrowRecordLabel;
    NSString *_intendedFederation;
}


@property (nonatomic, readonly) BOOL hasEscrowRecordLabel;
@property (nonatomic, retain) NSString *escrowRecordLabel;

@property (nonatomic, readonly) BOOL hasCurrentFederation;
@property (nonatomic, retain) NSString *currentFederation;

@property (nonatomic, readonly) BOOL hasIntendedFederation;
@property (nonatomic, retain) NSString *intendedFederation;

// Performs a shallow copy into other
- (void)copyTo:(OTEscrowMoveRequestContext *)other;

// Performs a deep merge from other into self
// If set in other, singular values in self are replaced in self
// Singular composite values are recursively merged
// Repeated values from other are appended to repeated values in self
- (void)mergeFrom:(OTEscrowMoveRequestContext *)other;

OTESCROWMOVEREQUESTCONTEXT_FUNCTION BOOL OTEscrowMoveRequestContextReadFrom(__unsafe_unretained OTEscrowMoveRequestContext *self, __unsafe_unretained PBDataReader *reader);

@end

