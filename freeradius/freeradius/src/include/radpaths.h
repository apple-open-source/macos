/* Automatically generated by "build-radpaths-h" */
#define LOGDIR		"/private/var/log/radius"
#define LIBDIR		"/usr/lib"
#define RADDBDIR	"/private/etc/raddb"
#define RUNDIR		"/private/var/run"
#define SBINDIR		"/usr/sbin"
#define RADIR		"/private/var/log/radius/radacct"
