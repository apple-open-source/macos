#define ANGLE_PROGRAM_VERSION "dc6d17b70385eb1f9cedfd9b82e1fd50"
#define ANGLE_PROGRAM_VERSION_HASH_SIZE 16
