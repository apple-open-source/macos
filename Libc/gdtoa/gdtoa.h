FreeBSD/gdtoa.h