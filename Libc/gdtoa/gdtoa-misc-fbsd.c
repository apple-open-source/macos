FreeBSD/gdtoa-misc.c