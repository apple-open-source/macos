FreeBSD/gdtoa-smisc.c