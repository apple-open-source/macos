FreeBSD/gdtoa-sum.c