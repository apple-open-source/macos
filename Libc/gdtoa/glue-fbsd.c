FreeBSD/glue.c