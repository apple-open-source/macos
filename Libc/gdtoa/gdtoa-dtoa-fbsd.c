FreeBSD/gdtoa-dtoa.c