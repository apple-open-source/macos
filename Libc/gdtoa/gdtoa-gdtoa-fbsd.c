FreeBSD/gdtoa-gdtoa.c