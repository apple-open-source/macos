FreeBSD/gdtoa-dmisc.c