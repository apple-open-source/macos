FreeBSD/gdtoa-gmisc.c