FreeBSD/gdtoa_fltrnds.h