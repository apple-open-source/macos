FreeBSD/gdtoa-hd_init.c