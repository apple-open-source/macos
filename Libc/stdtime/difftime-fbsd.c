FreeBSD/difftime.c