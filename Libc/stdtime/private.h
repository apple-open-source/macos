FreeBSD/private.h