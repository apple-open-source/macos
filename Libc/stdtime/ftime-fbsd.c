FreeBSD/ftime.c