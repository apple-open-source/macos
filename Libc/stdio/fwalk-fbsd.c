FreeBSD/fwalk.c