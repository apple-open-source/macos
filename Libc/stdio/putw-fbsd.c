FreeBSD/putw.c