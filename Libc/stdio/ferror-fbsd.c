FreeBSD/ferror.c