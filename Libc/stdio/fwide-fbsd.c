FreeBSD/fwide.c