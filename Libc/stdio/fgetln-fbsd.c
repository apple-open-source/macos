FreeBSD/fgetln.c