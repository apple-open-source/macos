FreeBSD/fvwrite.h