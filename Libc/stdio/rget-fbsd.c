FreeBSD/rget.c