FreeBSD/fvwrite.c