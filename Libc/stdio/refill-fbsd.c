FreeBSD/refill.c