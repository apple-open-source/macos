FreeBSD/fgetc.c