FreeBSD/setbuf.c