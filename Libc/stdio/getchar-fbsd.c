FreeBSD/getchar.c