FreeBSD/_flock_stub.c