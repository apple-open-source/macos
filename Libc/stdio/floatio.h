FreeBSD/floatio.h