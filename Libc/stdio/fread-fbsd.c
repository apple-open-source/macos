FreeBSD/fread.c