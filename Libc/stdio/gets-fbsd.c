FreeBSD/gets.c