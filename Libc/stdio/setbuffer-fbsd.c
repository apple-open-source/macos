FreeBSD/setbuffer.c