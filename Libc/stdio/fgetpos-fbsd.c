FreeBSD/fgetpos.c