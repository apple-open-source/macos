FreeBSD/fgets.c