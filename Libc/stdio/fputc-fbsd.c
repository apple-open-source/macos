FreeBSD/fputc.c