FreeBSD/ungetc.c