FreeBSD/remove.c