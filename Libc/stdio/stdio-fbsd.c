FreeBSD/stdio.c