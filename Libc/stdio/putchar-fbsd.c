FreeBSD/putchar.c