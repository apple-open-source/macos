FreeBSD/fseek.c