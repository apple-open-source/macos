FreeBSD/fdopen.c