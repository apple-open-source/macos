FreeBSD/putc.c