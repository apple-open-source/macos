FreeBSD/getc.c