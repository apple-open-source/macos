FreeBSD/tmpnam.c