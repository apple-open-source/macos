FreeBSD/wsetup.c