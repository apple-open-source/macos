FreeBSD/clrerr.c