FreeBSD/fsetpos.c