FreeBSD/getw.c