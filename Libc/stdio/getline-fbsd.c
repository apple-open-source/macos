FreeBSD/getline.c