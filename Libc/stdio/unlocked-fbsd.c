FreeBSD/unlocked.c