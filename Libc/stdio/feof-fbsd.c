FreeBSD/feof.c