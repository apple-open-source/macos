FreeBSD/setvbuf.c