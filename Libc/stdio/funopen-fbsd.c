FreeBSD/funopen.c