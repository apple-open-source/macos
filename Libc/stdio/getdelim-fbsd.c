FreeBSD/getdelim.c