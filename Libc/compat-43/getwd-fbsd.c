FreeBSD/getwd.c