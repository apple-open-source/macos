FreeBSD/setruid.c