FreeBSD/sethostid.c