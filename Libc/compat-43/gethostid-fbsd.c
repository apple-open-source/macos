FreeBSD/gethostid.c