FreeBSD/regerror.c