FreeBSD/cname.h