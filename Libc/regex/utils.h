FreeBSD/utils.h