FreeBSD/strcpy.c