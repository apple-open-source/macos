FreeBSD/strncpy.c