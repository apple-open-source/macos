FreeBSD/strstr.c