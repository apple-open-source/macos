FreeBSD/wcschr.c