FreeBSD/strpbrk.c