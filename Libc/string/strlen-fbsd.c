FreeBSD/strlen.c