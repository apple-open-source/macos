FreeBSD/strmode.c