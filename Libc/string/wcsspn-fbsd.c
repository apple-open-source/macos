FreeBSD/wcsspn.c