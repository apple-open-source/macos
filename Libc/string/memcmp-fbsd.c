FreeBSD/memcmp.c