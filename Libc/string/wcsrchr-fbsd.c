FreeBSD/wcsrchr.c