FreeBSD/wmemchr.c