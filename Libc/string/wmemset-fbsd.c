FreeBSD/wmemset.c