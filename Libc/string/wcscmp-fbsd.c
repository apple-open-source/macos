FreeBSD/wcscmp.c