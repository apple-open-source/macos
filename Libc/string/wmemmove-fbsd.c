FreeBSD/wmemmove.c