FreeBSD/memchr.c