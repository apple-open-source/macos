FreeBSD/strcspn.c