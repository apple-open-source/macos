FreeBSD/rindex.c