FreeBSD/wcslcat.c