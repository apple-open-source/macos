FreeBSD/wcpncpy.c