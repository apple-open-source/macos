FreeBSD/bcmp.c