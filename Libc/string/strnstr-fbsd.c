FreeBSD/strnstr.c