FreeBSD/wcslen.c