FreeBSD/stpncpy.c