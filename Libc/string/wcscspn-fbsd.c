FreeBSD/wcscspn.c