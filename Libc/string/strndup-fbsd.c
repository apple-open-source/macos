FreeBSD/strndup.c