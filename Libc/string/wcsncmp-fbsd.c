FreeBSD/wcsncmp.c