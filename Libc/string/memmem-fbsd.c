FreeBSD/memmem.c