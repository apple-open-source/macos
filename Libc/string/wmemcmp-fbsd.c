FreeBSD/wmemcmp.c