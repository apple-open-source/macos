FreeBSD/memset.c