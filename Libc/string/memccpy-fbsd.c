FreeBSD/memccpy.c