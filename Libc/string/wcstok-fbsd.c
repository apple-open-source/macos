FreeBSD/wcstok.c