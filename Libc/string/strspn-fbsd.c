FreeBSD/strspn.c