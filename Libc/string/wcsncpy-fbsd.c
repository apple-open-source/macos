FreeBSD/wcsncpy.c