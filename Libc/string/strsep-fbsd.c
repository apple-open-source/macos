FreeBSD/strsep.c