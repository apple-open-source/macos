FreeBSD/wcsdup.c