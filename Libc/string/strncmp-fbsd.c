FreeBSD/strncmp.c