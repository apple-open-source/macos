FreeBSD/wcsnlen.c