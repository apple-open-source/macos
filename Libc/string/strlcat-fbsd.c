FreeBSD/strlcat.c