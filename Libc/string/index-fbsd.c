FreeBSD/index.c