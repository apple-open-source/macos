FreeBSD/strnlen.c