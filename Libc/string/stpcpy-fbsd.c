FreeBSD/stpcpy.c