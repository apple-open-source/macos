FreeBSD/wmemcpy.c