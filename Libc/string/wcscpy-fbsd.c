FreeBSD/wcscpy.c