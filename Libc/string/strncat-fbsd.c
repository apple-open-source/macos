FreeBSD/strncat.c