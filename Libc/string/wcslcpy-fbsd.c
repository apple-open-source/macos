FreeBSD/wcslcpy.c