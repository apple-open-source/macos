FreeBSD/wcspbrk.c