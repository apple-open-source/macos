FreeBSD/wcsstr.c