FreeBSD/wcpcpy.c