FreeBSD/wcscat.c