FreeBSD/strdup.c