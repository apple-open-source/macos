FreeBSD/wcsncat.c