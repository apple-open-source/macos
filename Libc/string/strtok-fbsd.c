FreeBSD/strtok.c