FreeBSD/strlcpy.c