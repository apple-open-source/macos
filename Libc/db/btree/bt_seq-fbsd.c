FreeBSD/bt_seq.c