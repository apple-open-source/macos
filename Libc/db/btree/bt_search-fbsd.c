FreeBSD/bt_search.c