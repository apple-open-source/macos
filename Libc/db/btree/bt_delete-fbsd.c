FreeBSD/bt_delete.c