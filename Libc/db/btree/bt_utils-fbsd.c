FreeBSD/bt_utils.c