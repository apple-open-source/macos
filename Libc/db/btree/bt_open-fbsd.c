FreeBSD/bt_open.c