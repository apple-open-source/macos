FreeBSD/bt_conv.c