FreeBSD/bt_split.c