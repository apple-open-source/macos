FreeBSD/bt_overflow.c