FreeBSD/bt_close.c