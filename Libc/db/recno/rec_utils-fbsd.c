FreeBSD/rec_utils.c