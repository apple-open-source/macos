FreeBSD/rec_delete.c