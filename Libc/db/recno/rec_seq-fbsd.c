FreeBSD/rec_seq.c