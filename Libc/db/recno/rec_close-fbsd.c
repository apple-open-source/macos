FreeBSD/rec_close.c