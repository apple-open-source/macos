FreeBSD/rec_put.c