FreeBSD/rec_search.c