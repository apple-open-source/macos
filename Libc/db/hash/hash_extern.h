FreeBSD/extern.h