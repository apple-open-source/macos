FreeBSD/hash_log2.c