FreeBSD/db.c