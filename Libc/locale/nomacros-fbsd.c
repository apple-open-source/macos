FreeBSD/nomacros.c