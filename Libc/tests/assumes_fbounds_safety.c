assumes.c