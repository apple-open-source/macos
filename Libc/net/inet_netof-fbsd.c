FreeBSD/inet_netof.c