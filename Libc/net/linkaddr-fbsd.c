FreeBSD/linkaddr.c