FreeBSD/inet_net_ntop.c