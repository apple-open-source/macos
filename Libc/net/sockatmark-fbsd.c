FreeBSD/sockatmark.c