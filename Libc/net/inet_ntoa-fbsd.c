FreeBSD/inet_ntoa.c