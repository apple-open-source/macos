FreeBSD/addr2ascii.c