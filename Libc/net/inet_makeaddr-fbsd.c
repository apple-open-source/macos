FreeBSD/inet_makeaddr.c