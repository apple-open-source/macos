FreeBSD/inet_lnaof.c