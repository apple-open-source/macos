FreeBSD/inet_neta.c