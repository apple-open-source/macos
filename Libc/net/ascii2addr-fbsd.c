FreeBSD/ascii2addr.c