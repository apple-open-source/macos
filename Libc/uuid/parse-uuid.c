uuidsrc/parse.c