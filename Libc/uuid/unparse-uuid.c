uuidsrc/unparse.c