uuidsrc/pack.c