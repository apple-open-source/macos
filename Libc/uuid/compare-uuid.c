uuidsrc/compare.c