uuidsrc/unpack.c