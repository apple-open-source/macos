uuidsrc/copy.c