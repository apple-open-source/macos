uuidsrc/clear.c