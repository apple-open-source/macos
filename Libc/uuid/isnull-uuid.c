uuidsrc/isnull.c