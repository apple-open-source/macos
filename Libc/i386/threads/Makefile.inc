CFLAGS+= -I${.CURDIR}/threads
SRCS+= thread.c
