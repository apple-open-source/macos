.PATH: ${.CURDIR}/i386/mach

MDSRCS += mach_absolute_time.s
