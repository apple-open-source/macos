# searching ppc directory as a fallback to avoid unnecessary code duplication
.PATH: ${.CURDIR}/ppc/mach

MDSRCS += mach_absolute_time.s
