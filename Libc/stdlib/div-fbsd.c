FreeBSD/div.c