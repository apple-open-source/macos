FreeBSD/getsubopt.c