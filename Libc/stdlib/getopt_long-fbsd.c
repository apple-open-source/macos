FreeBSD/getopt_long.c