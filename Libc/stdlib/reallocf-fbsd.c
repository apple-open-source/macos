FreeBSD/reallocf.c