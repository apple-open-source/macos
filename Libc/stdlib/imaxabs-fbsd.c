FreeBSD/imaxabs.c