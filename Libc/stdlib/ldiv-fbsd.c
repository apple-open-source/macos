FreeBSD/ldiv.c