FreeBSD/remque.c