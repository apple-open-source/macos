FreeBSD/lldiv.c