FreeBSD/lsearch.c