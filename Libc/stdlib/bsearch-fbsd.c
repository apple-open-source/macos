FreeBSD/bsearch.c