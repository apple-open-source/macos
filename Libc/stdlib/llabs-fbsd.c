FreeBSD/llabs.c