FreeBSD/twalk.c