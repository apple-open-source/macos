FreeBSD/_Exit_.c