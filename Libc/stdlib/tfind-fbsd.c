FreeBSD/tfind.c