FreeBSD/imaxdiv.c