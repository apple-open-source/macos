FreeBSD/tsearch.c