FreeBSD/abs.c