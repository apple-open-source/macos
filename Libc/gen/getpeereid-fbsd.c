FreeBSD/getpeereid.c