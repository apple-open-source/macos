FreeBSD/wait3.c