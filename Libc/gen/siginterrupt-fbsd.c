FreeBSD/siginterrupt.c