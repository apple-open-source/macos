FreeBSD/seekdir.c