FreeBSD/times.c