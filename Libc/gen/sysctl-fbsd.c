FreeBSD/sysctl.c