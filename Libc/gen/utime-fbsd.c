FreeBSD/utime.c