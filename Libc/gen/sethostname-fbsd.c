FreeBSD/sethostname.c