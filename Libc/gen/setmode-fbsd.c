FreeBSD/setmode.c