FreeBSD/sysctlnametomib.c