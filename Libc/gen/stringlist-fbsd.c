FreeBSD/stringlist.c