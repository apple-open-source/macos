FreeBSD/ualarm.c