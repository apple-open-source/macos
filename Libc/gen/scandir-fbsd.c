FreeBSD/scandir.c