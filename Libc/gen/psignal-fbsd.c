FreeBSD/psignal.c