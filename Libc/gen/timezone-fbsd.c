FreeBSD/timezone.c