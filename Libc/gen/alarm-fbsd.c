FreeBSD/alarm.c