FreeBSD/rewinddir.c