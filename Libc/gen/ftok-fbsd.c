FreeBSD/ftok.c