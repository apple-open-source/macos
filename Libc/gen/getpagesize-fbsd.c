FreeBSD/getpagesize.c