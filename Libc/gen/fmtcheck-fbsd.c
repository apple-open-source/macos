FreeBSD/fmtcheck.c