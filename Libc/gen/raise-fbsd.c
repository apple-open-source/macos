FreeBSD/raise.c