FreeBSD/ttyslot.c