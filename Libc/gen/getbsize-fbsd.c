FreeBSD/getbsize.c