FreeBSD/clock.c