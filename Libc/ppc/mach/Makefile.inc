.PATH: ${.CURDIR}/ppc/mach
MDSRCS += mach_absolute_time.s
