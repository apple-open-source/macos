MDSRCS += \
       init_cpu_capabilities.c
