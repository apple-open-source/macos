
.PATH: ${.CURDIR}/x86_64/mach

MDSRCS += mach_absolute_time.s
