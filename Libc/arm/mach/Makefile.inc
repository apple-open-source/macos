.PATH: ${.CURDIR}/arm/mach
MDSRCS += mach_absolute_time.s
