#include "objcube.h"
#include "objico.h"
#include "objocta.h"
#include "objpyr.h"
#include "objplane.h"
