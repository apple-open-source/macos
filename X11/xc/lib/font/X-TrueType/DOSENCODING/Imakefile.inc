XCOMM $XFree86: xc/lib/font/X-TrueType/DOSENCODING/Imakefile.inc,v 1.1 1999/03/28 15:31:40 dawes Exp $

#define ModuleName DOSENCODING
MODULENAME = ModuleName
MODULESRCDIR = $(XTTSOURCEDIR)/$(MODULENAME)

SRCS =	main.c DOSENCODINGtoUCS2.c
OBJS =	main.o DOSENCODINGtoUCS2.o

LinkSourceFile(main.c,$(MODULESRCDIR))
LinkSourceFile(DOSENCODINGtoUCS2.c,$(MODULESRCDIR))
