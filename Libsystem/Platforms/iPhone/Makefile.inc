#
# Selectable features for iPhone
#

# Build _debug.dylib
#FEATURE_DEBUG_DYLIB = 1

# Build _profile.dylib
#FEATURE_PROFILE_DYLIB = 1
