#define SVN_SQLITE_MIN_VERSION_NUMBER 3024000
#define SVN_SQLITE_MIN_VERSION "3.24.0"
