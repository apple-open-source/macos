/* ----------------------------------------------------------------------------
 * This file was automatically generated by SWIG (http://www.swig.org).
 * Version 1.3.25
 * 
 * This file is not intended to be easily readable and contains a number of 
 * coding conventions designed to improve portability and efficiency. Do not make
 * changes to this file unless you know what you are doing--modify the SWIG 
 * interface file instead. 
 * ----------------------------------------------------------------------------- */

/***********************************************************************
 *
 *  This section contains generic SWIG labels for method/variable
 *  declarations/attributes, and other compiler dependent labels.
 *
 ************************************************************************/

/* template workaround for compilers that cannot correctly implement the C++ standard */
#ifndef SWIGTEMPLATEDISAMBIGUATOR
#  if defined(__SUNPRO_CC) && (__SUNPRO_CC <= 0x560)
#    define SWIGTEMPLATEDISAMBIGUATOR template
#  else
#    define SWIGTEMPLATEDISAMBIGUATOR 
#  endif
#endif

/* inline attribute */
#ifndef SWIGINLINE
# if defined(__cplusplus) || (defined(__GNUC__) && !defined(__STRICT_ANSI__))
#   define SWIGINLINE inline
# else
#   define SWIGINLINE
# endif
#endif

/* attribute recognised by some compilers to avoid 'unused' warnings */
#ifndef SWIGUNUSED
# if defined(__GNUC__) || defined(__ICC)
#   define SWIGUNUSED __attribute__ ((unused)) 
# else
#   define SWIGUNUSED 
# endif
#endif

/* internal SWIG method */
#ifndef SWIGINTERN
# define SWIGINTERN static SWIGUNUSED
#endif

/* internal inline SWIG method */
#ifndef SWIGINTERNINLINE
# define SWIGINTERNINLINE SWIGINTERN SWIGINLINE
#endif

/* exporting methods for Windows DLLs */
#ifndef SWIGEXPORT
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   if defined(STATIC_LINKED)
#     define SWIGEXPORT
#   else
#     define SWIGEXPORT __declspec(dllexport)
#   endif
# else
#   define SWIGEXPORT
# endif
#endif

/* calling conventions for Windows */
#ifndef SWIGSTDCALL
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   define SWIGSTDCALL __stdcall
# else
#   define SWIGSTDCALL
# endif 
#endif


/***********************************************************************
 * swigrun.swg
 *
 *     This file contains generic CAPI SWIG runtime support for pointer
 *     type checking.
 *
 ************************************************************************/

/* This should only be incremented when either the layout of swig_type_info changes,
   or for whatever reason, the runtime changes incompatibly */
#define SWIG_RUNTIME_VERSION "2"

/* define SWIG_TYPE_TABLE_NAME as "SWIG_TYPE_TABLE" */
#ifdef SWIG_TYPE_TABLE
# define SWIG_QUOTE_STRING(x) #x
# define SWIG_EXPAND_AND_QUOTE_STRING(x) SWIG_QUOTE_STRING(x)
# define SWIG_TYPE_TABLE_NAME SWIG_EXPAND_AND_QUOTE_STRING(SWIG_TYPE_TABLE)
#else
# define SWIG_TYPE_TABLE_NAME
#endif

/*
  You can use the SWIGRUNTIME and SWIGRUNTIMEINLINE macros for
  creating a static or dynamic library from the swig runtime code.
  In 99.9% of the cases, swig just needs to declare them as 'static'.
  
  But only do this if is strictly necessary, ie, if you have problems
  with your compiler or so.
*/

#ifndef SWIGRUNTIME
# define SWIGRUNTIME SWIGINTERN
#endif

#ifndef SWIGRUNTIMEINLINE
# define SWIGRUNTIMEINLINE SWIGRUNTIME SWIGINLINE
#endif

#include <string.h>

#ifdef __cplusplus
extern "C" {
#endif

typedef void *(*swig_converter_func)(void *);
typedef struct swig_type_info *(*swig_dycast_func)(void **);

/* Structure to store inforomation on one type */
typedef struct swig_type_info {
  const char             *name;			/* mangled name of this type */
  const char             *str;			/* human readable name of this type */
  swig_dycast_func        dcast;		/* dynamic cast function down a hierarchy */
  struct swig_cast_info  *cast;			/* linked list of types that can cast into this type */
  void                   *clientdata;		/* language specific type data */
} swig_type_info;

/* Structure to store a type and conversion function used for casting */
typedef struct swig_cast_info {
  swig_type_info         *type;			/* pointer to type that is equivalent to this type */
  swig_converter_func     converter;		/* function to cast the void pointers */
  struct swig_cast_info  *next;			/* pointer to next cast in linked list */
  struct swig_cast_info  *prev;			/* pointer to the previous cast */
} swig_cast_info;

/* Structure used to store module information
 * Each module generates one structure like this, and the runtime collects
 * all of these structures and stores them in a circularly linked list.*/
typedef struct swig_module_info {
  swig_type_info         **types;		/* Array of pointers to swig_type_info structures that are in this module */
  size_t                 size;		        /* Number of types in this module */
  struct swig_module_info *next;		/* Pointer to next element in circularly linked list */
  swig_type_info         **type_initial;	/* Array of initially generated type structures */
  swig_cast_info         **cast_initial;	/* Array of initially generated casting structures */
  void                    *clientdata;		/* Language specific module data */
} swig_module_info;


/* 
  Compare two type names skipping the space characters, therefore
  "char*" == "char *" and "Class<int>" == "Class<int >", etc.

  Return 0 when the two name types are equivalent, as in
  strncmp, but skipping ' '.
*/
SWIGRUNTIME int
SWIG_TypeNameComp(const char *f1, const char *l1,
		  const char *f2, const char *l2) {
  for (;(f1 != l1) && (f2 != l2); ++f1, ++f2) {
    while ((*f1 == ' ') && (f1 != l1)) ++f1;
    while ((*f2 == ' ') && (f2 != l2)) ++f2;
    if (*f1 != *f2) return (int)(*f1 - *f2);
  }
  return (l1 - f1) - (l2 - f2);
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if not equal, 1 if equal
*/
SWIGRUNTIME int
SWIG_TypeEquiv(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if equal, -1 if nb < tb, 1 if nb > tb
*/
SWIGRUNTIME int
SWIG_TypeCompare(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}


/* think of this as a c++ template<> or a scheme macro */
#define SWIG_TypeCheck_Template(comparison, ty)         \
  if (ty) {                                             \
    swig_cast_info *iter = ty->cast;                    \
    while (iter) {                                      \
      if (comparison) {                                 \
        if (iter == ty->cast) return iter;              \
        /* Move iter to the top of the linked list */   \
        iter->prev->next = iter->next;                  \
        if (iter->next)                                 \
          iter->next->prev = iter->prev;                \
        iter->next = ty->cast;                          \
        iter->prev = 0;                                 \
        if (ty->cast) ty->cast->prev = iter;            \
        ty->cast = iter;                                \
        return iter;                                    \
      }                                                 \
      iter = iter->next;                                \
    }                                                   \
  }                                                     \
  return 0

/*
  Check the typename
*/
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheck(const char *c, swig_type_info *ty) {
  SWIG_TypeCheck_Template(strcmp(iter->type->name, c) == 0, ty);
}

/* Same as previous function, except strcmp is replaced with a pointer comparison */
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheckStruct(swig_type_info *from, swig_type_info *into) {
  SWIG_TypeCheck_Template(iter->type == from, into);
}

/*
  Cast a pointer up an inheritance hierarchy
*/
SWIGRUNTIMEINLINE void *
SWIG_TypeCast(swig_cast_info *ty, void *ptr) {
  return ((!ty) || (!ty->converter)) ? ptr : (*ty->converter)(ptr);
}

/* 
   Dynamic pointer casting. Down an inheritance hierarchy
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeDynamicCast(swig_type_info *ty, void **ptr) {
  swig_type_info *lastty = ty;
  if (!ty || !ty->dcast) return ty;
  while (ty && (ty->dcast)) {
    ty = (*ty->dcast)(ptr);
    if (ty) lastty = ty;
  }
  return lastty;
}

/*
  Return the name associated with this type
*/
SWIGRUNTIMEINLINE const char *
SWIG_TypeName(const swig_type_info *ty) {
  return ty->name;
}

/*
  Return the pretty name associated with this type,
  that is an unmangled type name in a form presentable to the user.
*/
SWIGRUNTIME const char *
SWIG_TypePrettyName(const swig_type_info *type) {
  /* The "str" field contains the equivalent pretty names of the
     type, separated by vertical-bar characters.  We choose
     to print the last name, as it is often (?) the most
     specific. */
  if (type->str != NULL) {
    const char *last_name = type->str;
    const char *s;
    for (s = type->str; *s; s++)
      if (*s == '|') last_name = s+1;
    return last_name;
  }
  else
    return type->name;
}

/* 
   Set the clientdata field for a type
*/
SWIGRUNTIME void
SWIG_TypeClientData(swig_type_info *ti, void *clientdata) {
  if (!ti->clientdata) {
    swig_cast_info *cast = ti->cast;
    /* if (ti->clientdata == clientdata) return; */
    ti->clientdata = clientdata;
    
    while (cast) {
      if (!cast->converter)
	SWIG_TypeClientData(cast->type, clientdata);
      cast = cast->next;
    }
  }
}

/*
  Search for a swig_type_info structure only by mangled name
  Search is a O(log #types)
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_MangledTypeQueryModule(swig_module_info *start, 
                            swig_module_info *end, 
		            const char *name) {
  swig_module_info *iter = start;
  do {
    if (iter->size) {
      register size_t l = 0;
      register size_t r = iter->size - 1;
      do {
	/* since l+r >= 0, we can (>> 1) instead (/ 2) */
	register size_t i = (l + r) >> 1; 
	const char *iname = iter->types[i]->name;
	if (iname) {
	  register int compare = strcmp(name, iname);
	  if (compare == 0) {	    
	    return iter->types[i];
	  } else if (compare < 0) {
	    if (i) {
	      r = i - 1;
	    } else {
	      break;
	    }
	  } else if (compare > 0) {
	    l = i + 1;
	  }
	} else {
	  break; /* should never happen */
	}
      } while (l <= r);
    }
    iter = iter->next;
  } while (iter != end);
  return 0;
}

/*
  Search for a swig_type_info structure for either a mangled name or a human readable name.
  It first searches the mangled names of the types, which is a O(log #types)
  If a type is not found it then searches the human readable names, which is O(#types).
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeQueryModule(swig_module_info *start, 
                     swig_module_info *end, 
		     const char *name) {
  /* STEP 1: Search the name field using binary search */
  swig_type_info *ret = SWIG_MangledTypeQueryModule(start, end, name);
  if (ret) {
    return ret;
  } else {
    /* STEP 2: If the type hasn't been found, do a complete search
       of the str field (the human readable name) */
    swig_module_info *iter = start;
    do {
      register size_t i = 0;
      for (; i < iter->size; ++i) {
	if (iter->types[i]->str && (SWIG_TypeEquiv(iter->types[i]->str, name)))
	  return iter->types[i];
      }
      iter = iter->next;
    } while (iter != end);
  }
  
  /* neither found a match */
  return 0;
}


/* 
   Pack binary data into a string
*/
SWIGRUNTIME char *
SWIG_PackData(char *c, void *ptr, size_t sz) {
  static const char hex[17] = "0123456789abcdef";
  register const unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu =  u + sz;
  for (; u != eu; ++u) {
    register unsigned char uu = *u;
    *(c++) = hex[(uu & 0xf0) >> 4];
    *(c++) = hex[uu & 0xf];
  }
  return c;
}

/* 
   Unpack binary data from a string
*/
SWIGRUNTIME const char *
SWIG_UnpackData(const char *c, void *ptr, size_t sz) {
  register unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu = u + sz;
  for (; u != eu; ++u) {
    register char d = *(c++);
    register unsigned char uu = 0;
    if ((d >= '0') && (d <= '9'))
      uu = ((d - '0') << 4);
    else if ((d >= 'a') && (d <= 'f'))
      uu = ((d - ('a'-10)) << 4);
    else 
      return (char *) 0;
    d = *(c++);
    if ((d >= '0') && (d <= '9'))
      uu |= (d - '0');
    else if ((d >= 'a') && (d <= 'f'))
      uu |= (d - ('a'-10));
    else 
      return (char *) 0;
    *u = uu;
  }
  return c;
}

/* 
   Pack 'void *' into a string buffer.
*/
SWIGRUNTIME char *
SWIG_PackVoidPtr(char *buff, void *ptr, const char *name, size_t bsz) {
  char *r = buff;
  if ((2*sizeof(void *) + 2) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,&ptr,sizeof(void *));
  if (strlen(name) + 1 > (bsz - (r - buff))) return 0;
  strcpy(r,name);
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackVoidPtr(const char *c, void **ptr, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      *ptr = (void *) 0;
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sizeof(void *));
}

SWIGRUNTIME char *
SWIG_PackDataName(char *buff, void *ptr, size_t sz, const char *name, size_t bsz) {
  char *r = buff;
  size_t lname = (name ? strlen(name) : 0);
  if ((2*sz + 2 + lname) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,ptr,sz);
  if (lname) {
    strncpy(r,name,lname+1);
  } else {
    *r = 0;
  }
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackDataName(const char *c, void *ptr, size_t sz, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      memset(ptr,0,sz);
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sz);
}

#ifdef __cplusplus
}
#endif


/* ---------------------------------------------------------------------- -*- c -*-
 * perl5.swg
 *
 * Perl5 runtime library
 * $Header: /cvsroot/swig/SWIG/Lib/perl5/perlrun.swg,v 1.21 2005/02/01 00:08:17 wuzzeb Exp $
 * ----------------------------------------------------------------------------- */

#define SWIGPERL
#define SWIGPERL5
#ifdef __cplusplus
/* Needed on some windows machines---since MS plays funny games with the header files under C++ */
#include <math.h>
#include <stdlib.h>
extern "C" {
#endif
#include "EXTERN.h"
#include "perl.h"
#include "XSUB.h"

/* Get rid of free and malloc defined by perl */
#undef free
#undef malloc

#ifndef pTHX_
#define pTHX_
#endif

#include <string.h>
#ifdef __cplusplus
}
#endif

/* Macro to call an XS function */

#ifdef PERL_OBJECT 
#  define SWIG_CALLXS(_name) _name(cv,pPerl) 
#else 
#  ifndef MULTIPLICITY 
#    define SWIG_CALLXS(_name) _name(cv) 
#  else 
#    define SWIG_CALLXS(_name) _name(PERL_GET_THX, cv) 
#  endif 
#endif 

/* Contract support */

#define SWIG_contract_assert(expr,msg) if (!(expr)) { SWIG_croak(msg); } else

/* Note: SwigMagicFuncHack is a typedef used to get the C++ compiler to just shut up already */

#ifdef PERL_OBJECT
#define MAGIC_PPERL  CPerlObj *pPerl = (CPerlObj *) this;
typedef int (CPerlObj::*SwigMagicFunc)(SV *, MAGIC *);

#ifdef __cplusplus
extern "C" {
#endif
typedef int (CPerlObj::*SwigMagicFuncHack)(SV *, MAGIC *);
#ifdef __cplusplus
}
#endif

#define SWIG_MAGIC(a,b) (SV *a, MAGIC *b)
#define SWIGCLASS_STATIC
#else
#define MAGIC_PPERL
#define SWIGCLASS_STATIC static
#ifndef MULTIPLICITY
#define SWIG_MAGIC(a,b) (SV *a, MAGIC *b)
typedef int (*SwigMagicFunc)(SV *, MAGIC *);

#ifdef __cplusplus
extern "C" {
#endif
typedef int (*SwigMagicFuncHack)(SV *, MAGIC *);
#ifdef __cplusplus
}
#endif


#else
#define SWIG_MAGIC(a,b) (struct interpreter *interp, SV *a, MAGIC *b)
typedef int (*SwigMagicFunc)(struct interpreter *, SV *, MAGIC *);
#ifdef __cplusplus
extern "C" {
#endif
typedef int (*SwigMagicFuncHack)(struct interpreter *, SV *, MAGIC *);
#ifdef __cplusplus
}
#endif

#endif
#endif

#if defined(WIN32) && defined(PERL_OBJECT) && !defined(PerlIO_exportFILE)
#define PerlIO_exportFILE(fh,fl) (FILE*)(fh)
#endif

/* Modifications for newer Perl 5.005 releases */

#if !defined(PERL_REVISION) || ((PERL_REVISION >= 5) && ((PERL_VERSION < 5) || ((PERL_VERSION == 5) && (PERL_SUBVERSION < 50))))
#  ifndef PL_sv_yes
#    define PL_sv_yes sv_yes
#  endif
#  ifndef PL_sv_undef
#    define PL_sv_undef sv_undef
#  endif
#  ifndef PL_na
#    define PL_na na
#  endif
#endif

#include <stdlib.h>

#ifdef __cplusplus
extern "C" {
#endif

#define SWIG_OWNER 1
#define SWIG_SHADOW 2

/* Common SWIG API */

#ifdef PERL_OBJECT
#  define SWIG_ConvertPtr(obj, pp, type, flags) \
     SWIG_Perl_ConvertPtr(pPerl, obj, pp, type, flags)
#  define SWIG_NewPointerObj(p, type, flags) \
     SWIG_Perl_NewPointerObj(pPerl, p, type, flags)
#  define SWIG_MakePackedObj(sv, p, s, type)	\
     SWIG_Perl_MakePackedObj(pPerl, sv, p, s, type)
#  define SWIG_ConvertPacked(obj, p, s, type, flags) \
     SWIG_Perl_ConvertPacked(pPerl, obj, p, s, type, flags)

#else
#  define SWIG_ConvertPtr(obj, pp, type, flags) \
     SWIG_Perl_ConvertPtr(obj, pp, type, flags)
#  define SWIG_NewPointerObj(p, type, flags) \
     SWIG_Perl_NewPointerObj(p, type, flags)
#  define SWIG_MakePackedObj(sv, p, s, type)	\
     SWIG_Perl_MakePackedObj(sv, p, s, type )
#  define SWIG_ConvertPacked(obj, p, s, type, flags) \
     SWIG_Perl_ConvertPacked(obj, p, s, type, flags)
#endif

/* Runtime API */
#define SWIG_GetModule(clientdata) SWIG_Perl_GetModule()
#define SWIG_SetModule(clientdata, pointer) SWIG_Perl_SetModule(pointer)

/* Perl-specific API */
#ifdef PERL_OBJECT
#  define SWIG_MakePtr(sv, ptr, type, flags) \
     SWIG_Perl_MakePtr(pPerl, sv, ptr, type, flags)
#  define SWIG_SetError(str) \
     SWIG_Perl_SetError(pPerl, str)
#else
#  define SWIG_MakePtr(sv, ptr, type, flags) \
     SWIG_Perl_MakePtr(sv, ptr, type, flags)
#  define SWIG_SetError(str) \
     SWIG_Perl_SetError(str)
#  define SWIG_SetErrorSV(str) \
     SWIG_Perl_SetErrorSV(str)
#endif

#define SWIG_SetErrorf SWIG_Perl_SetErrorf


#ifdef PERL_OBJECT
#  define SWIG_MAYBE_PERL_OBJECT CPerlObj *pPerl,
#else
#  define SWIG_MAYBE_PERL_OBJECT
#endif

static swig_cast_info *
SWIG_Perl_TypeCheckRV(SWIG_MAYBE_PERL_OBJECT SV *rv, swig_type_info *ty) {
  SWIG_TypeCheck_Template(sv_derived_from(rv, (char *) iter->type->name), ty);
}

/* Function for getting a pointer value */

static int
SWIG_Perl_ConvertPtr(SWIG_MAYBE_PERL_OBJECT SV *sv, void **ptr, swig_type_info *_t, int flags) {
  swig_cast_info *tc;
  void *voidptr = (void *)0;

  /* If magical, apply more magic */
  if (SvGMAGICAL(sv))
    mg_get(sv);

  /* Check to see if this is an object */
  if (sv_isobject(sv)) {
    SV *tsv = (SV*) SvRV(sv);
    IV tmp = 0;
    if ((SvTYPE(tsv) == SVt_PVHV)) {
      MAGIC *mg;
      if (SvMAGICAL(tsv)) {
        mg = mg_find(tsv,'P');
        if (mg) {
          sv = mg->mg_obj;
          if (sv_isobject(sv)) {
            tmp = SvIV((SV*)SvRV(sv));
          }
        }
      } else {
        return -1;
      }
    } else {
      tmp = SvIV((SV*)SvRV(sv));
    }
    voidptr = (void *)tmp;
    if (!_t) {
      *(ptr) = voidptr;
      return 0;
    }
  } else if (! SvOK(sv)) {            /* Check for undef */
    *(ptr) = (void *) 0;
    return 0;
  } else if (SvTYPE(sv) == SVt_RV) {  /* Check for NULL pointer */
    *(ptr) = (void *) 0;
    if (!SvROK(sv))
      return 0;
    else
      return -1;
  } else {                            /* Don't know what it is */
    *(ptr) = (void *) 0;
    return -1;
  }
  if (_t) {
    /* Now see if the types match */
    char *_c = HvNAME(SvSTASH(SvRV(sv)));
    tc = SWIG_TypeCheck(_c,_t);
    if (!tc) {
      *ptr = voidptr;
      return -1;
    }
    *ptr = SWIG_TypeCast(tc,voidptr);
    return 0;
  }
  *ptr = voidptr;
  return 0;
}

static void
SWIG_Perl_MakePtr(SWIG_MAYBE_PERL_OBJECT SV *sv, void *ptr, swig_type_info *t, int flags) {
  if (ptr && (flags & SWIG_SHADOW)) {
    SV *self;
    SV *obj=newSV(0);
    HV *hash=newHV();
    HV *stash;
    sv_setref_pv(obj, (char *) t->name, ptr);
    stash=SvSTASH(SvRV(obj));
    if (flags & SWIG_OWNER) {
      HV *hv;
      GV *gv=*(GV**)hv_fetch(stash, "OWNER", 5, TRUE);
      if (!isGV(gv))
        gv_init(gv, stash, "OWNER", 5, FALSE);
      hv=GvHVn(gv);
      hv_store_ent(hv, obj, newSViv(1), 0);
    }
    sv_magic((SV *)hash, (SV *)obj, 'P', Nullch, 0);
    SvREFCNT_dec(obj);
    self=newRV_noinc((SV *)hash);
    sv_setsv(sv, self);
    SvREFCNT_dec((SV *)self);
    sv_bless(sv, stash);
  }
  else {
    sv_setref_pv(sv, (char *) t->name, ptr);
  }
}

static SWIGINLINE SV *
SWIG_Perl_NewPointerObj(SWIG_MAYBE_PERL_OBJECT void *ptr, swig_type_info *t, int flags) {
  SV *result = sv_newmortal();
  SWIG_MakePtr(result, ptr, t, flags);
  return result;
}

static void
  SWIG_Perl_MakePackedObj(SWIG_MAYBE_PERL_OBJECT SV *sv, void *ptr, int sz, swig_type_info *type) {
  char result[1024];
  char *r = result;
  if ((2*sz + 1 + strlen(type->name)) > 1000) return;
  *(r++) = '_';
  r = SWIG_PackData(r,ptr,sz);
  strcpy(r,type->name);
  sv_setpv(sv, result);
}

/* Convert a packed value value */
static int
SWIG_Perl_ConvertPacked(SWIG_MAYBE_PERL_OBJECT SV *obj, void *ptr, int sz, swig_type_info *ty, int flags) {
  swig_cast_info *tc;
  const char  *c = 0;

  if ((!obj) || (!SvOK(obj))) return -1;
  c = SvPV(obj, PL_na);
  /* Pointer values must start with leading underscore */
  if (*c != '_') return -1;
  c++;
  c = SWIG_UnpackData(c,ptr,sz);
  if (ty) {
    tc = SWIG_TypeCheck(c,ty);
    if (!tc) return -1;
  }
  return 0;
}

static SWIGINLINE void
SWIG_Perl_SetError(SWIG_MAYBE_PERL_OBJECT const char *error) {
  if (error) sv_setpv(perl_get_sv("@", TRUE), error);
}

static SWIGINLINE void
SWIG_Perl_SetErrorSV(SWIG_MAYBE_PERL_OBJECT SV *error) {
  if (error) sv_setsv(perl_get_sv("@", TRUE), error);
}

static void
SWIG_Perl_SetErrorf(const char *fmt, ...) {
  va_list args;
  va_start(args, fmt);
  sv_vsetpvfn(perl_get_sv("@", TRUE), fmt, strlen(fmt), &args, Null(SV**), 0, Null(bool*));
  va_end(args);
}

/* Macros for low-level exception handling */
#define SWIG_fail       goto fail
#define SWIG_croak(x)   { SWIG_SetError(x); goto fail; }
#define SWIG_croakSV(x) { SWIG_SetErrorSV(x); goto fail; }
/* most preprocessors do not support vararg macros :-( */
/* #define SWIG_croakf(x...) { SWIG_SetErrorf(x); goto fail; } */


typedef XS(SwigPerlWrapper);
typedef SwigPerlWrapper *SwigPerlWrapperPtr;

/* Structure for command table */
typedef struct {
  const char         *name;
  SwigPerlWrapperPtr  wrapper;
} swig_command_info;

/* Information for constant table */

#define SWIG_INT     1
#define SWIG_FLOAT   2
#define SWIG_STRING  3
#define SWIG_POINTER 4
#define SWIG_BINARY  5

/* Constant information structure */
typedef struct swig_constant_info {
    int              type;
    const char      *name;
    long             lvalue;
    double           dvalue;
    void            *pvalue;
    swig_type_info **ptype;
} swig_constant_info;

#ifdef __cplusplus
}
#endif

/* Structure for variable table */
typedef struct {
  const char   *name;
  SwigMagicFunc   set;
  SwigMagicFunc   get;
  swig_type_info  **type;
} swig_variable_info;

/* Magic variable code */
#ifndef PERL_OBJECT
#define swig_create_magic(s,a,b,c) _swig_create_magic(s,a,b,c)
  #ifndef MULTIPLICITY
     static void _swig_create_magic(SV *sv, char *name, int (*set)(SV *, MAGIC *), int (*get)(SV *,MAGIC *)) {
  #else
     static void _swig_create_magic(SV *sv, char *name, int (*set)(struct interpreter*, SV *, MAGIC *), int (*get)(struct interpreter*, SV *,MAGIC *)) {
  #endif
#else
#  define swig_create_magic(s,a,b,c) _swig_create_magic(pPerl,s,a,b,c)
static void _swig_create_magic(CPerlObj *pPerl, SV *sv, const char *name, int (CPerlObj::*set)(SV *, MAGIC *), int (CPerlObj::*get)(SV *, MAGIC *)) {
#endif
  MAGIC *mg;
  sv_magic(sv,sv,'U',(char *) name,strlen(name));
  mg = mg_find(sv,'U');
  mg->mg_virtual = (MGVTBL *) malloc(sizeof(MGVTBL));
  mg->mg_virtual->svt_get = (SwigMagicFuncHack) get;
  mg->mg_virtual->svt_set = (SwigMagicFuncHack) set;
  mg->mg_virtual->svt_len = 0;
  mg->mg_virtual->svt_clear = 0;
  mg->mg_virtual->svt_free = 0;
}


static swig_module_info *
SWIG_Perl_GetModule() {
  static void *type_pointer = (void *)0;
  SV *pointer;

  /* first check if pointer already created */
  if (!type_pointer) {
    pointer = get_sv("swig_runtime_data::type_pointer" SWIG_RUNTIME_VERSION SWIG_TYPE_TABLE_NAME, FALSE);
    if (pointer && SvOK(pointer)) {
      type_pointer = INT2PTR(swig_type_info **, SvIV(pointer));
    }
  }

  return (swig_module_info *) type_pointer;
}

static void
SWIG_Perl_SetModule(swig_module_info *module) {
  SV *pointer;

  /* create a new pointer */
  pointer = get_sv("swig_runtime_data::type_pointer" SWIG_RUNTIME_VERSION SWIG_TYPE_TABLE_NAME, TRUE);
  sv_setiv(pointer, PTR2IV(module));
}


#ifdef do_open
  #undef do_open
#endif
#ifdef do_close
  #undef do_close
#endif
#ifdef scalar
  #undef scalar
#endif
#ifdef list
  #undef list
#endif
#ifdef apply
  #undef apply
#endif
#ifdef convert
  #undef convert
#endif
#ifdef Error
  #undef Error
#endif
#ifdef form
  #undef form
#endif
#ifdef vform
  #undef vform
#endif
#ifdef LABEL
  #undef LABEL
#endif
#ifdef METHOD
  #undef METHOD
#endif
#ifdef Move
  #undef Move
#endif
#ifdef yylex
  #undef yylex
#endif
#ifdef yyparse
  #undef yyparse
#endif
#ifdef yyerror
  #undef yyerror
#endif
#ifdef invert
  #undef invert
#endif
#ifdef ref
  #undef ref
#endif
#ifdef ENTER
  #undef ENTER
#endif
#ifdef read
  #undef read
#endif
#ifdef write
  #undef write
#endif
#ifdef eof
  #undef eof
#endif



/* -------- TYPES TABLE (BEGIN) -------- */

#define SWIGTYPE_p_apr_array_header_t swig_types[0]
#define SWIGTYPE_p_apr_hash_t swig_types[1]
#define SWIGTYPE_p_apr_int32_t swig_types[2]
#define SWIGTYPE_p_apr_int64_t swig_types[3]
#define SWIGTYPE_p_apr_pool_t swig_types[4]
#define SWIGTYPE_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[5]
#define SWIGTYPE_p_f_p_p_svn_stream_t_p_void__p_svn_error_t swig_types[6]
#define SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[7]
#define SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t swig_types[8]
#define SWIGTYPE_p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[9]
#define SWIGTYPE_p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t swig_types[10]
#define SWIGTYPE_p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t swig_types[11]
#define SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t swig_types[12]
#define SWIGTYPE_p_f_p_void__p_svn_error_t swig_types[13]
#define SWIGTYPE_p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[14]
#define SWIGTYPE_p_f_p_void_p_q_const__char__p_svn_error_t swig_types[15]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t swig_types[16]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t swig_types[17]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t swig_types[18]
#define SWIGTYPE_p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t swig_types[19]
#define SWIGTYPE_p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t swig_types[20]
#define SWIGTYPE_p_int swig_types[21]
#define SWIGTYPE_p_long swig_types[22]
#define SWIGTYPE_p_p_apr_array_header_t swig_types[23]
#define SWIGTYPE_p_p_apr_hash_t swig_types[24]
#define SWIGTYPE_p_p_char swig_types[25]
#define SWIGTYPE_p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t swig_types[26]
#define SWIGTYPE_p_p_svn_authz_t swig_types[27]
#define SWIGTYPE_p_p_svn_delta_editor_t swig_types[28]
#define SWIGTYPE_p_p_svn_dirent_t swig_types[29]
#define SWIGTYPE_p_p_svn_fs_txn_t swig_types[30]
#define SWIGTYPE_p_p_svn_lock_t swig_types[31]
#define SWIGTYPE_p_p_svn_repos_parse_fns2_t swig_types[32]
#define SWIGTYPE_p_p_svn_repos_parse_fns_t swig_types[33]
#define SWIGTYPE_p_p_svn_repos_t swig_types[34]
#define SWIGTYPE_p_p_svn_stream_t swig_types[35]
#define SWIGTYPE_p_p_svn_string_t swig_types[36]
#define SWIGTYPE_p_p_void swig_types[37]
#define SWIGTYPE_p_svn_auth_baton_t swig_types[38]
#define SWIGTYPE_p_svn_auth_cred_simple_t swig_types[39]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_pw_t swig_types[40]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_t swig_types[41]
#define SWIGTYPE_p_svn_auth_cred_ssl_server_trust_t swig_types[42]
#define SWIGTYPE_p_svn_auth_cred_username_t swig_types[43]
#define SWIGTYPE_p_svn_auth_iterstate_t swig_types[44]
#define SWIGTYPE_p_svn_auth_provider_object_t swig_types[45]
#define SWIGTYPE_p_svn_auth_provider_t swig_types[46]
#define SWIGTYPE_p_svn_auth_ssl_server_cert_info_t swig_types[47]
#define SWIGTYPE_p_svn_authz_t swig_types[48]
#define SWIGTYPE_p_svn_commit_info_t swig_types[49]
#define SWIGTYPE_p_svn_config_t swig_types[50]
#define SWIGTYPE_p_svn_delta_editor_t swig_types[51]
#define SWIGTYPE_p_svn_diff_datasource_e swig_types[52]
#define SWIGTYPE_p_svn_diff_file_ignore_space_t swig_types[53]
#define SWIGTYPE_p_svn_diff_file_options_t swig_types[54]
#define SWIGTYPE_p_svn_diff_fns_t swig_types[55]
#define SWIGTYPE_p_svn_diff_output_fns_t swig_types[56]
#define SWIGTYPE_p_svn_diff_t swig_types[57]
#define SWIGTYPE_p_svn_dirent_t swig_types[58]
#define SWIGTYPE_p_svn_errno_t swig_types[59]
#define SWIGTYPE_p_svn_error_t swig_types[60]
#define SWIGTYPE_p_svn_fs_access_t swig_types[61]
#define SWIGTYPE_p_svn_fs_dirent_t swig_types[62]
#define SWIGTYPE_p_svn_fs_history_t swig_types[63]
#define SWIGTYPE_p_svn_fs_id_t swig_types[64]
#define SWIGTYPE_p_svn_fs_path_change_kind_t swig_types[65]
#define SWIGTYPE_p_svn_fs_path_change_t swig_types[66]
#define SWIGTYPE_p_svn_fs_root_t swig_types[67]
#define SWIGTYPE_p_svn_fs_t swig_types[68]
#define SWIGTYPE_p_svn_fs_txn_t swig_types[69]
#define SWIGTYPE_p_svn_io_dirent_t swig_types[70]
#define SWIGTYPE_p_svn_io_file_del_t swig_types[71]
#define SWIGTYPE_p_svn_lock_t swig_types[72]
#define SWIGTYPE_p_svn_log_changed_path_t swig_types[73]
#define SWIGTYPE_p_svn_node_kind_t swig_types[74]
#define SWIGTYPE_p_svn_opt_revision_t swig_types[75]
#define SWIGTYPE_p_svn_opt_revision_value_t swig_types[76]
#define SWIGTYPE_p_svn_opt_subcommand_desc2_t swig_types[77]
#define SWIGTYPE_p_svn_opt_subcommand_desc_t swig_types[78]
#define SWIGTYPE_p_svn_prop_kind swig_types[79]
#define SWIGTYPE_p_svn_repos_authz_access_t swig_types[80]
#define SWIGTYPE_p_svn_repos_node_t swig_types[81]
#define SWIGTYPE_p_svn_repos_parse_fns2_t swig_types[82]
#define SWIGTYPE_p_svn_repos_parse_fns_t swig_types[83]
#define SWIGTYPE_p_svn_repos_t swig_types[84]
#define SWIGTYPE_p_svn_stream_t swig_types[85]
#define SWIGTYPE_p_svn_string_t swig_types[86]
#define SWIGTYPE_p_svn_stringbuf_t swig_types[87]
#define SWIGTYPE_p_svn_txdelta_op_t swig_types[88]
#define SWIGTYPE_p_svn_txdelta_stream_t swig_types[89]
#define SWIGTYPE_p_svn_txdelta_window_t swig_types[90]
#define SWIGTYPE_p_svn_version_checklist_t swig_types[91]
#define SWIGTYPE_p_svn_version_t swig_types[92]
#define SWIGTYPE_p_void swig_types[93]
static swig_type_info *swig_types[94];
static swig_module_info swig_module = {swig_types, 94, 0, 0, 0, 0};
#define SWIG_TypeQuery(name) SWIG_TypeQueryModule(&swig_module, &swig_module, name)
#define SWIG_MangledTypeQuery(name) SWIG_MangledTypeQueryModule(&swig_module, &swig_module, name)

/* -------- TYPES TABLE (END) -------- */

#define SWIG_init    boot_SVN___Repos

#define SWIG_name   "SVN::_Repos::boot_SVN___Repos"
#define SWIG_prefix "SVN::_Repos::"

#ifdef __cplusplus
extern "C"
#endif
#ifndef PERL_OBJECT
#ifndef MULTIPLICITY
SWIGEXPORT void SWIG_init (CV* cv);
#else
SWIGEXPORT void SWIG_init (pTHXo_ CV* cv);
#endif
#else
SWIGEXPORT void SWIG_init (CV *cv, CPerlObj *);
#endif


#include "svn_time.h"
#include "svn_pools.h"


#ifdef SWIGPYTHON
#include "swigutil_py.h"
#endif

#ifdef SWIGPERL
#include "swigutil_pl.h"
#endif

#ifdef SWIGRUBY
#include "swigutil_rb.h"
#endif


#include "svn_repos.h"


static svn_error_t *svn_repos_parse_fns2_invoke_new_revision_record(
  svn_repos_parse_fns2_t *_obj, void **revision_baton, apr_hash_t *headers, void *parse_baton, apr_pool_t *pool) {
  return _obj->new_revision_record(revision_baton, headers, parse_baton, pool);
}

static svn_error_t *svn_repos_parse_fns2_invoke_uuid_record(
  svn_repos_parse_fns2_t *_obj, const char *uuid, void *parse_baton, apr_pool_t *pool) {
  return _obj->uuid_record(uuid, parse_baton, pool);
}

static svn_error_t *svn_repos_parse_fns2_invoke_new_node_record(
  svn_repos_parse_fns2_t *_obj, void **node_baton, apr_hash_t *headers, void *revision_baton, apr_pool_t *pool) {
  return _obj->new_node_record(node_baton, headers, revision_baton, pool);
}

static svn_error_t *svn_repos_parse_fns2_invoke_set_revision_property(
  svn_repos_parse_fns2_t *_obj, void *revision_baton, const char *name, const svn_string_t *value) {
  return _obj->set_revision_property(revision_baton, name, value);
}

static svn_error_t *svn_repos_parse_fns2_invoke_set_node_property(
  svn_repos_parse_fns2_t *_obj, void *node_baton, const char *name, const svn_string_t *value) {
  return _obj->set_node_property(node_baton, name, value);
}

static svn_error_t *svn_repos_parse_fns2_invoke_delete_node_property(
  svn_repos_parse_fns2_t *_obj, void *node_baton, const char *name) {
  return _obj->delete_node_property(node_baton, name);
}

static svn_error_t *svn_repos_parse_fns2_invoke_remove_node_props(
  svn_repos_parse_fns2_t *_obj, void *node_baton) {
  return _obj->remove_node_props(node_baton);
}

static svn_error_t *svn_repos_parse_fns2_invoke_set_fulltext(
  svn_repos_parse_fns2_t *_obj, svn_stream_t **stream, void *node_baton) {
  return _obj->set_fulltext(stream, node_baton);
}

static svn_error_t *svn_repos_parse_fns2_invoke_apply_textdelta(
  svn_repos_parse_fns2_t *_obj, svn_txdelta_window_handler_t *handler, void **handler_baton, void *node_baton) {
  return _obj->apply_textdelta(handler, handler_baton, node_baton);
}

static svn_error_t *svn_repos_parse_fns2_invoke_close_node(
  svn_repos_parse_fns2_t *_obj, void *node_baton) {
  return _obj->close_node(node_baton);
}

static svn_error_t *svn_repos_parse_fns2_invoke_close_revision(
  svn_repos_parse_fns2_t *_obj, void *revision_baton) {
  return _obj->close_revision(revision_baton);
}


#ifdef PERL_OBJECT
#define MAGIC_CLASS _wrap_SVN::_Repos_var::
class _wrap_SVN::_Repos_var : public CPerlObj {
public:
#else
#define MAGIC_CLASS
#endif
SWIGCLASS_STATIC int swig_magic_readonly(pTHX_ SV *sv, MAGIC *mg) {
    MAGIC_PPERL
    sv = sv; mg = mg;
    croak("Value is read-only.");
    return 0;
}


#ifdef PERL_OBJECT
};
#endif

#ifdef __cplusplus
extern "C" {
#endif
XS(_wrap_svn_repos_version) {
    {
        svn_version_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 0) || (items > 0)) {
            SWIG_croak("Usage: svn_repos_version();");
        }
        {
            result = (svn_version_t *)svn_repos_version();
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_version_t, SWIG_SHADOW|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_find_root_path) {
    {
        char *arg1 = (char *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_find_root_path(path,pool);");
        }
        if (!SvOK((SV*) ST(0))) arg1 = 0;
        else arg1 = (char *) SvPV(ST(0), PL_na);
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_find_root_path((char const *)arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_open) {
    {
        svn_repos_t **arg1 = (svn_repos_t **) 0 ;
        char *arg2 = (char *) 0 ;
        apr_pool_t *arg3 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_repos_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg3 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_repos_t **)&temp1;
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_open(path,pool);");
        }
        if (!SvOK((SV*) ST(0))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(0), PL_na);
        if (items > 1) {
            
        }
        {
            result = (svn_error_t *)svn_repos_open(arg1,(char const *)arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_repos_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_create) {
    {
        svn_repos_t **arg1 = (svn_repos_t **) 0 ;
        char *arg2 = (char *) 0 ;
        char *arg3 = (char *) 0 ;
        char *arg4 = (char *) 0 ;
        apr_hash_t *arg5 = (apr_hash_t *) 0 ;
        apr_hash_t *arg6 = (apr_hash_t *) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_repos_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_repos_t **)&temp1;
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_repos_create(path,unused_1,unused_2,config,fs_config,pool);");
        }
        if (!SvOK((SV*) ST(0))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(0), PL_na);
        if (!SvOK((SV*) ST(1))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(1), PL_na);
        if (!SvOK((SV*) ST(2))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(2), PL_na);
        {
            arg5 = svn_swig_pl_objs_to_hash_by_name (ST(3), "svn_config_t *",
            _global_pool);
        }
        {
            arg6 = svn_swig_pl_strings_to_hash (ST(4), _global_pool);
        }
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_repos_create(arg1,(char const *)arg2,(char const *)arg3,(char const *)arg4,arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_repos_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_delete) {
    {
        char *arg1 = (char *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_delete(path,pool);");
        }
        if (!SvOK((SV*) ST(0))) arg1 = 0;
        else arg1 = (char *) SvPV(ST(0), PL_na);
        if (items > 1) {
            
        }
        {
            result = (svn_error_t *)svn_repos_delete((char const *)arg1,arg2);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        svn_fs_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_fs(repos);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_fs. Expected _p_svn_repos_t");
            }
        }
        {
            result = (svn_fs_t *)svn_repos_fs(arg1);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_fs_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_hotcopy) {
    {
        char *arg1 = (char *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_boolean_t arg3 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_repos_hotcopy(src_path,dst_path,clean_logs,pool);");
        }
        if (!SvOK((SV*) ST(0))) arg1 = 0;
        else arg1 = (char *) SvPV(ST(0), PL_na);
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        arg3 = (svn_boolean_t) SvIV(ST(2));
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_repos_hotcopy((char const *)arg1,(char const *)arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_recover) {
    {
        char *arg1 = (char *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_recover(path,pool);");
        }
        if (!SvOK((SV*) ST(0))) arg1 = 0;
        else arg1 = (char *) SvPV(ST(0), PL_na);
        if (items > 1) {
            
        }
        {
            result = (svn_error_t *)svn_repos_recover((char const *)arg1,arg2);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_recover2) {
    {
        char *arg1 = (char *) 0 ;
        svn_boolean_t arg2 ;
        svn_error_t *(*arg3)(void *) = (svn_error_t *(*)(void *)) 0 ;
        void *arg4 = (void *) 0 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_repos_recover2(path,nonblocking,start_callback,start_callback_baton,pool);");
        }
        if (!SvOK((SV*) ST(0))) arg1 = 0;
        else arg1 = (char *) SvPV(ST(0), PL_na);
        arg2 = (svn_boolean_t) SvIV(ST(1));
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg3, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_recover2. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(3), (void **) &arg4, 0,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_recover2. Expected _p_void");
            }
        }
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_repos_recover2((char const *)arg1,arg2,arg3,arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_db_logfiles) {
    {
        apr_array_header_t **arg1 = (apr_array_header_t **) 0 ;
        char *arg2 = (char *) 0 ;
        svn_boolean_t arg3 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        apr_array_header_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = &temp1;
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_repos_db_logfiles(path,only_unused,pool);");
        }
        if (!SvOK((SV*) ST(0))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(0), PL_na);
        arg3 = (svn_boolean_t) SvIV(ST(1));
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_repos_db_logfiles(arg1,(char const *)arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = svn_swig_pl_array_to_list(*arg1);
            ++argvi;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_path) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_path(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_path. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_path(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_db_env) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_db_env(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_db_env. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_db_env(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_conf_dir) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_conf_dir(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_conf_dir. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_conf_dir(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_svnserve_conf) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_svnserve_conf(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_svnserve_conf. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_svnserve_conf(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_lock_dir) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_lock_dir(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_lock_dir. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_lock_dir(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_db_lockfile) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_db_lockfile(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_db_lockfile. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_db_lockfile(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_db_logs_lockfile) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_db_logs_lockfile(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_db_logs_lockfile. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_db_logs_lockfile(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_hook_dir) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_hook_dir(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_hook_dir. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_hook_dir(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_start_commit_hook) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_start_commit_hook(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_start_commit_hook. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_start_commit_hook(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_pre_commit_hook) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_pre_commit_hook(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_pre_commit_hook. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_pre_commit_hook(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_post_commit_hook) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_post_commit_hook(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_post_commit_hook. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_post_commit_hook(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_pre_revprop_change_hook) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_pre_revprop_change_hook(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_pre_revprop_change_hook. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_pre_revprop_change_hook(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_post_revprop_change_hook) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_post_revprop_change_hook(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_post_revprop_change_hook. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_post_revprop_change_hook(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_pre_lock_hook) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_pre_lock_hook(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_pre_lock_hook. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_pre_lock_hook(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_post_lock_hook) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_post_lock_hook(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_post_lock_hook. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_post_lock_hook(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_pre_unlock_hook) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_pre_unlock_hook(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_pre_unlock_hook. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_pre_unlock_hook(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_post_unlock_hook) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        char *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_post_unlock_hook(repos,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_post_unlock_hook. Expected _p_svn_repos_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (char *)svn_repos_post_unlock_hook(arg1,arg2);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_begin_report) {
    {
        void **arg1 = (void **) 0 ;
        svn_revnum_t arg2 ;
        char *arg3 = (char *) 0 ;
        svn_repos_t *arg4 = (svn_repos_t *) 0 ;
        char *arg5 = (char *) 0 ;
        char *arg6 = (char *) 0 ;
        char *arg7 = (char *) 0 ;
        svn_boolean_t arg8 ;
        svn_boolean_t arg9 ;
        svn_boolean_t arg10 ;
        svn_delta_editor_t *arg11 = (svn_delta_editor_t *) 0 ;
        void *arg12 = (void *) 0 ;
        svn_repos_authz_func_t arg13 = (svn_repos_authz_func_t) 0 ;
        void *arg14 = (void *) 0 ;
        apr_pool_t *arg15 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        void *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg15 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (void **)&temp1;
        }
        if ((items < 11) || (items > 12)) {
            SWIG_croak("Usage: svn_repos_begin_report(revnum,username,repos,fs_base,target,tgt_path,text_deltas,recurse,ignore_ancestry,editor,edit_baton,authz_read_func,authz_read_baton,pool);");
        }
        arg2 = (svn_revnum_t) SvIV(ST(0));
        if (!SvOK((SV*) ST(1))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(1), PL_na);
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg4, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_begin_report. Expected _p_svn_repos_t");
            }
        }
        if (!SvOK((SV*) ST(3))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(3), PL_na);
        if (!SvOK((SV*) ST(4))) arg6 = 0;
        else arg6 = (char *) SvPV(ST(4), PL_na);
        if (!SvOK((SV*) ST(5))) arg7 = 0;
        else arg7 = (char *) SvPV(ST(5), PL_na);
        arg8 = (svn_boolean_t) SvIV(ST(6));
        arg9 = (svn_boolean_t) SvIV(ST(7));
        arg10 = (svn_boolean_t) SvIV(ST(8));
        {
            svn_delta_make_editor(&arg11, &arg12, ST(9), _global_pool);
        }
        {
            if (SvOK (ST(10))) {
                arg13 = svn_swig_pl_thunk_authz_func;
                arg14 = ST(10); /* our function is the baton */
            }
            else {
                arg13 = NULL;
                arg14 = NULL;
            }
        }
        if (items > 11) {
            
        }
        {
            result = (svn_error_t *)svn_repos_begin_report(arg1,arg2,(char const *)arg3,arg4,(char const *)arg5,(char const *)arg6,(char const *)arg7,arg8,arg9,arg10,(struct svn_delta_editor_t const *)arg11,arg12,arg13,arg14,arg15);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_set_path2) {
    {
        void *arg1 = (void *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_revnum_t arg3 ;
        svn_boolean_t arg4 ;
        char *arg5 = (char *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_repos_set_path2(report_baton,path,revision,start_empty,lock_token,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, 0,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_set_path2. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        arg3 = (svn_revnum_t) SvIV(ST(2));
        arg4 = (svn_boolean_t) SvIV(ST(3));
        if (!SvOK((SV*) ST(4))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(4), PL_na);
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_repos_set_path2(arg1,(char const *)arg2,arg3,arg4,(char const *)arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_set_path) {
    {
        void *arg1 = (void *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_revnum_t arg3 ;
        svn_boolean_t arg4 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_repos_set_path(report_baton,path,revision,start_empty,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, 0,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_set_path. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        arg3 = (svn_revnum_t) SvIV(ST(2));
        arg4 = (svn_boolean_t) SvIV(ST(3));
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_repos_set_path(arg1,(char const *)arg2,arg3,arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_link_path2) {
    {
        void *arg1 = (void *) 0 ;
        char *arg2 = (char *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_revnum_t arg4 ;
        svn_boolean_t arg5 ;
        char *arg6 = (char *) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_repos_link_path2(report_baton,path,link_path,revision,start_empty,lock_token,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, 0,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_link_path2. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (svn_boolean_t) SvIV(ST(4));
        if (!SvOK((SV*) ST(5))) arg6 = 0;
        else arg6 = (char *) SvPV(ST(5), PL_na);
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_repos_link_path2(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,(char const *)arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_link_path) {
    {
        void *arg1 = (void *) 0 ;
        char *arg2 = (char *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_revnum_t arg4 ;
        svn_boolean_t arg5 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_repos_link_path(report_baton,path,link_path,revision,start_empty,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, 0,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_link_path. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (svn_boolean_t) SvIV(ST(4));
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_repos_link_path(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_delete_path) {
    {
        void *arg1 = (void *) 0 ;
        char *arg2 = (char *) 0 ;
        apr_pool_t *arg3 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg3 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_repos_delete_path(report_baton,path,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, 0,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_delete_path. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_repos_delete_path(arg1,(char const *)arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_finish_report) {
    {
        void *arg1 = (void *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_finish_report(report_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, 0,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_finish_report. Expected _p_void");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (svn_error_t *)svn_repos_finish_report(arg1,arg2);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_abort_report) {
    {
        void *arg1 = (void *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_abort_report(report_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, 0,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_abort_report. Expected _p_void");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (svn_error_t *)svn_repos_abort_report(arg1,arg2);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_dir_delta) {
    {
        svn_fs_root_t *arg1 = (svn_fs_root_t *) 0 ;
        char *arg2 = (char *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_fs_root_t *arg4 = (svn_fs_root_t *) 0 ;
        char *arg5 = (char *) 0 ;
        svn_delta_editor_t *arg6 = (svn_delta_editor_t *) 0 ;
        void *arg7 = (void *) 0 ;
        svn_repos_authz_func_t arg8 = (svn_repos_authz_func_t) 0 ;
        void *arg9 = (void *) 0 ;
        svn_boolean_t arg10 ;
        svn_boolean_t arg11 ;
        svn_boolean_t arg12 ;
        svn_boolean_t arg13 ;
        apr_pool_t *arg14 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg14 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 11) || (items > 12)) {
            SWIG_croak("Usage: svn_repos_dir_delta(src_root,src_parent_dir,src_entry,tgt_root,tgt_path,editor,edit_baton,authz_read_func,authz_read_baton,text_deltas,recurse,entry_props,ignore_ancestry,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_fs_root_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_dir_delta. Expected _p_svn_fs_root_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        {
            if (SWIG_ConvertPtr(ST(3), (void **) &arg4, SWIGTYPE_p_svn_fs_root_t,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_dir_delta. Expected _p_svn_fs_root_t");
            }
        }
        if (!SvOK((SV*) ST(4))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(4), PL_na);
        {
            svn_delta_make_editor(&arg6, &arg7, ST(5), _global_pool);
        }
        {
            if (SvOK (ST(6))) {
                arg8 = svn_swig_pl_thunk_authz_func;
                arg9 = ST(6); /* our function is the baton */
            }
            else {
                arg8 = NULL;
                arg9 = NULL;
            }
        }
        arg10 = (svn_boolean_t) SvIV(ST(7));
        arg11 = (svn_boolean_t) SvIV(ST(8));
        arg12 = (svn_boolean_t) SvIV(ST(9));
        arg13 = (svn_boolean_t) SvIV(ST(10));
        if (items > 11) {
            
        }
        {
            result = (svn_error_t *)svn_repos_dir_delta(arg1,(char const *)arg2,(char const *)arg3,arg4,(char const *)arg5,(struct svn_delta_editor_t const *)arg6,arg7,arg8,arg9,arg10,arg11,arg12,arg13,arg14);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_replay2) {
    {
        svn_fs_root_t *arg1 = (svn_fs_root_t *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_revnum_t arg3 ;
        svn_boolean_t arg4 ;
        svn_delta_editor_t *arg5 = (svn_delta_editor_t *) 0 ;
        void *arg6 = (void *) 0 ;
        svn_repos_authz_func_t arg7 = (svn_repos_authz_func_t) 0 ;
        void *arg8 = (void *) 0 ;
        apr_pool_t *arg9 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg9 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_repos_replay2(root,base_dir,low_water_mark,send_deltas,editor,edit_baton,authz_read_func,authz_read_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_fs_root_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_replay2. Expected _p_svn_fs_root_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        arg3 = (svn_revnum_t) SvIV(ST(2));
        arg4 = (svn_boolean_t) SvIV(ST(3));
        {
            svn_delta_make_editor(&arg5, &arg6, ST(4), _global_pool);
        }
        {
            if (SvOK (ST(5))) {
                arg7 = svn_swig_pl_thunk_authz_func;
                arg8 = ST(5); /* our function is the baton */
            }
            else {
                arg7 = NULL;
                arg8 = NULL;
            }
        }
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_repos_replay2(arg1,(char const *)arg2,arg3,arg4,(struct svn_delta_editor_t const *)arg5,arg6,arg7,arg8,arg9);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_replay) {
    {
        svn_fs_root_t *arg1 = (svn_fs_root_t *) 0 ;
        svn_delta_editor_t *arg2 = (svn_delta_editor_t *) 0 ;
        void *arg3 = (void *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_repos_replay(root,editor,edit_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_fs_root_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_replay. Expected _p_svn_fs_root_t");
            }
        }
        {
            svn_delta_make_editor(&arg2, &arg3, ST(1), _global_pool);
        }
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_repos_replay(arg1,(struct svn_delta_editor_t const *)arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_get_commit_editor4) {
    {
        svn_delta_editor_t **arg1 = (svn_delta_editor_t **) 0 ;
        void **arg2 = (void **) 0 ;
        svn_repos_t *arg3 = (svn_repos_t *) 0 ;
        svn_fs_txn_t *arg4 = (svn_fs_txn_t *) 0 ;
        char *arg5 = (char *) 0 ;
        char *arg6 = (char *) 0 ;
        char *arg7 = (char *) 0 ;
        char *arg8 = (char *) 0 ;
        svn_commit_callback2_t arg9 = (svn_commit_callback2_t) 0 ;
        void *arg10 = (void *) 0 ;
        svn_repos_authz_callback_t arg11 = (svn_repos_authz_callback_t) 0 ;
        void *arg12 = (void *) 0 ;
        apr_pool_t *arg13 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_delta_editor_t const *temp1 ;
        void *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg13 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_delta_editor_t **)&temp1;
        }
        {
            arg2 = (void **)&temp2;
        }
        if ((items < 10) || (items > 11)) {
            SWIG_croak("Usage: svn_repos_get_commit_editor4(repos,txn,repos_url,base_path,user,log_msg,callback,callback_baton,authz_callback,authz_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg3, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_get_commit_editor4. Expected _p_svn_repos_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg4, SWIGTYPE_p_svn_fs_txn_t,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_get_commit_editor4. Expected _p_svn_fs_txn_t");
            }
        }
        if (!SvOK((SV*) ST(2))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(2), PL_na);
        if (!SvOK((SV*) ST(3))) arg6 = 0;
        else arg6 = (char *) SvPV(ST(3), PL_na);
        if (!SvOK((SV*) ST(4))) arg7 = 0;
        else arg7 = (char *) SvPV(ST(4), PL_na);
        if (!SvOK((SV*) ST(5))) arg8 = 0;
        else arg8 = (char *) SvPV(ST(5), PL_na);
        {
            if (SWIG_ConvertPtr(ST(6), (void **) &arg9, SWIGTYPE_p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 9 of svn_repos_get_commit_editor4. Expected _p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(7), (void **) &arg10, 0,0) < 0) {
                SWIG_croak("Type error in argument 10 of svn_repos_get_commit_editor4. Expected _p_void");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(8), (void **) &arg11, SWIGTYPE_p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 11 of svn_repos_get_commit_editor4. Expected _p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(9), (void **) &arg12, 0,0) < 0) {
                SWIG_croak("Type error in argument 12 of svn_repos_get_commit_editor4. Expected _p_void");
            }
        }
        if (items > 10) {
            
        }
        {
            result = (svn_error_t *)svn_repos_get_commit_editor4((struct svn_delta_editor_t const **)arg1,arg2,arg3,arg4,(char const *)arg5,(char const *)arg6,(char const *)arg7,(char const *)arg8,arg9,arg10,arg11,arg12,arg13);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_delta_editor_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_get_commit_editor3) {
    {
        svn_delta_editor_t **arg1 = (svn_delta_editor_t **) 0 ;
        void **arg2 = (void **) 0 ;
        svn_repos_t *arg3 = (svn_repos_t *) 0 ;
        svn_fs_txn_t *arg4 = (svn_fs_txn_t *) 0 ;
        char *arg5 = (char *) 0 ;
        char *arg6 = (char *) 0 ;
        char *arg7 = (char *) 0 ;
        char *arg8 = (char *) 0 ;
        svn_commit_callback_t arg9 = (svn_commit_callback_t) 0 ;
        void *arg10 = (void *) 0 ;
        svn_repos_authz_callback_t arg11 = (svn_repos_authz_callback_t) 0 ;
        void *arg12 = (void *) 0 ;
        apr_pool_t *arg13 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_delta_editor_t const *temp1 ;
        void *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg13 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_delta_editor_t **)&temp1;
        }
        {
            arg2 = (void **)&temp2;
        }
        if ((items < 9) || (items > 10)) {
            SWIG_croak("Usage: svn_repos_get_commit_editor3(repos,txn,repos_url,base_path,user,log_msg,callback,callback_baton,authz_callback,authz_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg3, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_get_commit_editor3. Expected _p_svn_repos_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg4, SWIGTYPE_p_svn_fs_txn_t,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_get_commit_editor3. Expected _p_svn_fs_txn_t");
            }
        }
        if (!SvOK((SV*) ST(2))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(2), PL_na);
        if (!SvOK((SV*) ST(3))) arg6 = 0;
        else arg6 = (char *) SvPV(ST(3), PL_na);
        if (!SvOK((SV*) ST(4))) arg7 = 0;
        else arg7 = (char *) SvPV(ST(4), PL_na);
        if (!SvOK((SV*) ST(5))) arg8 = 0;
        else arg8 = (char *) SvPV(ST(5), PL_na);
        {
            arg9 = svn_swig_pl_thunk_commit_callback;
            arg10 = (void *)ST(6);
            svn_swig_pl_hold_ref_in_pool (_global_pool, ST(6));
        }
        {
            if (SWIG_ConvertPtr(ST(7), (void **) &arg11, SWIGTYPE_p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 11 of svn_repos_get_commit_editor3. Expected _p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(8), (void **) &arg12, 0,0) < 0) {
                SWIG_croak("Type error in argument 12 of svn_repos_get_commit_editor3. Expected _p_void");
            }
        }
        if (items > 9) {
            
        }
        {
            result = (svn_error_t *)svn_repos_get_commit_editor3((struct svn_delta_editor_t const **)arg1,arg2,arg3,arg4,(char const *)arg5,(char const *)arg6,(char const *)arg7,(char const *)arg8,arg9,arg10,arg11,arg12,arg13);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_delta_editor_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_get_commit_editor2) {
    {
        svn_delta_editor_t **arg1 = (svn_delta_editor_t **) 0 ;
        void **arg2 = (void **) 0 ;
        svn_repos_t *arg3 = (svn_repos_t *) 0 ;
        svn_fs_txn_t *arg4 = (svn_fs_txn_t *) 0 ;
        char *arg5 = (char *) 0 ;
        char *arg6 = (char *) 0 ;
        char *arg7 = (char *) 0 ;
        char *arg8 = (char *) 0 ;
        svn_commit_callback_t arg9 = (svn_commit_callback_t) 0 ;
        void *arg10 = (void *) 0 ;
        apr_pool_t *arg11 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_delta_editor_t const *temp1 ;
        void *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg11 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_delta_editor_t **)&temp1;
        }
        {
            arg2 = (void **)&temp2;
        }
        if ((items < 7) || (items > 8)) {
            SWIG_croak("Usage: svn_repos_get_commit_editor2(repos,txn,repos_url,base_path,user,log_msg,callback,callback_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg3, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_get_commit_editor2. Expected _p_svn_repos_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg4, SWIGTYPE_p_svn_fs_txn_t,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_get_commit_editor2. Expected _p_svn_fs_txn_t");
            }
        }
        if (!SvOK((SV*) ST(2))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(2), PL_na);
        if (!SvOK((SV*) ST(3))) arg6 = 0;
        else arg6 = (char *) SvPV(ST(3), PL_na);
        if (!SvOK((SV*) ST(4))) arg7 = 0;
        else arg7 = (char *) SvPV(ST(4), PL_na);
        if (!SvOK((SV*) ST(5))) arg8 = 0;
        else arg8 = (char *) SvPV(ST(5), PL_na);
        {
            arg9 = svn_swig_pl_thunk_commit_callback;
            arg10 = (void *)ST(6);
            svn_swig_pl_hold_ref_in_pool (_global_pool, ST(6));
        }
        if (items > 7) {
            
        }
        {
            result = (svn_error_t *)svn_repos_get_commit_editor2((struct svn_delta_editor_t const **)arg1,arg2,arg3,arg4,(char const *)arg5,(char const *)arg6,(char const *)arg7,(char const *)arg8,arg9,arg10,arg11);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_delta_editor_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_get_commit_editor) {
    {
        svn_delta_editor_t **arg1 = (svn_delta_editor_t **) 0 ;
        void **arg2 = (void **) 0 ;
        svn_repos_t *arg3 = (svn_repos_t *) 0 ;
        char *arg4 = (char *) 0 ;
        char *arg5 = (char *) 0 ;
        char *arg6 = (char *) 0 ;
        char *arg7 = (char *) 0 ;
        svn_commit_callback_t arg8 = (svn_commit_callback_t) 0 ;
        void *arg9 = (void *) 0 ;
        apr_pool_t *arg10 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_delta_editor_t const *temp1 ;
        void *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg10 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_delta_editor_t **)&temp1;
        }
        {
            arg2 = (void **)&temp2;
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_repos_get_commit_editor(repos,repos_url,base_path,user,log_msg,callback,callback_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg3, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_get_commit_editor. Expected _p_svn_repos_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(1), PL_na);
        if (!SvOK((SV*) ST(2))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(2), PL_na);
        if (!SvOK((SV*) ST(3))) arg6 = 0;
        else arg6 = (char *) SvPV(ST(3), PL_na);
        if (!SvOK((SV*) ST(4))) arg7 = 0;
        else arg7 = (char *) SvPV(ST(4), PL_na);
        {
            arg8 = svn_swig_pl_thunk_commit_callback;
            arg9 = (void *)ST(5);
            svn_swig_pl_hold_ref_in_pool (_global_pool, ST(5));
        }
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_repos_get_commit_editor((struct svn_delta_editor_t const **)arg1,arg2,arg3,(char const *)arg4,(char const *)arg5,(char const *)arg6,(char const *)arg7,arg8,arg9,arg10);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_delta_editor_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_dated_revision) {
    {
        svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
        svn_repos_t *arg2 = (svn_repos_t *) 0 ;
        apr_time_t arg3 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        long temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg1 = &temp1;
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_repos_dated_revision(repos,tm,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg2, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_dated_revision. Expected _p_svn_repos_t");
            }
        }
        arg3 = (apr_time_t) strtoll(SvPV(ST(1), PL_na), 0, 0);
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_repos_dated_revision(arg1,arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg1));
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_get_committed_info) {
    {
        svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
        char **arg2 = (char **) 0 ;
        char **arg3 = (char **) 0 ;
        svn_fs_root_t *arg4 = (svn_fs_root_t *) 0 ;
        char *arg5 = (char *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        long temp1 ;
        char const *temp2 = NULL ;
        char const *temp3 = NULL ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg1 = &temp1;
        arg2 = (char **)&temp2;
        arg3 = (char **)&temp3;
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_repos_get_committed_info(root,path,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg4, SWIGTYPE_p_svn_fs_root_t,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_get_committed_info. Expected _p_svn_fs_root_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(1), PL_na);
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_repos_get_committed_info(arg1,(char const **)arg2,(char const **)arg3,arg4,(char const *)arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg1));
            argvi++;
        }
        {
            if (*arg2 == NULL)
            ST(argvi) = &PL_sv_undef;
            else
            ST(argvi) = sv_2mortal(newSVpv(*arg2, 0));
            ++argvi;
        }
        {
            if (*arg3 == NULL)
            ST(argvi) = &PL_sv_undef;
            else
            ST(argvi) = sv_2mortal(newSVpv(*arg3, 0));
            ++argvi;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_stat) {
    {
        svn_dirent_t **arg1 = (svn_dirent_t **) 0 ;
        svn_fs_root_t *arg2 = (svn_fs_root_t *) 0 ;
        char *arg3 = (char *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_dirent_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_dirent_t **)&temp1;
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_repos_stat(root,path,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg2, SWIGTYPE_p_svn_fs_root_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_stat. Expected _p_svn_fs_root_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(1), PL_na);
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_repos_stat(arg1,arg2,(char const *)arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_dirent_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_history2) {
    {
        svn_fs_t *arg1 = (svn_fs_t *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_repos_history_func_t arg3 = (svn_repos_history_func_t) 0 ;
        void *arg4 = (void *) 0 ;
        svn_repos_authz_func_t arg5 = (svn_repos_authz_func_t) 0 ;
        void *arg6 = (void *) 0 ;
        svn_revnum_t arg7 ;
        svn_revnum_t arg8 ;
        svn_boolean_t arg9 ;
        apr_pool_t *arg10 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg10 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 7) || (items > 8)) {
            SWIG_croak("Usage: svn_repos_history2(fs,path,history_func,history_baton,authz_read_func,authz_read_baton,start,end,cross_copies,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_fs_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_history2. Expected _p_svn_fs_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        {
            arg3 = svn_swig_pl_thunk_history_func;
            arg4 = ST(2); /* our function is the baton. */
        }
        {
            if (SvOK (ST(3))) {
                arg5 = svn_swig_pl_thunk_authz_func;
                arg6 = ST(3); /* our function is the baton */
            }
            else {
                arg5 = NULL;
                arg6 = NULL;
            }
        }
        arg7 = (svn_revnum_t) SvIV(ST(4));
        arg8 = (svn_revnum_t) SvIV(ST(5));
        arg9 = (svn_boolean_t) SvIV(ST(6));
        if (items > 7) {
            
        }
        {
            result = (svn_error_t *)svn_repos_history2(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_history) {
    {
        svn_fs_t *arg1 = (svn_fs_t *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_repos_history_func_t arg3 = (svn_repos_history_func_t) 0 ;
        void *arg4 = (void *) 0 ;
        svn_revnum_t arg5 ;
        svn_revnum_t arg6 ;
        svn_boolean_t arg7 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_repos_history(fs,path,history_func,history_baton,start,end,cross_copies,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_fs_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_history. Expected _p_svn_fs_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        {
            arg3 = svn_swig_pl_thunk_history_func;
            arg4 = ST(2); /* our function is the baton. */
        }
        arg5 = (svn_revnum_t) SvIV(ST(3));
        arg6 = (svn_revnum_t) SvIV(ST(4));
        arg7 = (svn_boolean_t) SvIV(ST(5));
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_repos_history(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_trace_node_locations) {
    {
        svn_fs_t *arg1 = (svn_fs_t *) 0 ;
        apr_hash_t **arg2 = (apr_hash_t **) 0 ;
        char *arg3 = (char *) 0 ;
        svn_revnum_t arg4 ;
        apr_array_header_t *arg5 = (apr_array_header_t *) 0 ;
        svn_repos_authz_func_t arg6 = (svn_repos_authz_func_t) 0 ;
        void *arg7 = (void *) 0 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_repos_trace_node_locations(fs,locations,fs_path,peg_revision,location_revisions,authz_read_func,authz_read_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_fs_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_trace_node_locations. Expected _p_svn_fs_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_p_apr_hash_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_trace_node_locations. Expected _p_p_apr_hash_t");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_revnum_t) SvIV(ST(3));
        {
            if (SWIG_ConvertPtr(ST(4), (void **) &arg5, SWIGTYPE_p_apr_array_header_t,0) < 0) {
                SWIG_croak("Type error in argument 5 of svn_repos_trace_node_locations. Expected _p_apr_array_header_t");
            }
        }
        {
            if (SvOK (ST(5))) {
                arg6 = svn_swig_pl_thunk_authz_func;
                arg7 = ST(5); /* our function is the baton */
            }
            else {
                arg6 = NULL;
                arg7 = NULL;
            }
        }
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_repos_trace_node_locations(arg1,arg2,(char const *)arg3,arg4,arg5,arg6,arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_get_logs3) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
        svn_revnum_t arg3 ;
        svn_revnum_t arg4 ;
        int arg5 ;
        svn_boolean_t arg6 ;
        svn_boolean_t arg7 ;
        svn_repos_authz_func_t arg8 = (svn_repos_authz_func_t) 0 ;
        void *arg9 = (void *) 0 ;
        svn_log_message_receiver_t arg10 = (svn_log_message_receiver_t) 0 ;
        void *arg11 = (void *) 0 ;
        apr_pool_t *arg12 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg12 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 9) || (items > 10)) {
            SWIG_croak("Usage: svn_repos_get_logs3(repos,paths,start,end,limit,discover_changed_paths,strict_node_history,authz_read_func,authz_read_baton,receiver,receiver_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_get_logs3. Expected _p_svn_repos_t");
            }
        }
        {
            arg2 = (apr_array_header_t *) svn_swig_pl_strings_to_array(ST(1),
            _global_pool);
        }
        arg3 = (svn_revnum_t) SvIV(ST(2));
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (int) SvIV(ST(4));
        arg6 = (svn_boolean_t) SvIV(ST(5));
        arg7 = (svn_boolean_t) SvIV(ST(6));
        {
            if (SvOK (ST(7))) {
                arg8 = svn_swig_pl_thunk_authz_func;
                arg9 = ST(7); /* our function is the baton */
            }
            else {
                arg8 = NULL;
                arg9 = NULL;
            }
        }
        {
            arg10 = svn_swig_pl_thunk_log_receiver;
            arg11 = (void *)ST(8);
        }
        if (items > 9) {
            
        }
        {
            result = (svn_error_t *)svn_repos_get_logs3(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10,arg11,arg12);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_get_logs2) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
        svn_revnum_t arg3 ;
        svn_revnum_t arg4 ;
        svn_boolean_t arg5 ;
        svn_boolean_t arg6 ;
        svn_repos_authz_func_t arg7 = (svn_repos_authz_func_t) 0 ;
        void *arg8 = (void *) 0 ;
        svn_log_message_receiver_t arg9 = (svn_log_message_receiver_t) 0 ;
        void *arg10 = (void *) 0 ;
        apr_pool_t *arg11 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg11 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 8) || (items > 9)) {
            SWIG_croak("Usage: svn_repos_get_logs2(repos,paths,start,end,discover_changed_paths,strict_node_history,authz_read_func,authz_read_baton,receiver,receiver_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_get_logs2. Expected _p_svn_repos_t");
            }
        }
        {
            arg2 = (apr_array_header_t *) svn_swig_pl_strings_to_array(ST(1),
            _global_pool);
        }
        arg3 = (svn_revnum_t) SvIV(ST(2));
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (svn_boolean_t) SvIV(ST(4));
        arg6 = (svn_boolean_t) SvIV(ST(5));
        {
            if (SvOK (ST(6))) {
                arg7 = svn_swig_pl_thunk_authz_func;
                arg8 = ST(6); /* our function is the baton */
            }
            else {
                arg7 = NULL;
                arg8 = NULL;
            }
        }
        {
            arg9 = svn_swig_pl_thunk_log_receiver;
            arg10 = (void *)ST(7);
        }
        if (items > 8) {
            
        }
        {
            result = (svn_error_t *)svn_repos_get_logs2(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10,arg11);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_get_logs) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
        svn_revnum_t arg3 ;
        svn_revnum_t arg4 ;
        svn_boolean_t arg5 ;
        svn_boolean_t arg6 ;
        svn_log_message_receiver_t arg7 = (svn_log_message_receiver_t) 0 ;
        void *arg8 = (void *) 0 ;
        apr_pool_t *arg9 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg9 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 7) || (items > 8)) {
            SWIG_croak("Usage: svn_repos_get_logs(repos,paths,start,end,discover_changed_paths,strict_node_history,receiver,receiver_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_get_logs. Expected _p_svn_repos_t");
            }
        }
        {
            arg2 = (apr_array_header_t *) svn_swig_pl_strings_to_array(ST(1),
            _global_pool);
        }
        arg3 = (svn_revnum_t) SvIV(ST(2));
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (svn_boolean_t) SvIV(ST(4));
        arg6 = (svn_boolean_t) SvIV(ST(5));
        {
            arg7 = svn_swig_pl_thunk_log_receiver;
            arg8 = (void *)ST(6);
        }
        if (items > 7) {
            
        }
        {
            result = (svn_error_t *)svn_repos_get_logs(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_get_file_revs) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_revnum_t arg3 ;
        svn_revnum_t arg4 ;
        svn_repos_authz_func_t arg5 = (svn_repos_authz_func_t) 0 ;
        void *arg6 = (void *) 0 ;
        svn_repos_file_rev_handler_t arg7 = (svn_repos_file_rev_handler_t) 0 ;
        void *arg8 = (void *) 0 ;
        apr_pool_t *arg9 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg9 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 7) || (items > 8)) {
            SWIG_croak("Usage: svn_repos_get_file_revs(repos,path,start,end,authz_read_func,authz_read_baton,handler,handler_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_get_file_revs. Expected _p_svn_repos_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        arg3 = (svn_revnum_t) SvIV(ST(2));
        arg4 = (svn_revnum_t) SvIV(ST(3));
        {
            if (SvOK (ST(4))) {
                arg5 = svn_swig_pl_thunk_authz_func;
                arg6 = ST(4); /* our function is the baton */
            }
            else {
                arg5 = NULL;
                arg6 = NULL;
            }
        }
        {
            if (SWIG_ConvertPtr(ST(5), (void **) &arg7, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 7 of svn_repos_get_file_revs. Expected _p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(6), (void **) &arg8, 0,0) < 0) {
                SWIG_croak("Type error in argument 8 of svn_repos_get_file_revs. Expected _p_void");
            }
        }
        if (items > 7) {
            
        }
        {
            result = (svn_error_t *)svn_repos_get_file_revs(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_commit_txn) {
    {
        char **arg1 = (char **) 0 ;
        svn_repos_t *arg2 = (svn_repos_t *) 0 ;
        svn_revnum_t *arg3 = (svn_revnum_t *) 0 ;
        svn_fs_txn_t *arg4 = (svn_fs_txn_t *) 0 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        char const *temp1 = NULL ;
        long temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg1 = (char **)&temp1;
        arg3 = &temp3;
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_repos_fs_commit_txn(repos,txn,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg2, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_fs_commit_txn. Expected _p_svn_repos_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg4, SWIGTYPE_p_svn_fs_txn_t,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_fs_commit_txn. Expected _p_svn_fs_txn_t");
            }
        }
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_commit_txn((char const **)arg1,arg2,arg3,arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (*arg1 == NULL)
            ST(argvi) = &PL_sv_undef;
            else
            ST(argvi) = sv_2mortal(newSVpv(*arg1, 0));
            ++argvi;
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg3));
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_begin_txn_for_commit) {
    {
        svn_fs_txn_t **arg1 = (svn_fs_txn_t **) 0 ;
        svn_repos_t *arg2 = (svn_repos_t *) 0 ;
        svn_revnum_t arg3 ;
        char *arg4 = (char *) 0 ;
        char *arg5 = (char *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_fs_txn_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_fs_txn_t **)&temp1;
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_repos_fs_begin_txn_for_commit(repos,rev,author,log_msg,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg2, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_fs_begin_txn_for_commit. Expected _p_svn_repos_t");
            }
        }
        arg3 = (svn_revnum_t) SvIV(ST(1));
        if (!SvOK((SV*) ST(2))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(2), PL_na);
        if (!SvOK((SV*) ST(3))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(3), PL_na);
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_begin_txn_for_commit(arg1,arg2,arg3,(char const *)arg4,(char const *)arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_fs_txn_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_begin_txn_for_update) {
    {
        svn_fs_txn_t **arg1 = (svn_fs_txn_t **) 0 ;
        svn_repos_t *arg2 = (svn_repos_t *) 0 ;
        svn_revnum_t arg3 ;
        char *arg4 = (char *) 0 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_fs_txn_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_fs_txn_t **)&temp1;
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_repos_fs_begin_txn_for_update(repos,rev,author,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg2, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_fs_begin_txn_for_update. Expected _p_svn_repos_t");
            }
        }
        arg3 = (svn_revnum_t) SvIV(ST(1));
        if (!SvOK((SV*) ST(2))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(2), PL_na);
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_begin_txn_for_update(arg1,arg2,arg3,(char const *)arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_fs_txn_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_lock) {
    {
        svn_lock_t **arg1 = (svn_lock_t **) 0 ;
        svn_repos_t *arg2 = (svn_repos_t *) 0 ;
        char *arg3 = (char *) 0 ;
        char *arg4 = (char *) 0 ;
        char *arg5 = (char *) 0 ;
        svn_boolean_t arg6 ;
        apr_time_t arg7 ;
        svn_revnum_t arg8 ;
        svn_boolean_t arg9 ;
        apr_pool_t *arg10 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_lock_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg10 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_lock_t **)&temp1;
        }
        if ((items < 8) || (items > 9)) {
            SWIG_croak("Usage: svn_repos_fs_lock(repos,path,token,comment,is_dav_comment,expiration_date,current_rev,steal_lock,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg2, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_fs_lock. Expected _p_svn_repos_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(1), PL_na);
        if (!SvOK((SV*) ST(2))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(2), PL_na);
        if (!SvOK((SV*) ST(3))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(3), PL_na);
        arg6 = (svn_boolean_t) SvIV(ST(4));
        arg7 = (apr_time_t) strtoll(SvPV(ST(5), PL_na), 0, 0);
        arg8 = (svn_revnum_t) SvIV(ST(6));
        arg9 = (svn_boolean_t) SvIV(ST(7));
        if (items > 8) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_lock(arg1,arg2,(char const *)arg3,(char const *)arg4,(char const *)arg5,arg6,arg7,arg8,arg9,arg10);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_lock_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_unlock) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        char *arg2 = (char *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_boolean_t arg4 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_repos_fs_unlock(repos,path,token,break_lock,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_fs_unlock. Expected _p_svn_repos_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_boolean_t) SvIV(ST(3));
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_unlock(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_get_locks) {
    {
        apr_hash_t **arg1 = (apr_hash_t **) 0 ;
        svn_repos_t *arg2 = (svn_repos_t *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_repos_authz_func_t arg4 = (svn_repos_authz_func_t) 0 ;
        void *arg5 = (void *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_repos_fs_get_locks(locks,repos,path,authz_read_func,authz_read_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_p_apr_hash_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_fs_get_locks. Expected _p_p_apr_hash_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_fs_get_locks. Expected _p_svn_repos_t");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        {
            if (SvOK (ST(3))) {
                arg4 = svn_swig_pl_thunk_authz_func;
                arg5 = ST(3); /* our function is the baton */
            }
            else {
                arg4 = NULL;
                arg5 = NULL;
            }
        }
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_get_locks(arg1,arg2,(char const *)arg3,arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_change_rev_prop2) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        svn_revnum_t arg2 ;
        char *arg3 = (char *) 0 ;
        char *arg4 = (char *) 0 ;
        svn_string_t *arg5 = (svn_string_t *) 0 ;
        svn_repos_authz_func_t arg6 = (svn_repos_authz_func_t) 0 ;
        void *arg7 = (void *) 0 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_string_t value5 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_repos_fs_change_rev_prop2(repos,rev,author,name,new_value,authz_read_func,authz_read_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_fs_change_rev_prop2. Expected _p_svn_repos_t");
            }
        }
        arg2 = (svn_revnum_t) SvIV(ST(1));
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        if (!SvOK((SV*) ST(3))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(3), PL_na);
        {
            if (SvOK(ST(4))) {
                value5.data = SvPV(ST(4), value5.len);
                arg5 = &value5;
            }
            else {
                arg5 = NULL;
            }
        }
        {
            if (SvOK (ST(5))) {
                arg6 = svn_swig_pl_thunk_authz_func;
                arg7 = ST(5); /* our function is the baton */
            }
            else {
                arg6 = NULL;
                arg7 = NULL;
            }
        }
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_change_rev_prop2(arg1,arg2,(char const *)arg3,(char const *)arg4,(struct svn_string_t const *)arg5,arg6,arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_change_rev_prop) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        svn_revnum_t arg2 ;
        char *arg3 = (char *) 0 ;
        char *arg4 = (char *) 0 ;
        svn_string_t *arg5 = (svn_string_t *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_string_t value5 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_repos_fs_change_rev_prop(repos,rev,author,name,new_value,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_fs_change_rev_prop. Expected _p_svn_repos_t");
            }
        }
        arg2 = (svn_revnum_t) SvIV(ST(1));
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        if (!SvOK((SV*) ST(3))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(3), PL_na);
        {
            if (SvOK(ST(4))) {
                value5.data = SvPV(ST(4), value5.len);
                arg5 = &value5;
            }
            else {
                arg5 = NULL;
            }
        }
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_change_rev_prop(arg1,arg2,(char const *)arg3,(char const *)arg4,(struct svn_string_t const *)arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_revision_prop) {
    {
        svn_string_t **arg1 = (svn_string_t **) 0 ;
        svn_repos_t *arg2 = (svn_repos_t *) 0 ;
        svn_revnum_t arg3 ;
        char *arg4 = (char *) 0 ;
        svn_repos_authz_func_t arg5 = (svn_repos_authz_func_t) 0 ;
        void *arg6 = (void *) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_string_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = &temp1;
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_repos_fs_revision_prop(repos,rev,propname,authz_read_func,authz_read_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg2, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_fs_revision_prop. Expected _p_svn_repos_t");
            }
        }
        arg3 = (svn_revnum_t) SvIV(ST(1));
        if (!SvOK((SV*) ST(2))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(2), PL_na);
        {
            if (SvOK (ST(3))) {
                arg5 = svn_swig_pl_thunk_authz_func;
                arg6 = ST(3); /* our function is the baton */
            }
            else {
                arg5 = NULL;
                arg6 = NULL;
            }
        }
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_revision_prop(arg1,arg2,arg3,(char const *)arg4,arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (*arg1) {
                ST(argvi) = sv_newmortal();
                sv_setpvn (ST(argvi), (*arg1)->data, (*arg1)->len);
            }
            else
            ST(argvi) = &PL_sv_undef;
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_revision_proplist) {
    {
        apr_hash_t **arg1 = (apr_hash_t **) 0 ;
        svn_repos_t *arg2 = (svn_repos_t *) 0 ;
        svn_revnum_t arg3 ;
        svn_repos_authz_func_t arg4 = (svn_repos_authz_func_t) 0 ;
        void *arg5 = (void *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        apr_hash_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg1 = &temp1;
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_repos_fs_revision_proplist(repos,rev,authz_read_func,authz_read_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg2, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_fs_revision_proplist. Expected _p_svn_repos_t");
            }
        }
        arg3 = (svn_revnum_t) SvIV(ST(1));
        {
            if (SvOK (ST(2))) {
                arg4 = svn_swig_pl_thunk_authz_func;
                arg5 = ST(2); /* our function is the baton */
            }
            else {
                arg4 = NULL;
                arg5 = NULL;
            }
        }
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_revision_proplist(arg1,arg2,arg3,arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = svn_swig_pl_prophash_to_hash(*arg1);
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_change_node_prop) {
    {
        svn_fs_root_t *arg1 = (svn_fs_root_t *) 0 ;
        char *arg2 = (char *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_string_t *arg4 = (svn_string_t *) 0 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_string_t value4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_repos_fs_change_node_prop(root,path,name,value,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_fs_root_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_fs_change_node_prop. Expected _p_svn_fs_root_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        {
            if (SvOK(ST(3))) {
                value4.data = SvPV(ST(3), value4.len);
                arg4 = &value4;
            }
            else {
                arg4 = NULL;
            }
        }
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_change_node_prop(arg1,(char const *)arg2,(char const *)arg3,(struct svn_string_t const *)arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_fs_change_txn_prop) {
    {
        svn_fs_txn_t *arg1 = (svn_fs_txn_t *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_string_t *arg3 = (svn_string_t *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_string_t value3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_repos_fs_change_txn_prop(txn,name,value,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_fs_txn_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_fs_change_txn_prop. Expected _p_svn_fs_txn_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        {
            if (SvOK(ST(2))) {
                value3.data = SvPV(ST(2), value3.len);
                arg3 = &value3;
            }
            else {
                arg3 = NULL;
            }
        }
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_repos_fs_change_txn_prop(arg1,(char const *)arg2,(struct svn_string_t const *)arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_kind_set) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        svn_node_kind_t arg2 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_node_t_kind_set(self,kind);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_kind_set. Expected _p_svn_repos_node_t");
            }
        }
        arg2 = (svn_node_kind_t) SvIV(ST(1));
        if (arg1) (arg1)->kind = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_kind_get) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        svn_node_kind_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_node_t_kind_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_kind_get. Expected _p_svn_repos_node_t");
            }
        }
        result = (svn_node_kind_t) ((arg1)->kind);
        
        ST(argvi) = sv_newmortal();
        sv_setiv(ST(argvi++), (IV) result);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_action_set) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        char arg2 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_node_t_action_set(self,action);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_action_set. Expected _p_svn_repos_node_t");
            }
        }
        arg2 = (char) *SvPV(ST(1),PL_na);
        if (arg1) (arg1)->action = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_action_get) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        char result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_node_t_action_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_action_get. Expected _p_svn_repos_node_t");
            }
        }
        result = (char) ((arg1)->action);
        
        ST(argvi) = sv_newmortal();
        sv_setpvn((SV*)ST(argvi++), &result, 1);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_text_mod_set) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        svn_boolean_t arg2 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_node_t_text_mod_set(self,text_mod);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_text_mod_set. Expected _p_svn_repos_node_t");
            }
        }
        arg2 = (svn_boolean_t) SvIV(ST(1));
        if (arg1) (arg1)->text_mod = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_text_mod_get) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        svn_boolean_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_node_t_text_mod_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_text_mod_get. Expected _p_svn_repos_node_t");
            }
        }
        result = (svn_boolean_t) ((arg1)->text_mod);
        
        ST(argvi) = sv_newmortal();
        sv_setiv(ST(argvi++), (IV) result);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_prop_mod_set) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        svn_boolean_t arg2 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_node_t_prop_mod_set(self,prop_mod);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_prop_mod_set. Expected _p_svn_repos_node_t");
            }
        }
        arg2 = (svn_boolean_t) SvIV(ST(1));
        if (arg1) (arg1)->prop_mod = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_prop_mod_get) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        svn_boolean_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_node_t_prop_mod_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_prop_mod_get. Expected _p_svn_repos_node_t");
            }
        }
        result = (svn_boolean_t) ((arg1)->prop_mod);
        
        ST(argvi) = sv_newmortal();
        sv_setiv(ST(argvi++), (IV) result);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_name_set) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        char *arg2 = (char *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_node_t_name_set(self,name);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_name_set. Expected _p_svn_repos_node_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        {
            apr_size_t len = strlen(arg2) + 1;
            char *copied;
            if (arg1->name) free((char *)arg1->name);
            copied = malloc(len);
            memcpy(copied, arg2, len);
            arg1->name = copied;
        }
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_name_get) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        char *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_node_t_name_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_name_get. Expected _p_svn_repos_node_t");
            }
        }
        result = (char *) ((arg1)->name);
        
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_copyfrom_rev_set) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        svn_revnum_t arg2 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_node_t_copyfrom_rev_set(self,copyfrom_rev);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_copyfrom_rev_set. Expected _p_svn_repos_node_t");
            }
        }
        arg2 = (svn_revnum_t) SvIV(ST(1));
        if (arg1) (arg1)->copyfrom_rev = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_copyfrom_rev_get) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        svn_revnum_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_node_t_copyfrom_rev_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_copyfrom_rev_get. Expected _p_svn_repos_node_t");
            }
        }
        result = (svn_revnum_t) ((arg1)->copyfrom_rev);
        
        ST(argvi) = sv_newmortal();
        sv_setiv(ST(argvi++), (IV) result);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_copyfrom_path_set) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        char *arg2 = (char *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_node_t_copyfrom_path_set(self,copyfrom_path);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_copyfrom_path_set. Expected _p_svn_repos_node_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        {
            if (arg2) {
                arg1->copyfrom_path = (char const *) malloc(strlen(arg2)+1);
                strcpy((char*)arg1->copyfrom_path,arg2);
            } else {
                arg1->copyfrom_path = 0;
            }
        }
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_copyfrom_path_get) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        char *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_node_t_copyfrom_path_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_copyfrom_path_get. Expected _p_svn_repos_node_t");
            }
        }
        result = (char *) ((arg1)->copyfrom_path);
        
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_sibling_set) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        struct svn_repos_node_t *arg2 = (struct svn_repos_node_t *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_node_t_sibling_set(self,sibling);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_sibling_set. Expected _p_svn_repos_node_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_node_t_sibling_set. Expected _p_svn_repos_node_t");
            }
        }
        if (arg1) (arg1)->sibling = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_sibling_get) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        struct svn_repos_node_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_node_t_sibling_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_sibling_get. Expected _p_svn_repos_node_t");
            }
        }
        result = (struct svn_repos_node_t *) ((arg1)->sibling);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_repos_node_t, SWIG_SHADOW|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_child_set) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        struct svn_repos_node_t *arg2 = (struct svn_repos_node_t *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_node_t_child_set(self,child);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_child_set. Expected _p_svn_repos_node_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_node_t_child_set. Expected _p_svn_repos_node_t");
            }
        }
        if (arg1) (arg1)->child = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_child_get) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        struct svn_repos_node_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_node_t_child_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_child_get. Expected _p_svn_repos_node_t");
            }
        }
        result = (struct svn_repos_node_t *) ((arg1)->child);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_repos_node_t, SWIG_SHADOW|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_parent_set) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        struct svn_repos_node_t *arg2 = (struct svn_repos_node_t *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_node_t_parent_set(self,parent);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_parent_set. Expected _p_svn_repos_node_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_node_t_parent_set. Expected _p_svn_repos_node_t");
            }
        }
        if (arg1) (arg1)->parent = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_t_parent_get) {
    {
        svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
        struct svn_repos_node_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_node_t_parent_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_node_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_t_parent_get. Expected _p_svn_repos_node_t");
            }
        }
        result = (struct svn_repos_node_t *) ((arg1)->parent);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_repos_node_t, SWIG_SHADOW|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_editor) {
    {
        svn_delta_editor_t **arg1 = (svn_delta_editor_t **) 0 ;
        void **arg2 = (void **) 0 ;
        svn_repos_t *arg3 = (svn_repos_t *) 0 ;
        svn_fs_root_t *arg4 = (svn_fs_root_t *) 0 ;
        svn_fs_root_t *arg5 = (svn_fs_root_t *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_delta_editor_t const *temp1 ;
        void *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_delta_editor_t **)&temp1;
        }
        {
            arg2 = (void **)&temp2;
        }
        if ((items < 3) || (items > 5)) {
            SWIG_croak("Usage: svn_repos_node_editor(repos,base_root,root,node_pool,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg3, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_node_editor. Expected _p_svn_repos_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg4, SWIGTYPE_p_svn_fs_root_t,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_node_editor. Expected _p_svn_fs_root_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg5, SWIGTYPE_p_svn_fs_root_t,0) < 0) {
                SWIG_croak("Type error in argument 5 of svn_repos_node_editor. Expected _p_svn_fs_root_t");
            }
        }
        if (items > 3) {
            
        }
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_repos_node_editor((struct svn_delta_editor_t const **)arg1,arg2,arg3,arg4,arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_delta_editor_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_node_from_baton) {
    {
        void *arg1 = (void *) 0 ;
        svn_repos_node_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_node_from_baton(edit_baton);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, 0,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_node_from_baton. Expected _p_void");
            }
        }
        {
            result = (svn_repos_node_t *)svn_repos_node_from_baton(arg1);
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_repos_node_t, SWIG_SHADOW|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_dump_fs2) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        svn_stream_t *arg2 = (svn_stream_t *) 0 ;
        svn_stream_t *arg3 = (svn_stream_t *) 0 ;
        svn_revnum_t arg4 ;
        svn_revnum_t arg5 ;
        svn_boolean_t arg6 ;
        svn_boolean_t arg7 ;
        svn_cancel_func_t arg8 = (svn_cancel_func_t) 0 ;
        void *arg9 = (void *) 0 ;
        apr_pool_t *arg10 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg10 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 9) || (items > 10)) {
            SWIG_croak("Usage: svn_repos_dump_fs2(repos,dumpstream,feedback_stream,start_rev,end_rev,incremental,use_deltas,cancel_func,cancel_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_dump_fs2. Expected _p_svn_repos_t");
            }
        }
        {
            svn_swig_pl_make_stream (&arg2, ST(1));
        }
        {
            svn_swig_pl_make_stream (&arg3, ST(2));
        }
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (svn_revnum_t) SvIV(ST(4));
        arg6 = (svn_boolean_t) SvIV(ST(5));
        arg7 = (svn_boolean_t) SvIV(ST(6));
        {
            if (SWIG_ConvertPtr(ST(7), (void **) &arg8, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 8 of svn_repos_dump_fs2. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(8), (void **) &arg9, 0,0) < 0) {
                SWIG_croak("Type error in argument 9 of svn_repos_dump_fs2. Expected _p_void");
            }
        }
        if (items > 9) {
            
        }
        {
            result = (svn_error_t *)svn_repos_dump_fs2(arg1,arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_dump_fs) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        svn_stream_t *arg2 = (svn_stream_t *) 0 ;
        svn_stream_t *arg3 = (svn_stream_t *) 0 ;
        svn_revnum_t arg4 ;
        svn_revnum_t arg5 ;
        svn_boolean_t arg6 ;
        svn_cancel_func_t arg7 = (svn_cancel_func_t) 0 ;
        void *arg8 = (void *) 0 ;
        apr_pool_t *arg9 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg9 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 8) || (items > 9)) {
            SWIG_croak("Usage: svn_repos_dump_fs(repos,dumpstream,feedback_stream,start_rev,end_rev,incremental,cancel_func,cancel_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_dump_fs. Expected _p_svn_repos_t");
            }
        }
        {
            svn_swig_pl_make_stream (&arg2, ST(1));
        }
        {
            svn_swig_pl_make_stream (&arg3, ST(2));
        }
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (svn_revnum_t) SvIV(ST(4));
        arg6 = (svn_boolean_t) SvIV(ST(5));
        {
            if (SWIG_ConvertPtr(ST(6), (void **) &arg7, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 7 of svn_repos_dump_fs. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(7), (void **) &arg8, 0,0) < 0) {
                SWIG_croak("Type error in argument 8 of svn_repos_dump_fs. Expected _p_void");
            }
        }
        if (items > 8) {
            
        }
        {
            result = (svn_error_t *)svn_repos_dump_fs(arg1,arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_load_fs2) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        svn_stream_t *arg2 = (svn_stream_t *) 0 ;
        svn_stream_t *arg3 = (svn_stream_t *) 0 ;
        enum svn_repos_load_uuid arg4 ;
        char *arg5 = (char *) 0 ;
        svn_boolean_t arg6 ;
        svn_boolean_t arg7 ;
        svn_cancel_func_t arg8 = (svn_cancel_func_t) 0 ;
        void *arg9 = (void *) 0 ;
        apr_pool_t *arg10 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg10 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 9) || (items > 10)) {
            SWIG_croak("Usage: svn_repos_load_fs2(repos,dumpstream,feedback_stream,uuid_action,parent_dir,use_pre_commit_hook,use_post_commit_hook,cancel_func,cancel_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_load_fs2. Expected _p_svn_repos_t");
            }
        }
        {
            svn_swig_pl_make_stream (&arg2, ST(1));
        }
        {
            svn_swig_pl_make_stream (&arg3, ST(2));
        }
        arg4 = (enum svn_repos_load_uuid) SvIV(ST(3));
        if (!SvOK((SV*) ST(4))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(4), PL_na);
        arg6 = (svn_boolean_t) SvIV(ST(5));
        arg7 = (svn_boolean_t) SvIV(ST(6));
        {
            if (SWIG_ConvertPtr(ST(7), (void **) &arg8, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 8 of svn_repos_load_fs2. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(8), (void **) &arg9, 0,0) < 0) {
                SWIG_croak("Type error in argument 9 of svn_repos_load_fs2. Expected _p_void");
            }
        }
        if (items > 9) {
            
        }
        {
            result = (svn_error_t *)svn_repos_load_fs2(arg1,arg2,arg3,arg4,(char const *)arg5,arg6,arg7,arg8,arg9,arg10);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_load_fs) {
    {
        svn_repos_t *arg1 = (svn_repos_t *) 0 ;
        svn_stream_t *arg2 = (svn_stream_t *) 0 ;
        svn_stream_t *arg3 = (svn_stream_t *) 0 ;
        enum svn_repos_load_uuid arg4 ;
        char *arg5 = (char *) 0 ;
        svn_cancel_func_t arg6 = (svn_cancel_func_t) 0 ;
        void *arg7 = (void *) 0 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 7) || (items > 8)) {
            SWIG_croak("Usage: svn_repos_load_fs(repos,dumpstream,feedback_stream,uuid_action,parent_dir,cancel_func,cancel_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_load_fs. Expected _p_svn_repos_t");
            }
        }
        {
            svn_swig_pl_make_stream (&arg2, ST(1));
        }
        {
            svn_swig_pl_make_stream (&arg3, ST(2));
        }
        arg4 = (enum svn_repos_load_uuid) SvIV(ST(3));
        if (!SvOK((SV*) ST(4))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(4), PL_na);
        {
            if (SWIG_ConvertPtr(ST(5), (void **) &arg6, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 6 of svn_repos_load_fs. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(6), (void **) &arg7, 0,0) < 0) {
                SWIG_croak("Type error in argument 7 of svn_repos_load_fs. Expected _p_void");
            }
        }
        if (items > 7) {
            
        }
        {
            result = (svn_error_t *)svn_repos_load_fs(arg1,arg2,arg3,arg4,(char const *)arg5,arg6,arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_new_revision_record_set) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*arg2)(void **,apr_hash_t *,void *,apr_pool_t *) = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_new_revision_record_set(self,new_revision_record);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_new_revision_record_set. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_t_new_revision_record_set. Expected _p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->new_revision_record = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_new_revision_record_get) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*result)(void **,apr_hash_t *,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_new_revision_record_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_new_revision_record_get. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        result = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) ((arg1)->new_revision_record);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_uuid_record_set) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*arg2)(char const *,void *,apr_pool_t *) = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_uuid_record_set(self,uuid_record);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_uuid_record_set. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_t_uuid_record_set. Expected _p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->uuid_record = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_uuid_record_get) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*result)(char const *,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_uuid_record_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_uuid_record_get. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        result = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) ((arg1)->uuid_record);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_new_node_record_set) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*arg2)(void **,apr_hash_t *,void *,apr_pool_t *) = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_new_node_record_set(self,new_node_record);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_new_node_record_set. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_t_new_node_record_set. Expected _p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->new_node_record = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_new_node_record_get) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*result)(void **,apr_hash_t *,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_new_node_record_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_new_node_record_get. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        result = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) ((arg1)->new_node_record);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_set_revision_property_set) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,svn_string_t const *) = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_set_revision_property_set(self,set_revision_property);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_set_revision_property_set. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_t_set_revision_property_set. Expected _p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->set_revision_property = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_set_revision_property_get) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,svn_string_t const *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_set_revision_property_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_set_revision_property_get. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) ((arg1)->set_revision_property);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_set_node_property_set) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,svn_string_t const *) = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_set_node_property_set(self,set_node_property);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_set_node_property_set. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_t_set_node_property_set. Expected _p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->set_node_property = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_set_node_property_get) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,svn_string_t const *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_set_node_property_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_set_node_property_get. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) ((arg1)->set_node_property);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_delete_node_property_set) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *) = (svn_error_t *(*)(void *,char const *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_delete_node_property_set(self,delete_node_property);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_delete_node_property_set. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_t_delete_node_property_set. Expected _p_f_p_void_p_q_const__char__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->delete_node_property = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_delete_node_property_get) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*result)(void *,char const *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_delete_node_property_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_delete_node_property_get. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *)) ((arg1)->delete_node_property);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_remove_node_props_set) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_remove_node_props_set(self,remove_node_props);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_remove_node_props_set. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_t_remove_node_props_set. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->remove_node_props = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_remove_node_props_get) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*result)(void *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_remove_node_props_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_remove_node_props_get. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        result = (svn_error_t *(*)(void *)) ((arg1)->remove_node_props);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_set_fulltext_set) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*arg2)(svn_stream_t **,void *) = (svn_error_t *(*)(svn_stream_t **,void *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_set_fulltext_set(self,set_fulltext);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_set_fulltext_set. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_p_svn_stream_t_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_t_set_fulltext_set. Expected _p_f_p_p_svn_stream_t_p_void__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->set_fulltext = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_set_fulltext_get) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*result)(svn_stream_t **,void *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_set_fulltext_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_set_fulltext_get. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        result = (svn_error_t *(*)(svn_stream_t **,void *)) ((arg1)->set_fulltext);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_p_svn_stream_t_p_void__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_apply_textdelta_set) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*arg2)(svn_txdelta_window_handler_t *,void **,void *) = (svn_error_t *(*)(svn_txdelta_window_handler_t *,void **,void *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_apply_textdelta_set(self,apply_textdelta);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_apply_textdelta_set. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_t_apply_textdelta_set. Expected _p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->apply_textdelta = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_apply_textdelta_get) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*result)(svn_txdelta_window_handler_t *,void **,void *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_apply_textdelta_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_apply_textdelta_get. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        result = (svn_error_t *(*)(svn_txdelta_window_handler_t *,void **,void *)) ((arg1)->apply_textdelta);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_close_node_set) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_close_node_set(self,close_node);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_close_node_set. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_t_close_node_set. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->close_node = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_close_node_get) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*result)(void *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_close_node_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_close_node_get. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        result = (svn_error_t *(*)(void *)) ((arg1)->close_node);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_close_revision_set) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_close_revision_set(self,close_revision);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_close_revision_set. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_t_close_revision_set. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->close_revision = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_t_close_revision_get) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_error_t *(*result)(void *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_t_close_revision_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_t_close_revision_get. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        result = (svn_error_t *(*)(void *)) ((arg1)->close_revision);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_dumpstream2) {
    {
        svn_stream_t *arg1 = (svn_stream_t *) 0 ;
        svn_repos_parse_fns2_t *arg2 = (svn_repos_parse_fns2_t *) 0 ;
        void *arg3 = (void *) 0 ;
        svn_cancel_func_t arg4 = (svn_cancel_func_t) 0 ;
        void *arg5 = (void *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_repos_parse_dumpstream2(stream,parse_fns,parse_baton,cancel_func,cancel_baton,pool);");
        }
        {
            svn_swig_pl_make_stream (&arg1, ST(0));
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_dumpstream2. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg3, 0,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_parse_dumpstream2. Expected _p_void");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(3), (void **) &arg4, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_parse_dumpstream2. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(4), (void **) &arg5, 0,0) < 0) {
                SWIG_croak("Type error in argument 5 of svn_repos_parse_dumpstream2. Expected _p_void");
            }
        }
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_repos_parse_dumpstream2(arg1,(struct svn_repos_parse_fns2_t const *)arg2,arg3,arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_get_fs_build_parser2) {
    {
        svn_repos_parse_fns2_t **arg1 = (svn_repos_parse_fns2_t **) 0 ;
        void **arg2 = (void **) 0 ;
        svn_repos_t *arg3 = (svn_repos_t *) 0 ;
        svn_boolean_t arg4 ;
        enum svn_repos_load_uuid arg5 ;
        svn_stream_t *arg6 = (svn_stream_t *) 0 ;
        char *arg7 = (char *) 0 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        void *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (void **)&temp2;
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_repos_get_fs_build_parser2(parser,repos,use_history,uuid_action,outstream,parent_dir,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_get_fs_build_parser2. Expected _p_p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg3, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_get_fs_build_parser2. Expected _p_svn_repos_t");
            }
        }
        arg4 = (svn_boolean_t) SvIV(ST(2));
        arg5 = (enum svn_repos_load_uuid) SvIV(ST(3));
        {
            svn_swig_pl_make_stream (&arg6, ST(4));
        }
        if (!SvOK((SV*) ST(5))) arg7 = 0;
        else arg7 = (char *) SvPV(ST(5), PL_na);
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_repos_get_fs_build_parser2((struct svn_repos_parse_fns2_t const **)arg1,arg2,arg3,arg4,arg5,arg6,(char const *)arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_new_revision_record_set) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*arg2)(void **,apr_hash_t *,void *,apr_pool_t *) = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_new_revision_record_set(self,new_revision_record);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_new_revision_record_set. Expected _p_svn_repos_parse_fns_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parser_fns_t_new_revision_record_set. Expected _p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->new_revision_record = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_new_revision_record_get) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*result)(void **,apr_hash_t *,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_new_revision_record_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_new_revision_record_get. Expected _p_svn_repos_parse_fns_t");
            }
        }
        result = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) ((arg1)->new_revision_record);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_uuid_record_set) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*arg2)(char const *,void *,apr_pool_t *) = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_uuid_record_set(self,uuid_record);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_uuid_record_set. Expected _p_svn_repos_parse_fns_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parser_fns_t_uuid_record_set. Expected _p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->uuid_record = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_uuid_record_get) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*result)(char const *,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_uuid_record_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_uuid_record_get. Expected _p_svn_repos_parse_fns_t");
            }
        }
        result = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) ((arg1)->uuid_record);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_new_node_record_set) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*arg2)(void **,apr_hash_t *,void *,apr_pool_t *) = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_new_node_record_set(self,new_node_record);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_new_node_record_set. Expected _p_svn_repos_parse_fns_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parser_fns_t_new_node_record_set. Expected _p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->new_node_record = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_new_node_record_get) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*result)(void **,apr_hash_t *,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_new_node_record_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_new_node_record_get. Expected _p_svn_repos_parse_fns_t");
            }
        }
        result = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) ((arg1)->new_node_record);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_set_revision_property_set) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,svn_string_t const *) = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_set_revision_property_set(self,set_revision_property);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_set_revision_property_set. Expected _p_svn_repos_parse_fns_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parser_fns_t_set_revision_property_set. Expected _p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->set_revision_property = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_set_revision_property_get) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,svn_string_t const *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_set_revision_property_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_set_revision_property_get. Expected _p_svn_repos_parse_fns_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) ((arg1)->set_revision_property);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_set_node_property_set) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,svn_string_t const *) = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_set_node_property_set(self,set_node_property);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_set_node_property_set. Expected _p_svn_repos_parse_fns_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parser_fns_t_set_node_property_set. Expected _p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->set_node_property = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_set_node_property_get) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,svn_string_t const *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_set_node_property_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_set_node_property_get. Expected _p_svn_repos_parse_fns_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) ((arg1)->set_node_property);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_remove_node_props_set) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_remove_node_props_set(self,remove_node_props);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_remove_node_props_set. Expected _p_svn_repos_parse_fns_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parser_fns_t_remove_node_props_set. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->remove_node_props = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_remove_node_props_get) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*result)(void *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_remove_node_props_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_remove_node_props_get. Expected _p_svn_repos_parse_fns_t");
            }
        }
        result = (svn_error_t *(*)(void *)) ((arg1)->remove_node_props);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_set_fulltext_set) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*arg2)(svn_stream_t **,void *) = (svn_error_t *(*)(svn_stream_t **,void *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_set_fulltext_set(self,set_fulltext);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_set_fulltext_set. Expected _p_svn_repos_parse_fns_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_p_svn_stream_t_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parser_fns_t_set_fulltext_set. Expected _p_f_p_p_svn_stream_t_p_void__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->set_fulltext = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_set_fulltext_get) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*result)(svn_stream_t **,void *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_set_fulltext_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_set_fulltext_get. Expected _p_svn_repos_parse_fns_t");
            }
        }
        result = (svn_error_t *(*)(svn_stream_t **,void *)) ((arg1)->set_fulltext);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_p_svn_stream_t_p_void__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_close_node_set) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_close_node_set(self,close_node);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_close_node_set. Expected _p_svn_repos_parse_fns_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parser_fns_t_close_node_set. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->close_node = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_close_node_get) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*result)(void *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_close_node_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_close_node_get. Expected _p_svn_repos_parse_fns_t");
            }
        }
        result = (svn_error_t *(*)(void *)) ((arg1)->close_node);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_close_revision_set) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_close_revision_set(self,close_revision);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_close_revision_set. Expected _p_svn_repos_parse_fns_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parser_fns_t_close_revision_set. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->close_revision = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parser_fns_t_close_revision_get) {
    {
        svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
        svn_error_t *(*result)(void *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_repos_parser_fns_t_close_revision_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parser_fns_t_close_revision_get. Expected _p_svn_repos_parse_fns_t");
            }
        }
        result = (svn_error_t *(*)(void *)) ((arg1)->close_revision);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_dumpstream) {
    {
        svn_stream_t *arg1 = (svn_stream_t *) 0 ;
        svn_repos_parser_fns_t *arg2 = (svn_repos_parser_fns_t *) 0 ;
        void *arg3 = (void *) 0 ;
        svn_cancel_func_t arg4 = (svn_cancel_func_t) 0 ;
        void *arg5 = (void *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_repos_parse_dumpstream(stream,parse_fns,parse_baton,cancel_func,cancel_baton,pool);");
        }
        {
            svn_swig_pl_make_stream (&arg1, ST(0));
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_dumpstream. Expected _p_svn_repos_parse_fns_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg3, 0,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_parse_dumpstream. Expected _p_void");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(3), (void **) &arg4, SWIGTYPE_p_f_p_void__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_parse_dumpstream. Expected _p_f_p_void__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(4), (void **) &arg5, 0,0) < 0) {
                SWIG_croak("Type error in argument 5 of svn_repos_parse_dumpstream. Expected _p_void");
            }
        }
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_repos_parse_dumpstream(arg1,(struct svn_repos_parse_fns_t const *)arg2,arg3,arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_get_fs_build_parser) {
    {
        svn_repos_parser_fns_t **arg1 = (svn_repos_parser_fns_t **) 0 ;
        void **arg2 = (void **) 0 ;
        svn_repos_t *arg3 = (svn_repos_t *) 0 ;
        svn_boolean_t arg4 ;
        enum svn_repos_load_uuid arg5 ;
        svn_stream_t *arg6 = (svn_stream_t *) 0 ;
        char *arg7 = (char *) 0 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        void *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (void **)&temp2;
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_repos_get_fs_build_parser(parser,repos,use_history,uuid_action,outstream,parent_dir,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_p_svn_repos_parse_fns_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_get_fs_build_parser. Expected _p_p_svn_repos_parse_fns_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg3, SWIGTYPE_p_svn_repos_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_get_fs_build_parser. Expected _p_svn_repos_t");
            }
        }
        arg4 = (svn_boolean_t) SvIV(ST(2));
        arg5 = (enum svn_repos_load_uuid) SvIV(ST(3));
        {
            svn_swig_pl_make_stream (&arg6, ST(4));
        }
        if (!SvOK((SV*) ST(5))) arg7 = 0;
        else arg7 = (char *) SvPV(ST(5), PL_na);
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_repos_get_fs_build_parser((struct svn_repos_parse_fns_t const **)arg1,arg2,arg3,arg4,arg5,arg6,(char const *)arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_authz_read) {
    {
        svn_authz_t **arg1 = (svn_authz_t **) 0 ;
        char *arg2 = (char *) 0 ;
        svn_boolean_t arg3 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_authz_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_authz_t **)&temp1;
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_repos_authz_read(file,must_exist,pool);");
        }
        if (!SvOK((SV*) ST(0))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(0), PL_na);
        arg3 = (svn_boolean_t) SvIV(ST(1));
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_repos_authz_read(arg1,(char const *)arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_authz_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_authz_check_access) {
    {
        svn_authz_t *arg1 = (svn_authz_t *) 0 ;
        char *arg2 = (char *) 0 ;
        char *arg3 = (char *) 0 ;
        char *arg4 = (char *) 0 ;
        svn_repos_authz_access_t arg5 ;
        svn_boolean_t *arg6 = (svn_boolean_t *) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int temp6 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg6 = &temp6;
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_repos_authz_check_access(authz,repos_name,path,user,required_access,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_authz_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_authz_check_access. Expected _p_svn_authz_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        if (!SvOK((SV*) ST(3))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(3), PL_na);
        arg5 = (svn_repos_authz_access_t) SvIV(ST(4));
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_repos_authz_check_access(arg1,(char const *)arg2,(char const *)arg3,(char const *)arg4,arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg6));
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_invoke_new_revision_record) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        void **arg2 = (void **) 0 ;
        apr_hash_t *arg3 = (apr_hash_t *) 0 ;
        void *arg4 = (void *) 0 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        void *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (void **)&temp2;
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_invoke_new_revision_record(_obj,headers,parse_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_invoke_new_revision_record. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg3, SWIGTYPE_p_apr_hash_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_parse_fns2_invoke_new_revision_record. Expected _p_apr_hash_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg4, 0,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_parse_fns2_invoke_new_revision_record. Expected _p_void");
            }
        }
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_repos_parse_fns2_invoke_new_revision_record(arg1,arg2,arg3,arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_invoke_uuid_record) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        char *arg2 = (char *) 0 ;
        void *arg3 = (void *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_invoke_uuid_record(_obj,uuid,parse_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_invoke_uuid_record. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg3, 0,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_parse_fns2_invoke_uuid_record. Expected _p_void");
            }
        }
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_repos_parse_fns2_invoke_uuid_record(arg1,(char const *)arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_invoke_new_node_record) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        void **arg2 = (void **) 0 ;
        apr_hash_t *arg3 = (apr_hash_t *) 0 ;
        void *arg4 = (void *) 0 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        void *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (void **)&temp2;
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_invoke_new_node_record(_obj,headers,revision_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_invoke_new_node_record. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg3, SWIGTYPE_p_apr_hash_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_parse_fns2_invoke_new_node_record. Expected _p_apr_hash_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg4, 0,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_parse_fns2_invoke_new_node_record. Expected _p_void");
            }
        }
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_repos_parse_fns2_invoke_new_node_record(arg1,arg2,arg3,arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_invoke_set_revision_property) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_string_t *arg4 = (svn_string_t *) 0 ;
        svn_error_t *result;
        svn_string_t value4 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 4) || (items > 4)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_invoke_set_revision_property(_obj,revision_baton,name,value);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_invoke_set_revision_property. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_invoke_set_revision_property. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        {
            if (SvOK(ST(3))) {
                value4.data = SvPV(ST(3), value4.len);
                arg4 = &value4;
            }
            else {
                arg4 = NULL;
            }
        }
        {
            result = (svn_error_t *)svn_repos_parse_fns2_invoke_set_revision_property(arg1,arg2,(char const *)arg3,(struct svn_string_t const *)arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_invoke_set_node_property) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_string_t *arg4 = (svn_string_t *) 0 ;
        svn_error_t *result;
        svn_string_t value4 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 4) || (items > 4)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_invoke_set_node_property(_obj,node_baton,name,value);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_invoke_set_node_property. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_invoke_set_node_property. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        {
            if (SvOK(ST(3))) {
                value4.data = SvPV(ST(3), value4.len);
                arg4 = &value4;
            }
            else {
                arg4 = NULL;
            }
        }
        {
            result = (svn_error_t *)svn_repos_parse_fns2_invoke_set_node_property(arg1,arg2,(char const *)arg3,(struct svn_string_t const *)arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_invoke_delete_node_property) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_error_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 3) || (items > 3)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_invoke_delete_node_property(_obj,node_baton,name);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_invoke_delete_node_property. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_invoke_delete_node_property. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        {
            result = (svn_error_t *)svn_repos_parse_fns2_invoke_delete_node_property(arg1,arg2,(char const *)arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_invoke_remove_node_props) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_error_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_invoke_remove_node_props(_obj,node_baton);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_invoke_remove_node_props. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_invoke_remove_node_props. Expected _p_void");
            }
        }
        {
            result = (svn_error_t *)svn_repos_parse_fns2_invoke_remove_node_props(arg1,arg2);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_invoke_set_fulltext) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_stream_t **arg2 = (svn_stream_t **) 0 ;
        void *arg3 = (void *) 0 ;
        svn_error_t *result;
        svn_stream_t *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            arg2 = (svn_stream_t **)&temp2;
        }
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_invoke_set_fulltext(_obj,node_baton);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_invoke_set_fulltext. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg3, 0,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_repos_parse_fns2_invoke_set_fulltext. Expected _p_void");
            }
        }
        {
            result = (svn_error_t *)svn_repos_parse_fns2_invoke_set_fulltext(arg1,arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = svn_swig_pl_from_stream (*arg2);
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_invoke_apply_textdelta) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        svn_txdelta_window_handler_t *arg2 = (svn_txdelta_window_handler_t *) 0 ;
        void **arg3 = (void **) 0 ;
        void *arg4 = (void *) 0 ;
        svn_error_t *result;
        svn_txdelta_window_handler_t temp2 ;
        void *temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            arg2 = (svn_txdelta_window_handler_t *)&temp2;
        }
        {
            arg3 = (void **)&temp3;
        }
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_invoke_apply_textdelta(_obj,node_baton);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_invoke_apply_textdelta. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg4, 0,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_repos_parse_fns2_invoke_apply_textdelta. Expected _p_void");
            }
        }
        {
            result = (svn_error_t *)svn_repos_parse_fns2_invoke_apply_textdelta(arg1,arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg3, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_invoke_close_node) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_error_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_invoke_close_node(_obj,node_baton);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_invoke_close_node. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_invoke_close_node. Expected _p_void");
            }
        }
        {
            result = (svn_error_t *)svn_repos_parse_fns2_invoke_close_node(arg1,arg2);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_repos_parse_fns2_invoke_close_revision) {
    {
        svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_error_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_repos_parse_fns2_invoke_close_revision(_obj,revision_baton);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_repos_parse_fns2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_repos_parse_fns2_invoke_close_revision. Expected _p_svn_repos_parse_fns2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_repos_parse_fns2_invoke_close_revision. Expected _p_void");
            }
        }
        {
            result = (svn_error_t *)svn_repos_parse_fns2_invoke_close_revision(arg1,arg2);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}



/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (BEGIN) -------- */

static swig_type_info _swigt__p_apr_array_header_t = {"_p_apr_array_header_t", "apr_array_header_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_hash_t = {"_p_apr_hash_t", "apr_hash_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int32_t = {"_p_apr_int32_t", "apr_int32_t *|time_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int64_t = {"_p_apr_int64_t", "apr_int64_t *|svn_filesize_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_pool_t = {"_p_apr_pool_t", "apr_pool_t *", 0, 0, 0};
static swig_type_info _swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(apr_getopt_t *,void *,apr_pool_t *)|svn_opt_subcommand_t *", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_svn_stream_t_p_void__p_svn_error_t = {"_p_f_p_p_svn_stream_t_p_void__p_svn_error_t", "struct svn_error_t *(*)(svn_stream_t **,void *)|svn_error_t *(*)(svn_stream_t **,void *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)|svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(char const *,void *,apr_pool_t *)|svn_error_t *(*)(char const *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_commit_info_t const *,void *,apr_pool_t *)|svn_commit_callback2_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_boolean_t *,svn_fs_root_t *,char const *,void *,apr_pool_t *)|svn_repos_authz_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t = {"_p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t", "struct svn_error_t *(*)(svn_txdelta_window_handler_t *,void **,void *)|svn_error_t *(*)(svn_txdelta_window_handler_t *,void **,void *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t = {"_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t", "struct svn_error_t *(*)(svn_txdelta_window_t *,void *)|svn_txdelta_window_handler_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void__p_svn_error_t = {"_p_f_p_void__p_svn_error_t", "struct svn_error_t *(*)(void *)|svn_cancel_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_hash_t *,svn_revnum_t,char const *,char const *,char const *,apr_pool_t *)|svn_log_message_receiver_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char__p_svn_error_t = {"_p_f_p_void_p_q_const__char__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *)|svn_error_t *(*)(void *,char const *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_string_t const *)|svn_error_t *(*)(void *,char const *,svn_string_t const *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t *,svn_txdelta_window_handler_t *,void **,apr_array_header_t *,apr_pool_t *)|svn_repos_file_rev_handler_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_pool_t *)|svn_repos_history_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_repos_authz_access_t,svn_boolean_t *,svn_fs_root_t *,char const *,void *,apr_pool_t *)|svn_repos_authz_callback_t", 0, 0, 0};
static swig_type_info _swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t = {"_p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t", "struct svn_error_t *(*)(svn_revnum_t,char const *,char const *,void *)|svn_commit_callback_t", 0, 0, 0};
static swig_type_info _swigt__p_int = {"_p_int", "int *|svn_boolean_t *", 0, 0, 0};
static swig_type_info _swigt__p_long = {"_p_long", "long *|svn_revnum_t *", 0, 0, 0};
static swig_type_info _swigt__p_p_apr_array_header_t = {"_p_p_apr_array_header_t", "apr_array_header_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_apr_hash_t = {"_p_p_apr_hash_t", "apr_hash_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_char = {"_p_p_char", "char **", 0, 0, 0};
static swig_type_info _swigt__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t = {"_p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t", "struct svn_error_t *(**)(svn_txdelta_window_t *,void *)|svn_txdelta_window_handler_t *", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_authz_t = {"_p_p_svn_authz_t", "struct svn_authz_t **|svn_authz_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_delta_editor_t = {"_p_p_svn_delta_editor_t", "struct svn_delta_editor_t **|svn_delta_editor_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_dirent_t = {"_p_p_svn_dirent_t", "struct svn_dirent_t **|svn_dirent_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_fs_txn_t = {"_p_p_svn_fs_txn_t", "struct svn_fs_txn_t **|svn_fs_txn_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_lock_t = {"_p_p_svn_lock_t", "struct svn_lock_t **|svn_lock_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_repos_parse_fns2_t = {"_p_p_svn_repos_parse_fns2_t", "struct svn_repos_parse_fns2_t **|svn_repos_parse_fns2_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_repos_parse_fns_t = {"_p_p_svn_repos_parse_fns_t", "struct svn_repos_parse_fns_t **|svn_repos_parser_fns_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_repos_t = {"_p_p_svn_repos_t", "struct svn_repos_t **|svn_repos_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_stream_t = {"_p_p_svn_stream_t", "struct svn_stream_t **|svn_stream_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_string_t = {"_p_p_svn_string_t", "struct svn_string_t **|svn_string_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_void = {"_p_p_void", "void **", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_baton_t = {"_p_svn_auth_baton_t", "struct svn_auth_baton_t *|svn_auth_baton_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_simple_t = {"_p_svn_auth_cred_simple_t", "struct svn_auth_cred_simple_t *|svn_auth_cred_simple_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_pw_t = {"_p_svn_auth_cred_ssl_client_cert_pw_t", "struct svn_auth_cred_ssl_client_cert_pw_t *|svn_auth_cred_ssl_client_cert_pw_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_t = {"_p_svn_auth_cred_ssl_client_cert_t", "struct svn_auth_cred_ssl_client_cert_t *|svn_auth_cred_ssl_client_cert_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_server_trust_t = {"_p_svn_auth_cred_ssl_server_trust_t", "struct svn_auth_cred_ssl_server_trust_t *|svn_auth_cred_ssl_server_trust_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_username_t = {"_p_svn_auth_cred_username_t", "struct svn_auth_cred_username_t *|svn_auth_cred_username_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_iterstate_t = {"_p_svn_auth_iterstate_t", "struct svn_auth_iterstate_t *|svn_auth_iterstate_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_object_t = {"_p_svn_auth_provider_object_t", "struct svn_auth_provider_object_t *|svn_auth_provider_object_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_t = {"_p_svn_auth_provider_t", "struct svn_auth_provider_t *|svn_auth_provider_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_ssl_server_cert_info_t = {"_p_svn_auth_ssl_server_cert_info_t", "struct svn_auth_ssl_server_cert_info_t *|svn_auth_ssl_server_cert_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_authz_t = {"_p_svn_authz_t", "struct svn_authz_t *|svn_authz_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_commit_info_t = {"_p_svn_commit_info_t", "struct svn_commit_info_t *|svn_commit_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_config_t = {"_p_svn_config_t", "struct svn_config_t *|svn_config_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_delta_editor_t = {"_p_svn_delta_editor_t", "struct svn_delta_editor_t *|svn_delta_editor_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_datasource_e = {"_p_svn_diff_datasource_e", "enum svn_diff_datasource_e *|svn_diff_datasource_e *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_file_ignore_space_t = {"_p_svn_diff_file_ignore_space_t", "enum svn_diff_file_ignore_space_t *|svn_diff_file_ignore_space_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_file_options_t = {"_p_svn_diff_file_options_t", "struct svn_diff_file_options_t *|svn_diff_file_options_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_fns_t = {"_p_svn_diff_fns_t", "struct svn_diff_fns_t *|svn_diff_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_output_fns_t = {"_p_svn_diff_output_fns_t", "struct svn_diff_output_fns_t *|svn_diff_output_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_t = {"_p_svn_diff_t", "struct svn_diff_t *|svn_diff_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_dirent_t = {"_p_svn_dirent_t", "struct svn_dirent_t *|svn_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_errno_t = {"_p_svn_errno_t", "enum svn_errno_t *|svn_errno_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_error_t = {"_p_svn_error_t", "struct svn_error_t *|svn_error_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_access_t = {"_p_svn_fs_access_t", "struct svn_fs_access_t *|svn_fs_access_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_dirent_t = {"_p_svn_fs_dirent_t", "struct svn_fs_dirent_t *|svn_fs_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_history_t = {"_p_svn_fs_history_t", "struct svn_fs_history_t *|svn_fs_history_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_id_t = {"_p_svn_fs_id_t", "struct svn_fs_id_t *|svn_fs_id_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_path_change_kind_t = {"_p_svn_fs_path_change_kind_t", "enum svn_fs_path_change_kind_t *|svn_fs_path_change_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_path_change_t = {"_p_svn_fs_path_change_t", "struct svn_fs_path_change_t *|svn_fs_path_change_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_root_t = {"_p_svn_fs_root_t", "struct svn_fs_root_t *|svn_fs_root_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_t = {"_p_svn_fs_t", "struct svn_fs_t *|svn_fs_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_txn_t = {"_p_svn_fs_txn_t", "struct svn_fs_txn_t *|svn_fs_txn_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_dirent_t = {"_p_svn_io_dirent_t", "struct svn_io_dirent_t *|svn_io_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_file_del_t = {"_p_svn_io_file_del_t", "enum svn_io_file_del_t *|svn_io_file_del_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_lock_t = {"_p_svn_lock_t", "struct svn_lock_t *|svn_lock_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_log_changed_path_t = {"_p_svn_log_changed_path_t", "struct svn_log_changed_path_t *|svn_log_changed_path_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_node_kind_t = {"_p_svn_node_kind_t", "enum svn_node_kind_t *|svn_node_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_t = {"_p_svn_opt_revision_t", "struct svn_opt_revision_t *|svn_opt_revision_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_value_t = {"_p_svn_opt_revision_value_t", "union svn_opt_revision_value_t *|svn_opt_revision_value_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc2_t = {"_p_svn_opt_subcommand_desc2_t", "struct svn_opt_subcommand_desc2_t *|svn_opt_subcommand_desc2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc_t = {"_p_svn_opt_subcommand_desc_t", "struct svn_opt_subcommand_desc_t *|svn_opt_subcommand_desc_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_prop_kind = {"_p_svn_prop_kind", "enum svn_prop_kind *|svn_prop_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_repos_authz_access_t = {"_p_svn_repos_authz_access_t", "enum svn_repos_authz_access_t *|svn_repos_authz_access_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_repos_node_t = {"_p_svn_repos_node_t", "struct svn_repos_node_t *|svn_repos_node_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_repos_parse_fns2_t = {"_p_svn_repos_parse_fns2_t", "struct svn_repos_parse_fns2_t *|svn_repos_parse_fns2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_repos_parse_fns_t = {"_p_svn_repos_parse_fns_t", "struct svn_repos_parse_fns_t *|svn_repos_parser_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_repos_t = {"_p_svn_repos_t", "struct svn_repos_t *|svn_repos_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stream_t = {"_p_svn_stream_t", "struct svn_stream_t *|svn_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_string_t = {"_p_svn_string_t", "struct svn_string_t *|svn_string_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stringbuf_t = {"_p_svn_stringbuf_t", "struct svn_stringbuf_t *|svn_stringbuf_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_op_t = {"_p_svn_txdelta_op_t", "struct svn_txdelta_op_t *|svn_txdelta_op_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_stream_t = {"_p_svn_txdelta_stream_t", "struct svn_txdelta_stream_t *|svn_txdelta_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_window_t = {"_p_svn_txdelta_window_t", "struct svn_txdelta_window_t *|svn_txdelta_window_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_checklist_t = {"_p_svn_version_checklist_t", "struct svn_version_checklist_t *|svn_version_checklist_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_t = {"_p_svn_version_t", "struct svn_version_t *|svn_version_t *", 0, 0, 0};
static swig_type_info _swigt__p_void = {"_p_void", "void *", 0, 0, 0};

static swig_type_info *swig_type_initial[] = {
  &_swigt__p_apr_array_header_t,
  &_swigt__p_apr_hash_t,
  &_swigt__p_apr_int32_t,
  &_swigt__p_apr_int64_t,
  &_swigt__p_apr_pool_t,
  &_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_svn_stream_t_p_void__p_svn_error_t,
  &_swigt__p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t,
  &_swigt__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  &_swigt__p_f_p_void__p_svn_error_t,
  &_swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t,
  &_swigt__p_int,
  &_swigt__p_long,
  &_swigt__p_p_apr_array_header_t,
  &_swigt__p_p_apr_hash_t,
  &_swigt__p_p_char,
  &_swigt__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  &_swigt__p_p_svn_authz_t,
  &_swigt__p_p_svn_delta_editor_t,
  &_swigt__p_p_svn_dirent_t,
  &_swigt__p_p_svn_fs_txn_t,
  &_swigt__p_p_svn_lock_t,
  &_swigt__p_p_svn_repos_parse_fns2_t,
  &_swigt__p_p_svn_repos_parse_fns_t,
  &_swigt__p_p_svn_repos_t,
  &_swigt__p_p_svn_stream_t,
  &_swigt__p_p_svn_string_t,
  &_swigt__p_p_void,
  &_swigt__p_svn_auth_baton_t,
  &_swigt__p_svn_auth_cred_simple_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_pw_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_t,
  &_swigt__p_svn_auth_cred_ssl_server_trust_t,
  &_swigt__p_svn_auth_cred_username_t,
  &_swigt__p_svn_auth_iterstate_t,
  &_swigt__p_svn_auth_provider_object_t,
  &_swigt__p_svn_auth_provider_t,
  &_swigt__p_svn_auth_ssl_server_cert_info_t,
  &_swigt__p_svn_authz_t,
  &_swigt__p_svn_commit_info_t,
  &_swigt__p_svn_config_t,
  &_swigt__p_svn_delta_editor_t,
  &_swigt__p_svn_diff_datasource_e,
  &_swigt__p_svn_diff_file_ignore_space_t,
  &_swigt__p_svn_diff_file_options_t,
  &_swigt__p_svn_diff_fns_t,
  &_swigt__p_svn_diff_output_fns_t,
  &_swigt__p_svn_diff_t,
  &_swigt__p_svn_dirent_t,
  &_swigt__p_svn_errno_t,
  &_swigt__p_svn_error_t,
  &_swigt__p_svn_fs_access_t,
  &_swigt__p_svn_fs_dirent_t,
  &_swigt__p_svn_fs_history_t,
  &_swigt__p_svn_fs_id_t,
  &_swigt__p_svn_fs_path_change_kind_t,
  &_swigt__p_svn_fs_path_change_t,
  &_swigt__p_svn_fs_root_t,
  &_swigt__p_svn_fs_t,
  &_swigt__p_svn_fs_txn_t,
  &_swigt__p_svn_io_dirent_t,
  &_swigt__p_svn_io_file_del_t,
  &_swigt__p_svn_lock_t,
  &_swigt__p_svn_log_changed_path_t,
  &_swigt__p_svn_node_kind_t,
  &_swigt__p_svn_opt_revision_t,
  &_swigt__p_svn_opt_revision_value_t,
  &_swigt__p_svn_opt_subcommand_desc2_t,
  &_swigt__p_svn_opt_subcommand_desc_t,
  &_swigt__p_svn_prop_kind,
  &_swigt__p_svn_repos_authz_access_t,
  &_swigt__p_svn_repos_node_t,
  &_swigt__p_svn_repos_parse_fns2_t,
  &_swigt__p_svn_repos_parse_fns_t,
  &_swigt__p_svn_repos_t,
  &_swigt__p_svn_stream_t,
  &_swigt__p_svn_string_t,
  &_swigt__p_svn_stringbuf_t,
  &_swigt__p_svn_txdelta_op_t,
  &_swigt__p_svn_txdelta_stream_t,
  &_swigt__p_svn_txdelta_window_t,
  &_swigt__p_svn_version_checklist_t,
  &_swigt__p_svn_version_t,
  &_swigt__p_void,
};

static swig_cast_info _swigc__p_apr_array_header_t[] = {  {&_swigt__p_apr_array_header_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_hash_t[] = {  {&_swigt__p_apr_hash_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int32_t[] = {  {&_swigt__p_apr_int32_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int64_t[] = {  {&_swigt__p_apr_int64_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_pool_t[] = {  {&_swigt__p_apr_pool_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_svn_stream_t_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_p_svn_stream_t_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t[] = {  {&_swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_int[] = {  {&_swigt__p_int, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_long[] = {  {&_swigt__p_long, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_apr_array_header_t[] = {  {&_swigt__p_p_apr_array_header_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_apr_hash_t[] = {  {&_swigt__p_p_apr_hash_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_char[] = {  {&_swigt__p_p_char, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t[] = {  {&_swigt__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_authz_t[] = {  {&_swigt__p_p_svn_authz_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_delta_editor_t[] = {  {&_swigt__p_p_svn_delta_editor_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_dirent_t[] = {  {&_swigt__p_p_svn_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_fs_txn_t[] = {  {&_swigt__p_p_svn_fs_txn_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_lock_t[] = {  {&_swigt__p_p_svn_lock_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_repos_parse_fns2_t[] = {  {&_swigt__p_p_svn_repos_parse_fns2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_repos_parse_fns_t[] = {  {&_swigt__p_p_svn_repos_parse_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_repos_t[] = {  {&_swigt__p_p_svn_repos_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_stream_t[] = {  {&_swigt__p_p_svn_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_string_t[] = {  {&_swigt__p_p_svn_string_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_void[] = {  {&_swigt__p_p_void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_baton_t[] = {  {&_swigt__p_svn_auth_baton_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_simple_t[] = {  {&_swigt__p_svn_auth_cred_simple_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_pw_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_pw_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_server_trust_t[] = {  {&_swigt__p_svn_auth_cred_ssl_server_trust_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_username_t[] = {  {&_swigt__p_svn_auth_cred_username_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_iterstate_t[] = {  {&_swigt__p_svn_auth_iterstate_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_object_t[] = {  {&_swigt__p_svn_auth_provider_object_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_t[] = {  {&_swigt__p_svn_auth_provider_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_ssl_server_cert_info_t[] = {  {&_swigt__p_svn_auth_ssl_server_cert_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_authz_t[] = {  {&_swigt__p_svn_authz_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_commit_info_t[] = {  {&_swigt__p_svn_commit_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_config_t[] = {  {&_swigt__p_svn_config_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_delta_editor_t[] = {  {&_swigt__p_svn_delta_editor_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_datasource_e[] = {  {&_swigt__p_svn_diff_datasource_e, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_file_ignore_space_t[] = {  {&_swigt__p_svn_diff_file_ignore_space_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_file_options_t[] = {  {&_swigt__p_svn_diff_file_options_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_fns_t[] = {  {&_swigt__p_svn_diff_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_output_fns_t[] = {  {&_swigt__p_svn_diff_output_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_t[] = {  {&_swigt__p_svn_diff_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_dirent_t[] = {  {&_swigt__p_svn_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_errno_t[] = {  {&_swigt__p_svn_errno_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_error_t[] = {  {&_swigt__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_access_t[] = {  {&_swigt__p_svn_fs_access_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_dirent_t[] = {  {&_swigt__p_svn_fs_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_history_t[] = {  {&_swigt__p_svn_fs_history_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_id_t[] = {  {&_swigt__p_svn_fs_id_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_path_change_kind_t[] = {  {&_swigt__p_svn_fs_path_change_kind_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_path_change_t[] = {  {&_swigt__p_svn_fs_path_change_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_root_t[] = {  {&_swigt__p_svn_fs_root_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_t[] = {  {&_swigt__p_svn_fs_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_txn_t[] = {  {&_swigt__p_svn_fs_txn_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_dirent_t[] = {  {&_swigt__p_svn_io_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_file_del_t[] = {  {&_swigt__p_svn_io_file_del_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_lock_t[] = {  {&_swigt__p_svn_lock_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_log_changed_path_t[] = {  {&_swigt__p_svn_log_changed_path_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_node_kind_t[] = {  {&_swigt__p_svn_node_kind_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_t[] = {  {&_swigt__p_svn_opt_revision_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_value_t[] = {  {&_swigt__p_svn_opt_revision_value_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc2_t[] = {  {&_swigt__p_svn_opt_subcommand_desc2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc_t[] = {  {&_swigt__p_svn_opt_subcommand_desc_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_prop_kind[] = {  {&_swigt__p_svn_prop_kind, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_repos_authz_access_t[] = {  {&_swigt__p_svn_repos_authz_access_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_repos_node_t[] = {  {&_swigt__p_svn_repos_node_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_repos_parse_fns2_t[] = {  {&_swigt__p_svn_repos_parse_fns2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_repos_parse_fns_t[] = {  {&_swigt__p_svn_repos_parse_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_repos_t[] = {  {&_swigt__p_svn_repos_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stream_t[] = {  {&_swigt__p_svn_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_string_t[] = {  {&_swigt__p_svn_string_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stringbuf_t[] = {  {&_swigt__p_svn_stringbuf_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_op_t[] = {  {&_swigt__p_svn_txdelta_op_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_stream_t[] = {  {&_swigt__p_svn_txdelta_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_window_t[] = {  {&_swigt__p_svn_txdelta_window_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_checklist_t[] = {  {&_swigt__p_svn_version_checklist_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_t[] = {  {&_swigt__p_svn_version_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_void[] = {  {&_swigt__p_void, 0, 0, 0},{0, 0, 0, 0}};

static swig_cast_info *swig_cast_initial[] = {
  _swigc__p_apr_array_header_t,
  _swigc__p_apr_hash_t,
  _swigc__p_apr_int32_t,
  _swigc__p_apr_int64_t,
  _swigc__p_apr_pool_t,
  _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_svn_stream_t_p_void__p_svn_error_t,
  _swigc__p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t,
  _swigc__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  _swigc__p_f_p_void__p_svn_error_t,
  _swigc__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t,
  _swigc__p_int,
  _swigc__p_long,
  _swigc__p_p_apr_array_header_t,
  _swigc__p_p_apr_hash_t,
  _swigc__p_p_char,
  _swigc__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  _swigc__p_p_svn_authz_t,
  _swigc__p_p_svn_delta_editor_t,
  _swigc__p_p_svn_dirent_t,
  _swigc__p_p_svn_fs_txn_t,
  _swigc__p_p_svn_lock_t,
  _swigc__p_p_svn_repos_parse_fns2_t,
  _swigc__p_p_svn_repos_parse_fns_t,
  _swigc__p_p_svn_repos_t,
  _swigc__p_p_svn_stream_t,
  _swigc__p_p_svn_string_t,
  _swigc__p_p_void,
  _swigc__p_svn_auth_baton_t,
  _swigc__p_svn_auth_cred_simple_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_pw_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_t,
  _swigc__p_svn_auth_cred_ssl_server_trust_t,
  _swigc__p_svn_auth_cred_username_t,
  _swigc__p_svn_auth_iterstate_t,
  _swigc__p_svn_auth_provider_object_t,
  _swigc__p_svn_auth_provider_t,
  _swigc__p_svn_auth_ssl_server_cert_info_t,
  _swigc__p_svn_authz_t,
  _swigc__p_svn_commit_info_t,
  _swigc__p_svn_config_t,
  _swigc__p_svn_delta_editor_t,
  _swigc__p_svn_diff_datasource_e,
  _swigc__p_svn_diff_file_ignore_space_t,
  _swigc__p_svn_diff_file_options_t,
  _swigc__p_svn_diff_fns_t,
  _swigc__p_svn_diff_output_fns_t,
  _swigc__p_svn_diff_t,
  _swigc__p_svn_dirent_t,
  _swigc__p_svn_errno_t,
  _swigc__p_svn_error_t,
  _swigc__p_svn_fs_access_t,
  _swigc__p_svn_fs_dirent_t,
  _swigc__p_svn_fs_history_t,
  _swigc__p_svn_fs_id_t,
  _swigc__p_svn_fs_path_change_kind_t,
  _swigc__p_svn_fs_path_change_t,
  _swigc__p_svn_fs_root_t,
  _swigc__p_svn_fs_t,
  _swigc__p_svn_fs_txn_t,
  _swigc__p_svn_io_dirent_t,
  _swigc__p_svn_io_file_del_t,
  _swigc__p_svn_lock_t,
  _swigc__p_svn_log_changed_path_t,
  _swigc__p_svn_node_kind_t,
  _swigc__p_svn_opt_revision_t,
  _swigc__p_svn_opt_revision_value_t,
  _swigc__p_svn_opt_subcommand_desc2_t,
  _swigc__p_svn_opt_subcommand_desc_t,
  _swigc__p_svn_prop_kind,
  _swigc__p_svn_repos_authz_access_t,
  _swigc__p_svn_repos_node_t,
  _swigc__p_svn_repos_parse_fns2_t,
  _swigc__p_svn_repos_parse_fns_t,
  _swigc__p_svn_repos_t,
  _swigc__p_svn_stream_t,
  _swigc__p_svn_string_t,
  _swigc__p_svn_stringbuf_t,
  _swigc__p_svn_txdelta_op_t,
  _swigc__p_svn_txdelta_stream_t,
  _swigc__p_svn_txdelta_window_t,
  _swigc__p_svn_version_checklist_t,
  _swigc__p_svn_version_t,
  _swigc__p_void,
};


/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (END) -------- */

static swig_constant_info swig_constants[] = {
{ SWIG_INT,     (char *) SWIG_prefix "svn_authz_none", (long) svn_authz_none, 0, 0, 0},
{ SWIG_INT,     (char *) SWIG_prefix "svn_authz_read", (long) svn_authz_read, 0, 0, 0},
{ SWIG_INT,     (char *) SWIG_prefix "svn_authz_write", (long) svn_authz_write, 0, 0, 0},
{ SWIG_INT,     (char *) SWIG_prefix "svn_authz_recursive", (long) svn_authz_recursive, 0, 0, 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_MAGIC_HEADER", 0, 0, (void *)"SVN-fs-dump-format-version", 0},
{ SWIG_INT,     (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_FORMAT_VERSION", (long) 3, 0, 0, 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_UUID", 0, 0, (void *)"UUID", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_CONTENT_LENGTH", 0, 0, (void *)"Content-length", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_REVISION_NUMBER", 0, 0, (void *)"Revision-number", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_NODE_PATH", 0, 0, (void *)"Node-path", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_NODE_KIND", 0, 0, (void *)"Node-kind", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_NODE_ACTION", 0, 0, (void *)"Node-action", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_NODE_COPYFROM_PATH", 0, 0, (void *)"Node-copyfrom-path", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_NODE_COPYFROM_REV", 0, 0, (void *)"Node-copyfrom-rev", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_TEXT_COPY_SOURCE_CHECKSUM", 0, 0, (void *)"Text-copy-source-md5", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_TEXT_CONTENT_CHECKSUM", 0, 0, (void *)"Text-content-md5", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_PROP_CONTENT_LENGTH", 0, 0, (void *)"Prop-content-length", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_TEXT_CONTENT_LENGTH", 0, 0, (void *)"Text-content-length", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_PROP_DELTA", 0, 0, (void *)"Prop-delta", 0},
{ SWIG_STRING,  (char *) SWIG_prefix "SVN_REPOS_DUMPFILE_TEXT_DELTA", 0, 0, (void *)"Text-delta", 0},
{ SWIG_INT,     (char *) SWIG_prefix "svn_node_action_change", (long) svn_node_action_change, 0, 0, 0},
{ SWIG_INT,     (char *) SWIG_prefix "svn_node_action_add", (long) svn_node_action_add, 0, 0, 0},
{ SWIG_INT,     (char *) SWIG_prefix "svn_node_action_delete", (long) svn_node_action_delete, 0, 0, 0},
{ SWIG_INT,     (char *) SWIG_prefix "svn_node_action_replace", (long) svn_node_action_replace, 0, 0, 0},
{ SWIG_INT,     (char *) SWIG_prefix "svn_repos_load_uuid_default", (long) svn_repos_load_uuid_default, 0, 0, 0},
{ SWIG_INT,     (char *) SWIG_prefix "svn_repos_load_uuid_ignore", (long) svn_repos_load_uuid_ignore, 0, 0, 0},
{ SWIG_INT,     (char *) SWIG_prefix "svn_repos_load_uuid_force", (long) svn_repos_load_uuid_force, 0, 0, 0},
{0,0,0,0,0,0}
};
#ifdef __cplusplus
}
#endif
static swig_variable_info swig_variables[] = {
{0,0,0,0}
};
static swig_command_info swig_commands[] = {
{"SVN::_Repos::svn_repos_version", _wrap_svn_repos_version},
{"SVN::_Repos::svn_repos_find_root_path", _wrap_svn_repos_find_root_path},
{"SVN::_Repos::svn_repos_open", _wrap_svn_repos_open},
{"SVN::_Repos::svn_repos_create", _wrap_svn_repos_create},
{"SVN::_Repos::svn_repos_delete", _wrap_svn_repos_delete},
{"SVN::_Repos::svn_repos_fs", _wrap_svn_repos_fs},
{"SVN::_Repos::svn_repos_hotcopy", _wrap_svn_repos_hotcopy},
{"SVN::_Repos::svn_repos_recover", _wrap_svn_repos_recover},
{"SVN::_Repos::svn_repos_recover2", _wrap_svn_repos_recover2},
{"SVN::_Repos::svn_repos_db_logfiles", _wrap_svn_repos_db_logfiles},
{"SVN::_Repos::svn_repos_path", _wrap_svn_repos_path},
{"SVN::_Repos::svn_repos_db_env", _wrap_svn_repos_db_env},
{"SVN::_Repos::svn_repos_conf_dir", _wrap_svn_repos_conf_dir},
{"SVN::_Repos::svn_repos_svnserve_conf", _wrap_svn_repos_svnserve_conf},
{"SVN::_Repos::svn_repos_lock_dir", _wrap_svn_repos_lock_dir},
{"SVN::_Repos::svn_repos_db_lockfile", _wrap_svn_repos_db_lockfile},
{"SVN::_Repos::svn_repos_db_logs_lockfile", _wrap_svn_repos_db_logs_lockfile},
{"SVN::_Repos::svn_repos_hook_dir", _wrap_svn_repos_hook_dir},
{"SVN::_Repos::svn_repos_start_commit_hook", _wrap_svn_repos_start_commit_hook},
{"SVN::_Repos::svn_repos_pre_commit_hook", _wrap_svn_repos_pre_commit_hook},
{"SVN::_Repos::svn_repos_post_commit_hook", _wrap_svn_repos_post_commit_hook},
{"SVN::_Repos::svn_repos_pre_revprop_change_hook", _wrap_svn_repos_pre_revprop_change_hook},
{"SVN::_Repos::svn_repos_post_revprop_change_hook", _wrap_svn_repos_post_revprop_change_hook},
{"SVN::_Repos::svn_repos_pre_lock_hook", _wrap_svn_repos_pre_lock_hook},
{"SVN::_Repos::svn_repos_post_lock_hook", _wrap_svn_repos_post_lock_hook},
{"SVN::_Repos::svn_repos_pre_unlock_hook", _wrap_svn_repos_pre_unlock_hook},
{"SVN::_Repos::svn_repos_post_unlock_hook", _wrap_svn_repos_post_unlock_hook},
{"SVN::_Repos::svn_repos_begin_report", _wrap_svn_repos_begin_report},
{"SVN::_Repos::svn_repos_set_path2", _wrap_svn_repos_set_path2},
{"SVN::_Repos::svn_repos_set_path", _wrap_svn_repos_set_path},
{"SVN::_Repos::svn_repos_link_path2", _wrap_svn_repos_link_path2},
{"SVN::_Repos::svn_repos_link_path", _wrap_svn_repos_link_path},
{"SVN::_Repos::svn_repos_delete_path", _wrap_svn_repos_delete_path},
{"SVN::_Repos::svn_repos_finish_report", _wrap_svn_repos_finish_report},
{"SVN::_Repos::svn_repos_abort_report", _wrap_svn_repos_abort_report},
{"SVN::_Repos::svn_repos_dir_delta", _wrap_svn_repos_dir_delta},
{"SVN::_Repos::svn_repos_replay2", _wrap_svn_repos_replay2},
{"SVN::_Repos::svn_repos_replay", _wrap_svn_repos_replay},
{"SVN::_Repos::svn_repos_get_commit_editor4", _wrap_svn_repos_get_commit_editor4},
{"SVN::_Repos::svn_repos_get_commit_editor3", _wrap_svn_repos_get_commit_editor3},
{"SVN::_Repos::svn_repos_get_commit_editor2", _wrap_svn_repos_get_commit_editor2},
{"SVN::_Repos::svn_repos_get_commit_editor", _wrap_svn_repos_get_commit_editor},
{"SVN::_Repos::svn_repos_dated_revision", _wrap_svn_repos_dated_revision},
{"SVN::_Repos::svn_repos_get_committed_info", _wrap_svn_repos_get_committed_info},
{"SVN::_Repos::svn_repos_stat", _wrap_svn_repos_stat},
{"SVN::_Repos::svn_repos_history2", _wrap_svn_repos_history2},
{"SVN::_Repos::svn_repos_history", _wrap_svn_repos_history},
{"SVN::_Repos::svn_repos_trace_node_locations", _wrap_svn_repos_trace_node_locations},
{"SVN::_Repos::svn_repos_get_logs3", _wrap_svn_repos_get_logs3},
{"SVN::_Repos::svn_repos_get_logs2", _wrap_svn_repos_get_logs2},
{"SVN::_Repos::svn_repos_get_logs", _wrap_svn_repos_get_logs},
{"SVN::_Repos::svn_repos_get_file_revs", _wrap_svn_repos_get_file_revs},
{"SVN::_Repos::svn_repos_fs_commit_txn", _wrap_svn_repos_fs_commit_txn},
{"SVN::_Repos::svn_repos_fs_begin_txn_for_commit", _wrap_svn_repos_fs_begin_txn_for_commit},
{"SVN::_Repos::svn_repos_fs_begin_txn_for_update", _wrap_svn_repos_fs_begin_txn_for_update},
{"SVN::_Repos::svn_repos_fs_lock", _wrap_svn_repos_fs_lock},
{"SVN::_Repos::svn_repos_fs_unlock", _wrap_svn_repos_fs_unlock},
{"SVN::_Repos::svn_repos_fs_get_locks", _wrap_svn_repos_fs_get_locks},
{"SVN::_Repos::svn_repos_fs_change_rev_prop2", _wrap_svn_repos_fs_change_rev_prop2},
{"SVN::_Repos::svn_repos_fs_change_rev_prop", _wrap_svn_repos_fs_change_rev_prop},
{"SVN::_Repos::svn_repos_fs_revision_prop", _wrap_svn_repos_fs_revision_prop},
{"SVN::_Repos::svn_repos_fs_revision_proplist", _wrap_svn_repos_fs_revision_proplist},
{"SVN::_Repos::svn_repos_fs_change_node_prop", _wrap_svn_repos_fs_change_node_prop},
{"SVN::_Repos::svn_repos_fs_change_txn_prop", _wrap_svn_repos_fs_change_txn_prop},
{"SVN::_Repos::svn_repos_node_t_kind_set", _wrap_svn_repos_node_t_kind_set},
{"SVN::_Repos::svn_repos_node_t_kind_get", _wrap_svn_repos_node_t_kind_get},
{"SVN::_Repos::svn_repos_node_t_action_set", _wrap_svn_repos_node_t_action_set},
{"SVN::_Repos::svn_repos_node_t_action_get", _wrap_svn_repos_node_t_action_get},
{"SVN::_Repos::svn_repos_node_t_text_mod_set", _wrap_svn_repos_node_t_text_mod_set},
{"SVN::_Repos::svn_repos_node_t_text_mod_get", _wrap_svn_repos_node_t_text_mod_get},
{"SVN::_Repos::svn_repos_node_t_prop_mod_set", _wrap_svn_repos_node_t_prop_mod_set},
{"SVN::_Repos::svn_repos_node_t_prop_mod_get", _wrap_svn_repos_node_t_prop_mod_get},
{"SVN::_Repos::svn_repos_node_t_name_set", _wrap_svn_repos_node_t_name_set},
{"SVN::_Repos::svn_repos_node_t_name_get", _wrap_svn_repos_node_t_name_get},
{"SVN::_Repos::svn_repos_node_t_copyfrom_rev_set", _wrap_svn_repos_node_t_copyfrom_rev_set},
{"SVN::_Repos::svn_repos_node_t_copyfrom_rev_get", _wrap_svn_repos_node_t_copyfrom_rev_get},
{"SVN::_Repos::svn_repos_node_t_copyfrom_path_set", _wrap_svn_repos_node_t_copyfrom_path_set},
{"SVN::_Repos::svn_repos_node_t_copyfrom_path_get", _wrap_svn_repos_node_t_copyfrom_path_get},
{"SVN::_Repos::svn_repos_node_t_sibling_set", _wrap_svn_repos_node_t_sibling_set},
{"SVN::_Repos::svn_repos_node_t_sibling_get", _wrap_svn_repos_node_t_sibling_get},
{"SVN::_Repos::svn_repos_node_t_child_set", _wrap_svn_repos_node_t_child_set},
{"SVN::_Repos::svn_repos_node_t_child_get", _wrap_svn_repos_node_t_child_get},
{"SVN::_Repos::svn_repos_node_t_parent_set", _wrap_svn_repos_node_t_parent_set},
{"SVN::_Repos::svn_repos_node_t_parent_get", _wrap_svn_repos_node_t_parent_get},
{"SVN::_Repos::svn_repos_node_editor", _wrap_svn_repos_node_editor},
{"SVN::_Repos::svn_repos_node_from_baton", _wrap_svn_repos_node_from_baton},
{"SVN::_Repos::svn_repos_dump_fs2", _wrap_svn_repos_dump_fs2},
{"SVN::_Repos::svn_repos_dump_fs", _wrap_svn_repos_dump_fs},
{"SVN::_Repos::svn_repos_load_fs2", _wrap_svn_repos_load_fs2},
{"SVN::_Repos::svn_repos_load_fs", _wrap_svn_repos_load_fs},
{"SVN::_Repos::svn_repos_parse_fns2_t_new_revision_record_set", _wrap_svn_repos_parse_fns2_t_new_revision_record_set},
{"SVN::_Repos::svn_repos_parse_fns2_t_new_revision_record_get", _wrap_svn_repos_parse_fns2_t_new_revision_record_get},
{"SVN::_Repos::svn_repos_parse_fns2_t_uuid_record_set", _wrap_svn_repos_parse_fns2_t_uuid_record_set},
{"SVN::_Repos::svn_repos_parse_fns2_t_uuid_record_get", _wrap_svn_repos_parse_fns2_t_uuid_record_get},
{"SVN::_Repos::svn_repos_parse_fns2_t_new_node_record_set", _wrap_svn_repos_parse_fns2_t_new_node_record_set},
{"SVN::_Repos::svn_repos_parse_fns2_t_new_node_record_get", _wrap_svn_repos_parse_fns2_t_new_node_record_get},
{"SVN::_Repos::svn_repos_parse_fns2_t_set_revision_property_set", _wrap_svn_repos_parse_fns2_t_set_revision_property_set},
{"SVN::_Repos::svn_repos_parse_fns2_t_set_revision_property_get", _wrap_svn_repos_parse_fns2_t_set_revision_property_get},
{"SVN::_Repos::svn_repos_parse_fns2_t_set_node_property_set", _wrap_svn_repos_parse_fns2_t_set_node_property_set},
{"SVN::_Repos::svn_repos_parse_fns2_t_set_node_property_get", _wrap_svn_repos_parse_fns2_t_set_node_property_get},
{"SVN::_Repos::svn_repos_parse_fns2_t_delete_node_property_set", _wrap_svn_repos_parse_fns2_t_delete_node_property_set},
{"SVN::_Repos::svn_repos_parse_fns2_t_delete_node_property_get", _wrap_svn_repos_parse_fns2_t_delete_node_property_get},
{"SVN::_Repos::svn_repos_parse_fns2_t_remove_node_props_set", _wrap_svn_repos_parse_fns2_t_remove_node_props_set},
{"SVN::_Repos::svn_repos_parse_fns2_t_remove_node_props_get", _wrap_svn_repos_parse_fns2_t_remove_node_props_get},
{"SVN::_Repos::svn_repos_parse_fns2_t_set_fulltext_set", _wrap_svn_repos_parse_fns2_t_set_fulltext_set},
{"SVN::_Repos::svn_repos_parse_fns2_t_set_fulltext_get", _wrap_svn_repos_parse_fns2_t_set_fulltext_get},
{"SVN::_Repos::svn_repos_parse_fns2_t_apply_textdelta_set", _wrap_svn_repos_parse_fns2_t_apply_textdelta_set},
{"SVN::_Repos::svn_repos_parse_fns2_t_apply_textdelta_get", _wrap_svn_repos_parse_fns2_t_apply_textdelta_get},
{"SVN::_Repos::svn_repos_parse_fns2_t_close_node_set", _wrap_svn_repos_parse_fns2_t_close_node_set},
{"SVN::_Repos::svn_repos_parse_fns2_t_close_node_get", _wrap_svn_repos_parse_fns2_t_close_node_get},
{"SVN::_Repos::svn_repos_parse_fns2_t_close_revision_set", _wrap_svn_repos_parse_fns2_t_close_revision_set},
{"SVN::_Repos::svn_repos_parse_fns2_t_close_revision_get", _wrap_svn_repos_parse_fns2_t_close_revision_get},
{"SVN::_Repos::svn_repos_parse_dumpstream2", _wrap_svn_repos_parse_dumpstream2},
{"SVN::_Repos::svn_repos_get_fs_build_parser2", _wrap_svn_repos_get_fs_build_parser2},
{"SVN::_Repos::svn_repos_parser_fns_t_new_revision_record_set", _wrap_svn_repos_parser_fns_t_new_revision_record_set},
{"SVN::_Repos::svn_repos_parser_fns_t_new_revision_record_get", _wrap_svn_repos_parser_fns_t_new_revision_record_get},
{"SVN::_Repos::svn_repos_parser_fns_t_uuid_record_set", _wrap_svn_repos_parser_fns_t_uuid_record_set},
{"SVN::_Repos::svn_repos_parser_fns_t_uuid_record_get", _wrap_svn_repos_parser_fns_t_uuid_record_get},
{"SVN::_Repos::svn_repos_parser_fns_t_new_node_record_set", _wrap_svn_repos_parser_fns_t_new_node_record_set},
{"SVN::_Repos::svn_repos_parser_fns_t_new_node_record_get", _wrap_svn_repos_parser_fns_t_new_node_record_get},
{"SVN::_Repos::svn_repos_parser_fns_t_set_revision_property_set", _wrap_svn_repos_parser_fns_t_set_revision_property_set},
{"SVN::_Repos::svn_repos_parser_fns_t_set_revision_property_get", _wrap_svn_repos_parser_fns_t_set_revision_property_get},
{"SVN::_Repos::svn_repos_parser_fns_t_set_node_property_set", _wrap_svn_repos_parser_fns_t_set_node_property_set},
{"SVN::_Repos::svn_repos_parser_fns_t_set_node_property_get", _wrap_svn_repos_parser_fns_t_set_node_property_get},
{"SVN::_Repos::svn_repos_parser_fns_t_remove_node_props_set", _wrap_svn_repos_parser_fns_t_remove_node_props_set},
{"SVN::_Repos::svn_repos_parser_fns_t_remove_node_props_get", _wrap_svn_repos_parser_fns_t_remove_node_props_get},
{"SVN::_Repos::svn_repos_parser_fns_t_set_fulltext_set", _wrap_svn_repos_parser_fns_t_set_fulltext_set},
{"SVN::_Repos::svn_repos_parser_fns_t_set_fulltext_get", _wrap_svn_repos_parser_fns_t_set_fulltext_get},
{"SVN::_Repos::svn_repos_parser_fns_t_close_node_set", _wrap_svn_repos_parser_fns_t_close_node_set},
{"SVN::_Repos::svn_repos_parser_fns_t_close_node_get", _wrap_svn_repos_parser_fns_t_close_node_get},
{"SVN::_Repos::svn_repos_parser_fns_t_close_revision_set", _wrap_svn_repos_parser_fns_t_close_revision_set},
{"SVN::_Repos::svn_repos_parser_fns_t_close_revision_get", _wrap_svn_repos_parser_fns_t_close_revision_get},
{"SVN::_Repos::svn_repos_parse_dumpstream", _wrap_svn_repos_parse_dumpstream},
{"SVN::_Repos::svn_repos_get_fs_build_parser", _wrap_svn_repos_get_fs_build_parser},
{"SVN::_Repos::svn_repos_authz_read", _wrap_svn_repos_authz_read},
{"SVN::_Repos::svn_repos_authz_check_access", _wrap_svn_repos_authz_check_access},
{"SVN::_Repos::svn_repos_parse_fns2_invoke_new_revision_record", _wrap_svn_repos_parse_fns2_invoke_new_revision_record},
{"SVN::_Repos::svn_repos_parse_fns2_invoke_uuid_record", _wrap_svn_repos_parse_fns2_invoke_uuid_record},
{"SVN::_Repos::svn_repos_parse_fns2_invoke_new_node_record", _wrap_svn_repos_parse_fns2_invoke_new_node_record},
{"SVN::_Repos::svn_repos_parse_fns2_invoke_set_revision_property", _wrap_svn_repos_parse_fns2_invoke_set_revision_property},
{"SVN::_Repos::svn_repos_parse_fns2_invoke_set_node_property", _wrap_svn_repos_parse_fns2_invoke_set_node_property},
{"SVN::_Repos::svn_repos_parse_fns2_invoke_delete_node_property", _wrap_svn_repos_parse_fns2_invoke_delete_node_property},
{"SVN::_Repos::svn_repos_parse_fns2_invoke_remove_node_props", _wrap_svn_repos_parse_fns2_invoke_remove_node_props},
{"SVN::_Repos::svn_repos_parse_fns2_invoke_set_fulltext", _wrap_svn_repos_parse_fns2_invoke_set_fulltext},
{"SVN::_Repos::svn_repos_parse_fns2_invoke_apply_textdelta", _wrap_svn_repos_parse_fns2_invoke_apply_textdelta},
{"SVN::_Repos::svn_repos_parse_fns2_invoke_close_node", _wrap_svn_repos_parse_fns2_invoke_close_node},
{"SVN::_Repos::svn_repos_parse_fns2_invoke_close_revision", _wrap_svn_repos_parse_fns2_invoke_close_revision},
{0,0}
};
/*************************************************************************
 * Type initialization:
 * This problem is tough by the requirement that no dynamic 
 * memory is used. Also, since swig_type_info structures store pointers to 
 * swig_cast_info structures and swig_cast_info structures store pointers back
 * to swig_type_info structures, we need some lookup code at initialization. 
 * The idea is that swig generates all the structures that are needed. 
 * The runtime then collects these partially filled structures. 
 * The SWIG_InitializeModule function takes these initial arrays out of 
 * swig_module, and does all the lookup, filling in the swig_module.types
 * array with the correct data and linking the correct swig_cast_info
 * structures together.

 * The generated swig_type_info structures are assigned staticly to an initial 
 * array. We just loop though that array, and handle each type individually.
 * First we lookup if this type has been already loaded, and if so, use the
 * loaded structure instead of the generated one. Then we have to fill in the
 * cast linked list. The cast data is initially stored in something like a
 * two-dimensional array. Each row corresponds to a type (there are the same
 * number of rows as there are in the swig_type_initial array). Each entry in
 * a column is one of the swig_cast_info structures for that type.
 * The cast_initial array is actually an array of arrays, because each row has
 * a variable number of columns. So to actually build the cast linked list,
 * we find the array of casts associated with the type, and loop through it 
 * adding the casts to the list. The one last trick we need to do is making
 * sure the type pointer in the swig_cast_info struct is correct.

 * First off, we lookup the cast->type name to see if it is already loaded. 
 * There are three cases to handle:
 *  1) If the cast->type has already been loaded AND the type we are adding
 *     casting info to has not been loaded (it is in this module), THEN we
 *     replace the cast->type pointer with the type pointer that has already
 *     been loaded.
 *  2) If BOTH types (the one we are adding casting info to, and the 
 *     cast->type) are loaded, THEN the cast info has already been loaded by
 *     the previous module so we just ignore it.
 *  3) Finally, if cast->type has not already been loaded, then we add that
 *     swig_cast_info to the linked list (because the cast->type) pointer will
 *     be correct.
**/

#ifdef __cplusplus
extern "C" {
#endif
    
    SWIGRUNTIME void
    SWIG_InitializeModule(void *clientdata) {
        swig_type_info *type, *ret;
        swig_cast_info *cast;
        size_t i;
        swig_module_info *module_head;
        static int init_run = 0;
        
        clientdata = clientdata;
        
        if (init_run) return;
        init_run = 1;
        
        /* Initialize the swig_module */
        swig_module.type_initial = swig_type_initial;
        swig_module.cast_initial = swig_cast_initial;
        
        /* Try and load any already created modules */
        module_head = SWIG_GetModule(clientdata);
        if (module_head) {
            swig_module.next = module_head->next;
            module_head->next = &swig_module;
        } else {
            /* This is the first module loaded */
            swig_module.next = &swig_module;
            SWIG_SetModule(clientdata, &swig_module);
        }
        
        /* Now work on filling in swig_module.types */
        for (i = 0; i < swig_module.size; ++i) {
            type = 0;
            
            /* if there is another module already loaded */
            if (swig_module.next != &swig_module) {
                type = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, swig_module.type_initial[i]->name);
            }
            if (type) {
                /* Overwrite clientdata field */
                if (swig_module.type_initial[i]->clientdata) type->clientdata = swig_module.type_initial[i]->clientdata;
            } else {
                type = swig_module.type_initial[i];
            }
            
            /* Insert casting types */
            cast = swig_module.cast_initial[i];
            while (cast->type) {
                /* Don't need to add information already in the list */
                ret = 0;
                if (swig_module.next != &swig_module) {
                    ret = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, cast->type->name);
                }
                if (ret && type == swig_module.type_initial[i]) {
                    cast->type = ret;
                    ret = 0;
                }
                
                if (!ret) {
                    if (type->cast) {
                        type->cast->prev = cast;
                        cast->next = type->cast;
                    }
                    type->cast = cast;
                }
                
                cast++;
            }
            
            /* Set entry in modules->types array equal to the type */
            swig_module.types[i] = type;
        }
    }
    
    /* This function will propagate the clientdata field of type to
    * any new swig_type_info structures that have been added into the list
    * of equivalent types.  It is like calling
    * SWIG_TypeClientData(type, clientdata) a second time.
    */
    SWIGRUNTIME void
    SWIG_PropagateClientData(void) {
        size_t i;
        swig_cast_info *equiv;
        static int init_run = 0;
        
        if (init_run) return;
        init_run = 1;
        
        for (i = 0; i < swig_module.size; i++) {
            if (swig_module.types[i]->clientdata) {
                equiv = swig_module.types[i]->cast;
                while (equiv) {
                    if (!equiv->converter) {
                        if (equiv->type && !equiv->type->clientdata)
                        SWIG_TypeClientData(equiv->type, swig_module.types[i]->clientdata);
                    }
                    equiv = equiv->next;
                }
            }
        }
    }
    
#ifdef __cplusplus
}
#endif



#ifdef __cplusplus
extern "C"
#endif

XS(SWIG_init) {
    dXSARGS;
    int i;
    
    SWIG_InitializeModule(0);
    
    /* Install commands */
    for (i = 0; swig_commands[i].name; i++) {
        newXS((char*) swig_commands[i].name,swig_commands[i].wrapper, (char*)__FILE__);
    }
    
    /* Install variables */
    for (i = 0; swig_variables[i].name; i++) {
        SV *sv;
        sv = perl_get_sv((char*) swig_variables[i].name, TRUE | 0x2);
        if (swig_variables[i].type) {
            SWIG_MakePtr(sv,(void *)1, *swig_variables[i].type,0);
        } else {
            sv_setiv(sv,(IV) 0);
        }
        swig_create_magic(sv, (char *) swig_variables[i].name, swig_variables[i].set, swig_variables[i].get); 
    }
    
    /* Install constant */
    for (i = 0; swig_constants[i].type; i++) {
        SV *sv;
        sv = perl_get_sv((char*)swig_constants[i].name, TRUE | 0x2);
        switch(swig_constants[i].type) {
            case SWIG_INT:
            sv_setiv(sv, (IV) swig_constants[i].lvalue);
            break;
            case SWIG_FLOAT:
            sv_setnv(sv, (double) swig_constants[i].dvalue);
            break;
            case SWIG_STRING:
            sv_setpv(sv, (char *) swig_constants[i].pvalue);
            break;
            case SWIG_POINTER:
            SWIG_MakePtr(sv, swig_constants[i].pvalue, *(swig_constants[i].ptype),0);
            break;
            case SWIG_BINARY:
            SWIG_MakePackedObj(sv, swig_constants[i].pvalue, swig_constants[i].lvalue, *(swig_constants[i].ptype));
            break;
            default:
            break;
        }
        SvREADONLY_on(sv);
    }
    
    ST(0) = &PL_sv_yes;
    XSRETURN(1);
}

