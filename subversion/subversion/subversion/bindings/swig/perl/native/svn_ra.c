/* ----------------------------------------------------------------------------
 * This file was automatically generated by SWIG (http://www.swig.org).
 * Version 1.3.25
 * 
 * This file is not intended to be easily readable and contains a number of 
 * coding conventions designed to improve portability and efficiency. Do not make
 * changes to this file unless you know what you are doing--modify the SWIG 
 * interface file instead. 
 * ----------------------------------------------------------------------------- */

/***********************************************************************
 *
 *  This section contains generic SWIG labels for method/variable
 *  declarations/attributes, and other compiler dependent labels.
 *
 ************************************************************************/

/* template workaround for compilers that cannot correctly implement the C++ standard */
#ifndef SWIGTEMPLATEDISAMBIGUATOR
#  if defined(__SUNPRO_CC) && (__SUNPRO_CC <= 0x560)
#    define SWIGTEMPLATEDISAMBIGUATOR template
#  else
#    define SWIGTEMPLATEDISAMBIGUATOR 
#  endif
#endif

/* inline attribute */
#ifndef SWIGINLINE
# if defined(__cplusplus) || (defined(__GNUC__) && !defined(__STRICT_ANSI__))
#   define SWIGINLINE inline
# else
#   define SWIGINLINE
# endif
#endif

/* attribute recognised by some compilers to avoid 'unused' warnings */
#ifndef SWIGUNUSED
# if defined(__GNUC__) || defined(__ICC)
#   define SWIGUNUSED __attribute__ ((unused)) 
# else
#   define SWIGUNUSED 
# endif
#endif

/* internal SWIG method */
#ifndef SWIGINTERN
# define SWIGINTERN static SWIGUNUSED
#endif

/* internal inline SWIG method */
#ifndef SWIGINTERNINLINE
# define SWIGINTERNINLINE SWIGINTERN SWIGINLINE
#endif

/* exporting methods for Windows DLLs */
#ifndef SWIGEXPORT
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   if defined(STATIC_LINKED)
#     define SWIGEXPORT
#   else
#     define SWIGEXPORT __declspec(dllexport)
#   endif
# else
#   define SWIGEXPORT
# endif
#endif

/* calling conventions for Windows */
#ifndef SWIGSTDCALL
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   define SWIGSTDCALL __stdcall
# else
#   define SWIGSTDCALL
# endif 
#endif


/***********************************************************************
 * swigrun.swg
 *
 *     This file contains generic CAPI SWIG runtime support for pointer
 *     type checking.
 *
 ************************************************************************/

/* This should only be incremented when either the layout of swig_type_info changes,
   or for whatever reason, the runtime changes incompatibly */
#define SWIG_RUNTIME_VERSION "2"

/* define SWIG_TYPE_TABLE_NAME as "SWIG_TYPE_TABLE" */
#ifdef SWIG_TYPE_TABLE
# define SWIG_QUOTE_STRING(x) #x
# define SWIG_EXPAND_AND_QUOTE_STRING(x) SWIG_QUOTE_STRING(x)
# define SWIG_TYPE_TABLE_NAME SWIG_EXPAND_AND_QUOTE_STRING(SWIG_TYPE_TABLE)
#else
# define SWIG_TYPE_TABLE_NAME
#endif

/*
  You can use the SWIGRUNTIME and SWIGRUNTIMEINLINE macros for
  creating a static or dynamic library from the swig runtime code.
  In 99.9% of the cases, swig just needs to declare them as 'static'.
  
  But only do this if is strictly necessary, ie, if you have problems
  with your compiler or so.
*/

#ifndef SWIGRUNTIME
# define SWIGRUNTIME SWIGINTERN
#endif

#ifndef SWIGRUNTIMEINLINE
# define SWIGRUNTIMEINLINE SWIGRUNTIME SWIGINLINE
#endif

#include <string.h>

#ifdef __cplusplus
extern "C" {
#endif

typedef void *(*swig_converter_func)(void *);
typedef struct swig_type_info *(*swig_dycast_func)(void **);

/* Structure to store inforomation on one type */
typedef struct swig_type_info {
  const char             *name;			/* mangled name of this type */
  const char             *str;			/* human readable name of this type */
  swig_dycast_func        dcast;		/* dynamic cast function down a hierarchy */
  struct swig_cast_info  *cast;			/* linked list of types that can cast into this type */
  void                   *clientdata;		/* language specific type data */
} swig_type_info;

/* Structure to store a type and conversion function used for casting */
typedef struct swig_cast_info {
  swig_type_info         *type;			/* pointer to type that is equivalent to this type */
  swig_converter_func     converter;		/* function to cast the void pointers */
  struct swig_cast_info  *next;			/* pointer to next cast in linked list */
  struct swig_cast_info  *prev;			/* pointer to the previous cast */
} swig_cast_info;

/* Structure used to store module information
 * Each module generates one structure like this, and the runtime collects
 * all of these structures and stores them in a circularly linked list.*/
typedef struct swig_module_info {
  swig_type_info         **types;		/* Array of pointers to swig_type_info structures that are in this module */
  size_t                 size;		        /* Number of types in this module */
  struct swig_module_info *next;		/* Pointer to next element in circularly linked list */
  swig_type_info         **type_initial;	/* Array of initially generated type structures */
  swig_cast_info         **cast_initial;	/* Array of initially generated casting structures */
  void                    *clientdata;		/* Language specific module data */
} swig_module_info;


/* 
  Compare two type names skipping the space characters, therefore
  "char*" == "char *" and "Class<int>" == "Class<int >", etc.

  Return 0 when the two name types are equivalent, as in
  strncmp, but skipping ' '.
*/
SWIGRUNTIME int
SWIG_TypeNameComp(const char *f1, const char *l1,
		  const char *f2, const char *l2) {
  for (;(f1 != l1) && (f2 != l2); ++f1, ++f2) {
    while ((*f1 == ' ') && (f1 != l1)) ++f1;
    while ((*f2 == ' ') && (f2 != l2)) ++f2;
    if (*f1 != *f2) return (int)(*f1 - *f2);
  }
  return (l1 - f1) - (l2 - f2);
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if not equal, 1 if equal
*/
SWIGRUNTIME int
SWIG_TypeEquiv(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if equal, -1 if nb < tb, 1 if nb > tb
*/
SWIGRUNTIME int
SWIG_TypeCompare(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}


/* think of this as a c++ template<> or a scheme macro */
#define SWIG_TypeCheck_Template(comparison, ty)         \
  if (ty) {                                             \
    swig_cast_info *iter = ty->cast;                    \
    while (iter) {                                      \
      if (comparison) {                                 \
        if (iter == ty->cast) return iter;              \
        /* Move iter to the top of the linked list */   \
        iter->prev->next = iter->next;                  \
        if (iter->next)                                 \
          iter->next->prev = iter->prev;                \
        iter->next = ty->cast;                          \
        iter->prev = 0;                                 \
        if (ty->cast) ty->cast->prev = iter;            \
        ty->cast = iter;                                \
        return iter;                                    \
      }                                                 \
      iter = iter->next;                                \
    }                                                   \
  }                                                     \
  return 0

/*
  Check the typename
*/
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheck(const char *c, swig_type_info *ty) {
  SWIG_TypeCheck_Template(strcmp(iter->type->name, c) == 0, ty);
}

/* Same as previous function, except strcmp is replaced with a pointer comparison */
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheckStruct(swig_type_info *from, swig_type_info *into) {
  SWIG_TypeCheck_Template(iter->type == from, into);
}

/*
  Cast a pointer up an inheritance hierarchy
*/
SWIGRUNTIMEINLINE void *
SWIG_TypeCast(swig_cast_info *ty, void *ptr) {
  return ((!ty) || (!ty->converter)) ? ptr : (*ty->converter)(ptr);
}

/* 
   Dynamic pointer casting. Down an inheritance hierarchy
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeDynamicCast(swig_type_info *ty, void **ptr) {
  swig_type_info *lastty = ty;
  if (!ty || !ty->dcast) return ty;
  while (ty && (ty->dcast)) {
    ty = (*ty->dcast)(ptr);
    if (ty) lastty = ty;
  }
  return lastty;
}

/*
  Return the name associated with this type
*/
SWIGRUNTIMEINLINE const char *
SWIG_TypeName(const swig_type_info *ty) {
  return ty->name;
}

/*
  Return the pretty name associated with this type,
  that is an unmangled type name in a form presentable to the user.
*/
SWIGRUNTIME const char *
SWIG_TypePrettyName(const swig_type_info *type) {
  /* The "str" field contains the equivalent pretty names of the
     type, separated by vertical-bar characters.  We choose
     to print the last name, as it is often (?) the most
     specific. */
  if (type->str != NULL) {
    const char *last_name = type->str;
    const char *s;
    for (s = type->str; *s; s++)
      if (*s == '|') last_name = s+1;
    return last_name;
  }
  else
    return type->name;
}

/* 
   Set the clientdata field for a type
*/
SWIGRUNTIME void
SWIG_TypeClientData(swig_type_info *ti, void *clientdata) {
  if (!ti->clientdata) {
    swig_cast_info *cast = ti->cast;
    /* if (ti->clientdata == clientdata) return; */
    ti->clientdata = clientdata;
    
    while (cast) {
      if (!cast->converter)
	SWIG_TypeClientData(cast->type, clientdata);
      cast = cast->next;
    }
  }
}

/*
  Search for a swig_type_info structure only by mangled name
  Search is a O(log #types)
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_MangledTypeQueryModule(swig_module_info *start, 
                            swig_module_info *end, 
		            const char *name) {
  swig_module_info *iter = start;
  do {
    if (iter->size) {
      register size_t l = 0;
      register size_t r = iter->size - 1;
      do {
	/* since l+r >= 0, we can (>> 1) instead (/ 2) */
	register size_t i = (l + r) >> 1; 
	const char *iname = iter->types[i]->name;
	if (iname) {
	  register int compare = strcmp(name, iname);
	  if (compare == 0) {	    
	    return iter->types[i];
	  } else if (compare < 0) {
	    if (i) {
	      r = i - 1;
	    } else {
	      break;
	    }
	  } else if (compare > 0) {
	    l = i + 1;
	  }
	} else {
	  break; /* should never happen */
	}
      } while (l <= r);
    }
    iter = iter->next;
  } while (iter != end);
  return 0;
}

/*
  Search for a swig_type_info structure for either a mangled name or a human readable name.
  It first searches the mangled names of the types, which is a O(log #types)
  If a type is not found it then searches the human readable names, which is O(#types).
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeQueryModule(swig_module_info *start, 
                     swig_module_info *end, 
		     const char *name) {
  /* STEP 1: Search the name field using binary search */
  swig_type_info *ret = SWIG_MangledTypeQueryModule(start, end, name);
  if (ret) {
    return ret;
  } else {
    /* STEP 2: If the type hasn't been found, do a complete search
       of the str field (the human readable name) */
    swig_module_info *iter = start;
    do {
      register size_t i = 0;
      for (; i < iter->size; ++i) {
	if (iter->types[i]->str && (SWIG_TypeEquiv(iter->types[i]->str, name)))
	  return iter->types[i];
      }
      iter = iter->next;
    } while (iter != end);
  }
  
  /* neither found a match */
  return 0;
}


/* 
   Pack binary data into a string
*/
SWIGRUNTIME char *
SWIG_PackData(char *c, void *ptr, size_t sz) {
  static const char hex[17] = "0123456789abcdef";
  register const unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu =  u + sz;
  for (; u != eu; ++u) {
    register unsigned char uu = *u;
    *(c++) = hex[(uu & 0xf0) >> 4];
    *(c++) = hex[uu & 0xf];
  }
  return c;
}

/* 
   Unpack binary data from a string
*/
SWIGRUNTIME const char *
SWIG_UnpackData(const char *c, void *ptr, size_t sz) {
  register unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu = u + sz;
  for (; u != eu; ++u) {
    register char d = *(c++);
    register unsigned char uu = 0;
    if ((d >= '0') && (d <= '9'))
      uu = ((d - '0') << 4);
    else if ((d >= 'a') && (d <= 'f'))
      uu = ((d - ('a'-10)) << 4);
    else 
      return (char *) 0;
    d = *(c++);
    if ((d >= '0') && (d <= '9'))
      uu |= (d - '0');
    else if ((d >= 'a') && (d <= 'f'))
      uu |= (d - ('a'-10));
    else 
      return (char *) 0;
    *u = uu;
  }
  return c;
}

/* 
   Pack 'void *' into a string buffer.
*/
SWIGRUNTIME char *
SWIG_PackVoidPtr(char *buff, void *ptr, const char *name, size_t bsz) {
  char *r = buff;
  if ((2*sizeof(void *) + 2) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,&ptr,sizeof(void *));
  if (strlen(name) + 1 > (bsz - (r - buff))) return 0;
  strcpy(r,name);
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackVoidPtr(const char *c, void **ptr, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      *ptr = (void *) 0;
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sizeof(void *));
}

SWIGRUNTIME char *
SWIG_PackDataName(char *buff, void *ptr, size_t sz, const char *name, size_t bsz) {
  char *r = buff;
  size_t lname = (name ? strlen(name) : 0);
  if ((2*sz + 2 + lname) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,ptr,sz);
  if (lname) {
    strncpy(r,name,lname+1);
  } else {
    *r = 0;
  }
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackDataName(const char *c, void *ptr, size_t sz, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      memset(ptr,0,sz);
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sz);
}

#ifdef __cplusplus
}
#endif


/* ---------------------------------------------------------------------- -*- c -*-
 * perl5.swg
 *
 * Perl5 runtime library
 * $Header: /cvsroot/swig/SWIG/Lib/perl5/perlrun.swg,v 1.21 2005/02/01 00:08:17 wuzzeb Exp $
 * ----------------------------------------------------------------------------- */

#define SWIGPERL
#define SWIGPERL5
#ifdef __cplusplus
/* Needed on some windows machines---since MS plays funny games with the header files under C++ */
#include <math.h>
#include <stdlib.h>
extern "C" {
#endif
#include "EXTERN.h"
#include "perl.h"
#include "XSUB.h"

/* Get rid of free and malloc defined by perl */
#undef free
#undef malloc

#ifndef pTHX_
#define pTHX_
#endif

#include <string.h>
#ifdef __cplusplus
}
#endif

/* Macro to call an XS function */

#ifdef PERL_OBJECT 
#  define SWIG_CALLXS(_name) _name(cv,pPerl) 
#else 
#  ifndef MULTIPLICITY 
#    define SWIG_CALLXS(_name) _name(cv) 
#  else 
#    define SWIG_CALLXS(_name) _name(PERL_GET_THX, cv) 
#  endif 
#endif 

/* Contract support */

#define SWIG_contract_assert(expr,msg) if (!(expr)) { SWIG_croak(msg); } else

/* Note: SwigMagicFuncHack is a typedef used to get the C++ compiler to just shut up already */

#ifdef PERL_OBJECT
#define MAGIC_PPERL  CPerlObj *pPerl = (CPerlObj *) this;
typedef int (CPerlObj::*SwigMagicFunc)(SV *, MAGIC *);

#ifdef __cplusplus
extern "C" {
#endif
typedef int (CPerlObj::*SwigMagicFuncHack)(SV *, MAGIC *);
#ifdef __cplusplus
}
#endif

#define SWIG_MAGIC(a,b) (SV *a, MAGIC *b)
#define SWIGCLASS_STATIC
#else
#define MAGIC_PPERL
#define SWIGCLASS_STATIC static
#ifndef MULTIPLICITY
#define SWIG_MAGIC(a,b) (SV *a, MAGIC *b)
typedef int (*SwigMagicFunc)(SV *, MAGIC *);

#ifdef __cplusplus
extern "C" {
#endif
typedef int (*SwigMagicFuncHack)(SV *, MAGIC *);
#ifdef __cplusplus
}
#endif


#else
#define SWIG_MAGIC(a,b) (struct interpreter *interp, SV *a, MAGIC *b)
typedef int (*SwigMagicFunc)(struct interpreter *, SV *, MAGIC *);
#ifdef __cplusplus
extern "C" {
#endif
typedef int (*SwigMagicFuncHack)(struct interpreter *, SV *, MAGIC *);
#ifdef __cplusplus
}
#endif

#endif
#endif

#if defined(WIN32) && defined(PERL_OBJECT) && !defined(PerlIO_exportFILE)
#define PerlIO_exportFILE(fh,fl) (FILE*)(fh)
#endif

/* Modifications for newer Perl 5.005 releases */

#if !defined(PERL_REVISION) || ((PERL_REVISION >= 5) && ((PERL_VERSION < 5) || ((PERL_VERSION == 5) && (PERL_SUBVERSION < 50))))
#  ifndef PL_sv_yes
#    define PL_sv_yes sv_yes
#  endif
#  ifndef PL_sv_undef
#    define PL_sv_undef sv_undef
#  endif
#  ifndef PL_na
#    define PL_na na
#  endif
#endif

#include <stdlib.h>

#ifdef __cplusplus
extern "C" {
#endif

#define SWIG_OWNER 1
#define SWIG_SHADOW 2

/* Common SWIG API */

#ifdef PERL_OBJECT
#  define SWIG_ConvertPtr(obj, pp, type, flags) \
     SWIG_Perl_ConvertPtr(pPerl, obj, pp, type, flags)
#  define SWIG_NewPointerObj(p, type, flags) \
     SWIG_Perl_NewPointerObj(pPerl, p, type, flags)
#  define SWIG_MakePackedObj(sv, p, s, type)	\
     SWIG_Perl_MakePackedObj(pPerl, sv, p, s, type)
#  define SWIG_ConvertPacked(obj, p, s, type, flags) \
     SWIG_Perl_ConvertPacked(pPerl, obj, p, s, type, flags)

#else
#  define SWIG_ConvertPtr(obj, pp, type, flags) \
     SWIG_Perl_ConvertPtr(obj, pp, type, flags)
#  define SWIG_NewPointerObj(p, type, flags) \
     SWIG_Perl_NewPointerObj(p, type, flags)
#  define SWIG_MakePackedObj(sv, p, s, type)	\
     SWIG_Perl_MakePackedObj(sv, p, s, type )
#  define SWIG_ConvertPacked(obj, p, s, type, flags) \
     SWIG_Perl_ConvertPacked(obj, p, s, type, flags)
#endif

/* Runtime API */
#define SWIG_GetModule(clientdata) SWIG_Perl_GetModule()
#define SWIG_SetModule(clientdata, pointer) SWIG_Perl_SetModule(pointer)

/* Perl-specific API */
#ifdef PERL_OBJECT
#  define SWIG_MakePtr(sv, ptr, type, flags) \
     SWIG_Perl_MakePtr(pPerl, sv, ptr, type, flags)
#  define SWIG_SetError(str) \
     SWIG_Perl_SetError(pPerl, str)
#else
#  define SWIG_MakePtr(sv, ptr, type, flags) \
     SWIG_Perl_MakePtr(sv, ptr, type, flags)
#  define SWIG_SetError(str) \
     SWIG_Perl_SetError(str)
#  define SWIG_SetErrorSV(str) \
     SWIG_Perl_SetErrorSV(str)
#endif

#define SWIG_SetErrorf SWIG_Perl_SetErrorf


#ifdef PERL_OBJECT
#  define SWIG_MAYBE_PERL_OBJECT CPerlObj *pPerl,
#else
#  define SWIG_MAYBE_PERL_OBJECT
#endif

static swig_cast_info *
SWIG_Perl_TypeCheckRV(SWIG_MAYBE_PERL_OBJECT SV *rv, swig_type_info *ty) {
  SWIG_TypeCheck_Template(sv_derived_from(rv, (char *) iter->type->name), ty);
}

/* Function for getting a pointer value */

static int
SWIG_Perl_ConvertPtr(SWIG_MAYBE_PERL_OBJECT SV *sv, void **ptr, swig_type_info *_t, int flags) {
  swig_cast_info *tc;
  void *voidptr = (void *)0;

  /* If magical, apply more magic */
  if (SvGMAGICAL(sv))
    mg_get(sv);

  /* Check to see if this is an object */
  if (sv_isobject(sv)) {
    SV *tsv = (SV*) SvRV(sv);
    IV tmp = 0;
    if ((SvTYPE(tsv) == SVt_PVHV)) {
      MAGIC *mg;
      if (SvMAGICAL(tsv)) {
        mg = mg_find(tsv,'P');
        if (mg) {
          sv = mg->mg_obj;
          if (sv_isobject(sv)) {
            tmp = SvIV((SV*)SvRV(sv));
          }
        }
      } else {
        return -1;
      }
    } else {
      tmp = SvIV((SV*)SvRV(sv));
    }
    voidptr = (void *)tmp;
    if (!_t) {
      *(ptr) = voidptr;
      return 0;
    }
  } else if (! SvOK(sv)) {            /* Check for undef */
    *(ptr) = (void *) 0;
    return 0;
  } else if (SvTYPE(sv) == SVt_RV) {  /* Check for NULL pointer */
    *(ptr) = (void *) 0;
    if (!SvROK(sv))
      return 0;
    else
      return -1;
  } else {                            /* Don't know what it is */
    *(ptr) = (void *) 0;
    return -1;
  }
  if (_t) {
    /* Now see if the types match */
    char *_c = HvNAME(SvSTASH(SvRV(sv)));
    tc = SWIG_TypeCheck(_c,_t);
    if (!tc) {
      *ptr = voidptr;
      return -1;
    }
    *ptr = SWIG_TypeCast(tc,voidptr);
    return 0;
  }
  *ptr = voidptr;
  return 0;
}

static void
SWIG_Perl_MakePtr(SWIG_MAYBE_PERL_OBJECT SV *sv, void *ptr, swig_type_info *t, int flags) {
  if (ptr && (flags & SWIG_SHADOW)) {
    SV *self;
    SV *obj=newSV(0);
    HV *hash=newHV();
    HV *stash;
    sv_setref_pv(obj, (char *) t->name, ptr);
    stash=SvSTASH(SvRV(obj));
    if (flags & SWIG_OWNER) {
      HV *hv;
      GV *gv=*(GV**)hv_fetch(stash, "OWNER", 5, TRUE);
      if (!isGV(gv))
        gv_init(gv, stash, "OWNER", 5, FALSE);
      hv=GvHVn(gv);
      hv_store_ent(hv, obj, newSViv(1), 0);
    }
    sv_magic((SV *)hash, (SV *)obj, 'P', Nullch, 0);
    SvREFCNT_dec(obj);
    self=newRV_noinc((SV *)hash);
    sv_setsv(sv, self);
    SvREFCNT_dec((SV *)self);
    sv_bless(sv, stash);
  }
  else {
    sv_setref_pv(sv, (char *) t->name, ptr);
  }
}

static SWIGINLINE SV *
SWIG_Perl_NewPointerObj(SWIG_MAYBE_PERL_OBJECT void *ptr, swig_type_info *t, int flags) {
  SV *result = sv_newmortal();
  SWIG_MakePtr(result, ptr, t, flags);
  return result;
}

static void
  SWIG_Perl_MakePackedObj(SWIG_MAYBE_PERL_OBJECT SV *sv, void *ptr, int sz, swig_type_info *type) {
  char result[1024];
  char *r = result;
  if ((2*sz + 1 + strlen(type->name)) > 1000) return;
  *(r++) = '_';
  r = SWIG_PackData(r,ptr,sz);
  strcpy(r,type->name);
  sv_setpv(sv, result);
}

/* Convert a packed value value */
static int
SWIG_Perl_ConvertPacked(SWIG_MAYBE_PERL_OBJECT SV *obj, void *ptr, int sz, swig_type_info *ty, int flags) {
  swig_cast_info *tc;
  const char  *c = 0;

  if ((!obj) || (!SvOK(obj))) return -1;
  c = SvPV(obj, PL_na);
  /* Pointer values must start with leading underscore */
  if (*c != '_') return -1;
  c++;
  c = SWIG_UnpackData(c,ptr,sz);
  if (ty) {
    tc = SWIG_TypeCheck(c,ty);
    if (!tc) return -1;
  }
  return 0;
}

static SWIGINLINE void
SWIG_Perl_SetError(SWIG_MAYBE_PERL_OBJECT const char *error) {
  if (error) sv_setpv(perl_get_sv("@", TRUE), error);
}

static SWIGINLINE void
SWIG_Perl_SetErrorSV(SWIG_MAYBE_PERL_OBJECT SV *error) {
  if (error) sv_setsv(perl_get_sv("@", TRUE), error);
}

static void
SWIG_Perl_SetErrorf(const char *fmt, ...) {
  va_list args;
  va_start(args, fmt);
  sv_vsetpvfn(perl_get_sv("@", TRUE), fmt, strlen(fmt), &args, Null(SV**), 0, Null(bool*));
  va_end(args);
}

/* Macros for low-level exception handling */
#define SWIG_fail       goto fail
#define SWIG_croak(x)   { SWIG_SetError(x); goto fail; }
#define SWIG_croakSV(x) { SWIG_SetErrorSV(x); goto fail; }
/* most preprocessors do not support vararg macros :-( */
/* #define SWIG_croakf(x...) { SWIG_SetErrorf(x); goto fail; } */


typedef XS(SwigPerlWrapper);
typedef SwigPerlWrapper *SwigPerlWrapperPtr;

/* Structure for command table */
typedef struct {
  const char         *name;
  SwigPerlWrapperPtr  wrapper;
} swig_command_info;

/* Information for constant table */

#define SWIG_INT     1
#define SWIG_FLOAT   2
#define SWIG_STRING  3
#define SWIG_POINTER 4
#define SWIG_BINARY  5

/* Constant information structure */
typedef struct swig_constant_info {
    int              type;
    const char      *name;
    long             lvalue;
    double           dvalue;
    void            *pvalue;
    swig_type_info **ptype;
} swig_constant_info;

#ifdef __cplusplus
}
#endif

/* Structure for variable table */
typedef struct {
  const char   *name;
  SwigMagicFunc   set;
  SwigMagicFunc   get;
  swig_type_info  **type;
} swig_variable_info;

/* Magic variable code */
#ifndef PERL_OBJECT
#define swig_create_magic(s,a,b,c) _swig_create_magic(s,a,b,c)
  #ifndef MULTIPLICITY
     static void _swig_create_magic(SV *sv, char *name, int (*set)(SV *, MAGIC *), int (*get)(SV *,MAGIC *)) {
  #else
     static void _swig_create_magic(SV *sv, char *name, int (*set)(struct interpreter*, SV *, MAGIC *), int (*get)(struct interpreter*, SV *,MAGIC *)) {
  #endif
#else
#  define swig_create_magic(s,a,b,c) _swig_create_magic(pPerl,s,a,b,c)
static void _swig_create_magic(CPerlObj *pPerl, SV *sv, const char *name, int (CPerlObj::*set)(SV *, MAGIC *), int (CPerlObj::*get)(SV *, MAGIC *)) {
#endif
  MAGIC *mg;
  sv_magic(sv,sv,'U',(char *) name,strlen(name));
  mg = mg_find(sv,'U');
  mg->mg_virtual = (MGVTBL *) malloc(sizeof(MGVTBL));
  mg->mg_virtual->svt_get = (SwigMagicFuncHack) get;
  mg->mg_virtual->svt_set = (SwigMagicFuncHack) set;
  mg->mg_virtual->svt_len = 0;
  mg->mg_virtual->svt_clear = 0;
  mg->mg_virtual->svt_free = 0;
}


static swig_module_info *
SWIG_Perl_GetModule() {
  static void *type_pointer = (void *)0;
  SV *pointer;

  /* first check if pointer already created */
  if (!type_pointer) {
    pointer = get_sv("swig_runtime_data::type_pointer" SWIG_RUNTIME_VERSION SWIG_TYPE_TABLE_NAME, FALSE);
    if (pointer && SvOK(pointer)) {
      type_pointer = INT2PTR(swig_type_info **, SvIV(pointer));
    }
  }

  return (swig_module_info *) type_pointer;
}

static void
SWIG_Perl_SetModule(swig_module_info *module) {
  SV *pointer;

  /* create a new pointer */
  pointer = get_sv("swig_runtime_data::type_pointer" SWIG_RUNTIME_VERSION SWIG_TYPE_TABLE_NAME, TRUE);
  sv_setiv(pointer, PTR2IV(module));
}


#ifdef do_open
  #undef do_open
#endif
#ifdef do_close
  #undef do_close
#endif
#ifdef scalar
  #undef scalar
#endif
#ifdef list
  #undef list
#endif
#ifdef apply
  #undef apply
#endif
#ifdef convert
  #undef convert
#endif
#ifdef Error
  #undef Error
#endif
#ifdef form
  #undef form
#endif
#ifdef vform
  #undef vform
#endif
#ifdef LABEL
  #undef LABEL
#endif
#ifdef METHOD
  #undef METHOD
#endif
#ifdef Move
  #undef Move
#endif
#ifdef yylex
  #undef yylex
#endif
#ifdef yyparse
  #undef yyparse
#endif
#ifdef yyerror
  #undef yyerror
#endif
#ifdef invert
  #undef invert
#endif
#ifdef ref
  #undef ref
#endif
#ifdef ENTER
  #undef ENTER
#endif
#ifdef read
  #undef read
#endif
#ifdef write
  #undef write
#endif
#ifdef eof
  #undef eof
#endif



/* -------- TYPES TABLE (BEGIN) -------- */

#define SWIGTYPE_p_apr_array_header_t swig_types[0]
#define SWIGTYPE_p_apr_file_t swig_types[1]
#define SWIGTYPE_p_apr_hash_t swig_types[2]
#define SWIGTYPE_p_apr_int32_t swig_types[3]
#define SWIGTYPE_p_apr_int64_t swig_types[4]
#define SWIGTYPE_p_apr_pool_t swig_types[5]
#define SWIGTYPE_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void swig_types[6]
#define SWIGTYPE_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[7]
#define SWIGTYPE_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[8]
#define SWIGTYPE_p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t swig_types[9]
#define SWIGTYPE_p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[10]
#define SWIGTYPE_p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[11]
#define SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t swig_types[12]
#define SWIGTYPE_p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t swig_types[13]
#define SWIGTYPE_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[14]
#define SWIGTYPE_p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[15]
#define SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[16]
#define SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[17]
#define SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[18]
#define SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[19]
#define SWIGTYPE_p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[20]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[21]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[22]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t swig_types[23]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t swig_types[24]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t swig_types[25]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[26]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t swig_types[27]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t swig_types[28]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t swig_types[29]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t swig_types[30]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t swig_types[31]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t swig_types[32]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[33]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[34]
#define SWIGTYPE_p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t swig_types[35]
#define SWIGTYPE_p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t swig_types[36]
#define SWIGTYPE_p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t swig_types[37]
#define SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t swig_types[38]
#define SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t swig_types[39]
#define SWIGTYPE_p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t swig_types[40]
#define SWIGTYPE_p_f_void__p_svn_version_t swig_types[41]
#define SWIGTYPE_p_int swig_types[42]
#define SWIGTYPE_p_long swig_types[43]
#define SWIGTYPE_p_p_apr_file_t swig_types[44]
#define SWIGTYPE_p_p_apr_hash_t swig_types[45]
#define SWIGTYPE_p_p_char swig_types[46]
#define SWIGTYPE_p_p_svn_delta_editor_t swig_types[47]
#define SWIGTYPE_p_p_svn_dirent_t swig_types[48]
#define SWIGTYPE_p_p_svn_lock_t swig_types[49]
#define SWIGTYPE_p_p_svn_ra_callbacks2_t swig_types[50]
#define SWIGTYPE_p_p_svn_ra_plugin_t swig_types[51]
#define SWIGTYPE_p_p_svn_ra_reporter2_t swig_types[52]
#define SWIGTYPE_p_p_svn_ra_reporter_t swig_types[53]
#define SWIGTYPE_p_p_svn_ra_session_t swig_types[54]
#define SWIGTYPE_p_p_svn_string_t swig_types[55]
#define SWIGTYPE_p_p_svn_stringbuf_t swig_types[56]
#define SWIGTYPE_p_p_void swig_types[57]
#define SWIGTYPE_p_svn_auth_baton_t swig_types[58]
#define SWIGTYPE_p_svn_auth_cred_simple_t swig_types[59]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_pw_t swig_types[60]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_t swig_types[61]
#define SWIGTYPE_p_svn_auth_cred_ssl_server_trust_t swig_types[62]
#define SWIGTYPE_p_svn_auth_cred_username_t swig_types[63]
#define SWIGTYPE_p_svn_auth_iterstate_t swig_types[64]
#define SWIGTYPE_p_svn_auth_provider_object_t swig_types[65]
#define SWIGTYPE_p_svn_auth_provider_t swig_types[66]
#define SWIGTYPE_p_svn_auth_ssl_server_cert_info_t swig_types[67]
#define SWIGTYPE_p_svn_commit_info_t swig_types[68]
#define SWIGTYPE_p_svn_config_t swig_types[69]
#define SWIGTYPE_p_svn_delta_editor_t swig_types[70]
#define SWIGTYPE_p_svn_diff_datasource_e swig_types[71]
#define SWIGTYPE_p_svn_diff_file_ignore_space_t swig_types[72]
#define SWIGTYPE_p_svn_diff_file_options_t swig_types[73]
#define SWIGTYPE_p_svn_diff_fns_t swig_types[74]
#define SWIGTYPE_p_svn_diff_output_fns_t swig_types[75]
#define SWIGTYPE_p_svn_diff_t swig_types[76]
#define SWIGTYPE_p_svn_dirent_t swig_types[77]
#define SWIGTYPE_p_svn_errno_t swig_types[78]
#define SWIGTYPE_p_svn_error_t swig_types[79]
#define SWIGTYPE_p_svn_io_dirent_t swig_types[80]
#define SWIGTYPE_p_svn_io_file_del_t swig_types[81]
#define SWIGTYPE_p_svn_lock_t swig_types[82]
#define SWIGTYPE_p_svn_log_changed_path_t swig_types[83]
#define SWIGTYPE_p_svn_node_kind_t swig_types[84]
#define SWIGTYPE_p_svn_opt_revision_t swig_types[85]
#define SWIGTYPE_p_svn_opt_revision_value_t swig_types[86]
#define SWIGTYPE_p_svn_opt_subcommand_desc2_t swig_types[87]
#define SWIGTYPE_p_svn_opt_subcommand_desc_t swig_types[88]
#define SWIGTYPE_p_svn_prop_kind swig_types[89]
#define SWIGTYPE_p_svn_ra_callbacks2_t swig_types[90]
#define SWIGTYPE_p_svn_ra_callbacks_t swig_types[91]
#define SWIGTYPE_p_svn_ra_plugin_t swig_types[92]
#define SWIGTYPE_p_svn_ra_reporter2_t swig_types[93]
#define SWIGTYPE_p_svn_ra_reporter_t swig_types[94]
#define SWIGTYPE_p_svn_ra_session_t swig_types[95]
#define SWIGTYPE_p_svn_stream_t swig_types[96]
#define SWIGTYPE_p_svn_string_t swig_types[97]
#define SWIGTYPE_p_svn_stringbuf_t swig_types[98]
#define SWIGTYPE_p_svn_txdelta_op_t swig_types[99]
#define SWIGTYPE_p_svn_txdelta_stream_t swig_types[100]
#define SWIGTYPE_p_svn_txdelta_window_t swig_types[101]
#define SWIGTYPE_p_svn_version_checklist_t swig_types[102]
#define SWIGTYPE_p_svn_version_t swig_types[103]
#define SWIGTYPE_p_void swig_types[104]
static swig_type_info *swig_types[105];
static swig_module_info swig_module = {swig_types, 105, 0, 0, 0, 0};
#define SWIG_TypeQuery(name) SWIG_TypeQueryModule(&swig_module, &swig_module, name)
#define SWIG_MangledTypeQuery(name) SWIG_MangledTypeQueryModule(&swig_module, &swig_module, name)

/* -------- TYPES TABLE (END) -------- */

#define SWIG_init    boot_SVN___Ra

#define SWIG_name   "SVN::_Ra::boot_SVN___Ra"
#define SWIG_prefix "SVN::_Ra::"

#ifdef __cplusplus
extern "C"
#endif
#ifndef PERL_OBJECT
#ifndef MULTIPLICITY
SWIGEXPORT void SWIG_init (CV* cv);
#else
SWIGEXPORT void SWIG_init (pTHXo_ CV* cv);
#endif
#else
SWIGEXPORT void SWIG_init (CV *cv, CPerlObj *);
#endif


#include "svn_time.h"
#include "svn_pools.h"


#ifdef SWIGPYTHON
#include "swigutil_py.h"
#endif

#ifdef SWIGPERL
#include "swigutil_pl.h"
#endif

#ifdef SWIGRUBY
#include "swigutil_rb.h"
#endif


#include "svn_ra.h"


static svn_error_t *svn_ra_reporter2_invoke_set_path(
  svn_ra_reporter2_t *_obj, void *report_baton, const char *path, svn_revnum_t revision, svn_boolean_t start_empty, const char *lock_token, apr_pool_t *pool) {
  return _obj->set_path(report_baton, path, revision, start_empty, lock_token, pool);
}

static svn_error_t *svn_ra_reporter2_invoke_delete_path(
  svn_ra_reporter2_t *_obj, void *report_baton, const char *path, apr_pool_t *pool) {
  return _obj->delete_path(report_baton, path, pool);
}

static svn_error_t *svn_ra_reporter2_invoke_link_path(
  svn_ra_reporter2_t *_obj, void *report_baton, const char *path, const char *url, svn_revnum_t revision, svn_boolean_t start_empty, const char *lock_token, apr_pool_t *pool) {
  return _obj->link_path(report_baton, path, url, revision, start_empty, lock_token, pool);
}

static svn_error_t *svn_ra_reporter2_invoke_finish_report(
  svn_ra_reporter2_t *_obj, void *report_baton, apr_pool_t *pool) {
  return _obj->finish_report(report_baton, pool);
}

static svn_error_t *svn_ra_reporter2_invoke_abort_report(
  svn_ra_reporter2_t *_obj, void *report_baton, apr_pool_t *pool) {
  return _obj->abort_report(report_baton, pool);
}

static svn_error_t *svn_ra_reporter_invoke_set_path(
  svn_ra_reporter_t *_obj, void *report_baton, const char *path, svn_revnum_t revision, svn_boolean_t start_empty, apr_pool_t *pool) {
  return _obj->set_path(report_baton, path, revision, start_empty, pool);
}

static svn_error_t *svn_ra_reporter_invoke_delete_path(
  svn_ra_reporter_t *_obj, void *report_baton, const char *path, apr_pool_t *pool) {
  return _obj->delete_path(report_baton, path, pool);
}

static svn_error_t *svn_ra_reporter_invoke_link_path(
  svn_ra_reporter_t *_obj, void *report_baton, const char *path, const char *url, svn_revnum_t revision, svn_boolean_t start_empty, apr_pool_t *pool) {
  return _obj->link_path(report_baton, path, url, revision, start_empty, pool);
}

static svn_error_t *svn_ra_reporter_invoke_finish_report(
  svn_ra_reporter_t *_obj, void *report_baton, apr_pool_t *pool) {
  return _obj->finish_report(report_baton, pool);
}

static svn_error_t *svn_ra_reporter_invoke_abort_report(
  svn_ra_reporter_t *_obj, void *report_baton, apr_pool_t *pool) {
  return _obj->abort_report(report_baton, pool);
}

static svn_error_t *svn_ra_callbacks2_invoke_open_tmp_file(
  svn_ra_callbacks2_t *_obj, apr_file_t **fp, void *callback_baton, apr_pool_t *pool) {
  return _obj->open_tmp_file(fp, callback_baton, pool);
}

static svn_error_t *svn_ra_callbacks_invoke_open_tmp_file(
  svn_ra_callbacks_t *_obj, apr_file_t **fp, void *callback_baton, apr_pool_t *pool) {
  return _obj->open_tmp_file(fp, callback_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_open(
  svn_ra_plugin_t *_obj, void **session_baton, const char *repos_URL, const svn_ra_callbacks_t *callbacks, void *callback_baton, apr_hash_t *config, apr_pool_t *pool) {
  return _obj->open(session_baton, repos_URL, callbacks, callback_baton, config, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_latest_revnum(
  svn_ra_plugin_t *_obj, void *session_baton, svn_revnum_t *latest_revnum, apr_pool_t *pool) {
  return _obj->get_latest_revnum(session_baton, latest_revnum, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_dated_revision(
  svn_ra_plugin_t *_obj, void *session_baton, svn_revnum_t *revision, apr_time_t tm, apr_pool_t *pool) {
  return _obj->get_dated_revision(session_baton, revision, tm, pool);
}

static svn_error_t *svn_ra_plugin_invoke_change_rev_prop(
  svn_ra_plugin_t *_obj, void *session_baton, svn_revnum_t rev, const char *name, const svn_string_t *value, apr_pool_t *pool) {
  return _obj->change_rev_prop(session_baton, rev, name, value, pool);
}

static svn_error_t *svn_ra_plugin_invoke_rev_proplist(
  svn_ra_plugin_t *_obj, void *session_baton, svn_revnum_t rev, apr_hash_t **props, apr_pool_t *pool) {
  return _obj->rev_proplist(session_baton, rev, props, pool);
}

static svn_error_t *svn_ra_plugin_invoke_rev_prop(
  svn_ra_plugin_t *_obj, void *session_baton, svn_revnum_t rev, const char *name, svn_string_t **value, apr_pool_t *pool) {
  return _obj->rev_prop(session_baton, rev, name, value, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_commit_editor(
  svn_ra_plugin_t *_obj, void *session_baton, const svn_delta_editor_t **editor, void **edit_baton, const char *log_msg, svn_commit_callback_t callback, void *callback_baton, apr_pool_t *pool) {
  return _obj->get_commit_editor(session_baton, editor, edit_baton, log_msg, callback, callback_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_file(
  svn_ra_plugin_t *_obj, void *session_baton, const char *path, svn_revnum_t revision, svn_stream_t *stream, svn_revnum_t *fetched_rev, apr_hash_t **props, apr_pool_t *pool) {
  return _obj->get_file(session_baton, path, revision, stream, fetched_rev, props, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_dir(
  svn_ra_plugin_t *_obj, void *session_baton, const char *path, svn_revnum_t revision, apr_hash_t **dirents, svn_revnum_t *fetched_rev, apr_hash_t **props, apr_pool_t *pool) {
  return _obj->get_dir(session_baton, path, revision, dirents, fetched_rev, props, pool);
}

static svn_error_t *svn_ra_plugin_invoke_do_update(
  svn_ra_plugin_t *_obj, void *session_baton, const svn_ra_reporter_t **reporter, void **report_baton, svn_revnum_t revision_to_update_to, const char *update_target, svn_boolean_t recurse, const svn_delta_editor_t *update_editor, void *update_baton, apr_pool_t *pool) {
  return _obj->do_update(session_baton, reporter, report_baton, revision_to_update_to, update_target, recurse, update_editor, update_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_do_switch(
  svn_ra_plugin_t *_obj, void *session_baton, const svn_ra_reporter_t **reporter, void **report_baton, svn_revnum_t revision_to_switch_to, const char *switch_target, svn_boolean_t recurse, const char *switch_url, const svn_delta_editor_t *switch_editor, void *switch_baton, apr_pool_t *pool) {
  return _obj->do_switch(session_baton, reporter, report_baton, revision_to_switch_to, switch_target, recurse, switch_url, switch_editor, switch_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_do_status(
  svn_ra_plugin_t *_obj, void *session_baton, const svn_ra_reporter_t **reporter, void **report_baton, const char *status_target, svn_revnum_t revision, svn_boolean_t recurse, const svn_delta_editor_t *status_editor, void *status_baton, apr_pool_t *pool) {
  return _obj->do_status(session_baton, reporter, report_baton, status_target, revision, recurse, status_editor, status_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_do_diff(
  svn_ra_plugin_t *_obj, void *session_baton, const svn_ra_reporter_t **reporter, void **report_baton, svn_revnum_t revision, const char *diff_target, svn_boolean_t recurse, svn_boolean_t ignore_ancestry, const char *versus_url, const svn_delta_editor_t *diff_editor, void *diff_baton, apr_pool_t *pool) {
  return _obj->do_diff(session_baton, reporter, report_baton, revision, diff_target, recurse, ignore_ancestry, versus_url, diff_editor, diff_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_log(
  svn_ra_plugin_t *_obj, void *session_baton, const apr_array_header_t *paths, svn_revnum_t start, svn_revnum_t end, svn_boolean_t discover_changed_paths, svn_boolean_t strict_node_history, svn_log_message_receiver_t receiver, void *receiver_baton, apr_pool_t *pool) {
  return _obj->get_log(session_baton, paths, start, end, discover_changed_paths, strict_node_history, receiver, receiver_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_check_path(
  svn_ra_plugin_t *_obj, void *session_baton, const char *path, svn_revnum_t revision, svn_node_kind_t *kind, apr_pool_t *pool) {
  return _obj->check_path(session_baton, path, revision, kind, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_uuid(
  svn_ra_plugin_t *_obj, void *session_baton, const char **uuid, apr_pool_t *pool) {
  return _obj->get_uuid(session_baton, uuid, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_repos_root(
  svn_ra_plugin_t *_obj, void *session_baton, const char **url, apr_pool_t *pool) {
  return _obj->get_repos_root(session_baton, url, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_locations(
  svn_ra_plugin_t *_obj, void *session_baton, apr_hash_t **locations, const char *path, svn_revnum_t peg_revision, apr_array_header_t *location_revisions, apr_pool_t *pool) {
  return _obj->get_locations(session_baton, locations, path, peg_revision, location_revisions, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_file_revs(
  svn_ra_plugin_t *_obj, void *session_baton, const char *path, svn_revnum_t start, svn_revnum_t end, svn_ra_file_rev_handler_t handler, void *handler_baton, apr_pool_t *pool) {
  return _obj->get_file_revs(session_baton, path, start, end, handler, handler_baton, pool);
}


#ifdef PERL_OBJECT
#define MAGIC_CLASS _wrap_SVN::_Ra_var::
class _wrap_SVN::_Ra_var : public CPerlObj {
public:
#else
#define MAGIC_CLASS
#endif
SWIGCLASS_STATIC int swig_magic_readonly(pTHX_ SV *sv, MAGIC *mg) {
    MAGIC_PPERL
    sv = sv; mg = mg;
    croak("Value is read-only.");
    return 0;
}


#ifdef PERL_OBJECT
};
#endif

#ifdef __cplusplus
extern "C" {
#endif
XS(_wrap_svn_ra_version) {
    {
        svn_version_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 0) || (items > 0)) {
            SWIG_croak("Usage: svn_ra_version();");
        }
        {
            result = (svn_version_t *)svn_ra_version();
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_version_t, SWIG_SHADOW|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_t_set_path_set) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_reporter2_t_set_path_set(self,set_path);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_t_set_path_set. Expected _p_svn_ra_reporter2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter2_t_set_path_set. Expected _p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->set_path = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_t_set_path_get) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_reporter2_t_set_path_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_t_set_path_get. Expected _p_svn_ra_reporter2_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)) ((arg1)->set_path);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_t_delete_path_set) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_reporter2_t_delete_path_set(self,delete_path);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_t_delete_path_set. Expected _p_svn_ra_reporter2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter2_t_delete_path_set. Expected _p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->delete_path = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_t_delete_path_get) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_reporter2_t_delete_path_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_t_delete_path_get. Expected _p_svn_ra_reporter2_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,apr_pool_t *)) ((arg1)->delete_path);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_t_link_path_set) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_reporter2_t_link_path_set(self,link_path);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_t_link_path_set. Expected _p_svn_ra_reporter2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter2_t_link_path_set. Expected _p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->link_path = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_t_link_path_get) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_reporter2_t_link_path_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_t_link_path_get. Expected _p_svn_ra_reporter2_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)) ((arg1)->link_path);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_t_finish_report_set) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        svn_error_t *(*arg2)(void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_reporter2_t_finish_report_set(self,finish_report);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_t_finish_report_set. Expected _p_svn_ra_reporter2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter2_t_finish_report_set. Expected _p_f_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->finish_report = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_t_finish_report_get) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        svn_error_t *(*result)(void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_reporter2_t_finish_report_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_t_finish_report_get. Expected _p_svn_ra_reporter2_t");
            }
        }
        result = (svn_error_t *(*)(void *,apr_pool_t *)) ((arg1)->finish_report);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_t_abort_report_set) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        svn_error_t *(*arg2)(void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_reporter2_t_abort_report_set(self,abort_report);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_t_abort_report_set. Expected _p_svn_ra_reporter2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter2_t_abort_report_set. Expected _p_f_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->abort_report = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_t_abort_report_get) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        svn_error_t *(*result)(void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_reporter2_t_abort_report_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_t_abort_report_get. Expected _p_svn_ra_reporter2_t");
            }
        }
        result = (svn_error_t *(*)(void *,apr_pool_t *)) ((arg1)->abort_report);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_new_svn_ra_reporter2_t) {
    {
        svn_ra_reporter2_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 0) || (items > 0)) {
            SWIG_croak("Usage: new_svn_ra_reporter2_t();");
        }
        {
            result = (svn_ra_reporter2_t *)(svn_ra_reporter2_t *) calloc(1, sizeof(svn_ra_reporter2_t));
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_ra_reporter2_t, SWIG_SHADOW|SWIG_OWNER);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_delete_svn_ra_reporter2_t) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: delete_svn_ra_reporter2_t(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of delete_svn_ra_reporter2_t. Expected _p_svn_ra_reporter2_t");
            }
        }
        {
            free((char *) arg1);
            
            
            
            
        }
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_t_set_path_set) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_reporter_t_set_path_set(self,set_path);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_t_set_path_set. Expected _p_svn_ra_reporter_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter_t_set_path_set. Expected _p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->set_path = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_t_set_path_get) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_reporter_t_set_path_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_t_set_path_get. Expected _p_svn_ra_reporter_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)) ((arg1)->set_path);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_t_delete_path_set) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_reporter_t_delete_path_set(self,delete_path);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_t_delete_path_set. Expected _p_svn_ra_reporter_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter_t_delete_path_set. Expected _p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->delete_path = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_t_delete_path_get) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_reporter_t_delete_path_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_t_delete_path_get. Expected _p_svn_ra_reporter_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,apr_pool_t *)) ((arg1)->delete_path);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_t_link_path_set) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_reporter_t_link_path_set(self,link_path);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_t_link_path_set. Expected _p_svn_ra_reporter_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter_t_link_path_set. Expected _p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->link_path = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_t_link_path_get) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_reporter_t_link_path_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_t_link_path_get. Expected _p_svn_ra_reporter_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)) ((arg1)->link_path);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_t_finish_report_set) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        svn_error_t *(*arg2)(void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_reporter_t_finish_report_set(self,finish_report);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_t_finish_report_set. Expected _p_svn_ra_reporter_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter_t_finish_report_set. Expected _p_f_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->finish_report = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_t_finish_report_get) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        svn_error_t *(*result)(void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_reporter_t_finish_report_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_t_finish_report_get. Expected _p_svn_ra_reporter_t");
            }
        }
        result = (svn_error_t *(*)(void *,apr_pool_t *)) ((arg1)->finish_report);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_t_abort_report_set) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        svn_error_t *(*arg2)(void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_reporter_t_abort_report_set(self,abort_report);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_t_abort_report_set. Expected _p_svn_ra_reporter_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter_t_abort_report_set. Expected _p_f_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->abort_report = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_t_abort_report_get) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        svn_error_t *(*result)(void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_reporter_t_abort_report_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_t_abort_report_get. Expected _p_svn_ra_reporter_t");
            }
        }
        result = (svn_error_t *(*)(void *,apr_pool_t *)) ((arg1)->abort_report);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_new_svn_ra_reporter_t) {
    {
        svn_ra_reporter_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 0) || (items > 0)) {
            SWIG_croak("Usage: new_svn_ra_reporter_t();");
        }
        {
            result = (svn_ra_reporter_t *)(svn_ra_reporter_t *) calloc(1, sizeof(svn_ra_reporter_t));
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_ra_reporter_t, SWIG_SHADOW|SWIG_OWNER);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_delete_svn_ra_reporter_t) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: delete_svn_ra_reporter_t(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of delete_svn_ra_reporter_t. Expected _p_svn_ra_reporter_t");
            }
        }
        {
            free((char *) arg1);
            
            
            
            
        }
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_open_tmp_file_set) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_error_t *(*arg2)(apr_file_t **,void *,apr_pool_t *) = (svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_open_tmp_file_set(self,open_tmp_file);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_open_tmp_file_set. Expected _p_svn_ra_callbacks2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks2_t_open_tmp_file_set. Expected _p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->open_tmp_file = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_open_tmp_file_get) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_error_t *(*result)(apr_file_t **,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_open_tmp_file_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_open_tmp_file_get. Expected _p_svn_ra_callbacks2_t");
            }
        }
        result = (svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)) ((arg1)->open_tmp_file);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_auth_baton_set) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_auth_baton_t *arg2 = (svn_auth_baton_t *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_auth_baton_set(self,auth_baton);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_auth_baton_set. Expected _p_svn_ra_callbacks2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_svn_auth_baton_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks2_t_auth_baton_set. Expected _p_svn_auth_baton_t");
            }
        }
        if (arg1) (arg1)->auth_baton = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_auth_baton_get) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_auth_baton_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_auth_baton_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_auth_baton_get. Expected _p_svn_ra_callbacks2_t");
            }
        }
        result = (svn_auth_baton_t *) ((arg1)->auth_baton);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_auth_baton_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_get_wc_prop_set) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_ra_get_wc_prop_func_t arg2 = (svn_ra_get_wc_prop_func_t) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_get_wc_prop_set(self,get_wc_prop);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_get_wc_prop_set. Expected _p_svn_ra_callbacks2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks2_t_get_wc_prop_set. Expected _p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_wc_prop = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_get_wc_prop_get) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_ra_get_wc_prop_func_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_get_wc_prop_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_get_wc_prop_get. Expected _p_svn_ra_callbacks2_t");
            }
        }
        result = (svn_ra_get_wc_prop_func_t) ((arg1)->get_wc_prop);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_set_wc_prop_set) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_ra_set_wc_prop_func_t arg2 = (svn_ra_set_wc_prop_func_t) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_set_wc_prop_set(self,set_wc_prop);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_set_wc_prop_set. Expected _p_svn_ra_callbacks2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks2_t_set_wc_prop_set. Expected _p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->set_wc_prop = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_set_wc_prop_get) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_ra_set_wc_prop_func_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_set_wc_prop_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_set_wc_prop_get. Expected _p_svn_ra_callbacks2_t");
            }
        }
        result = (svn_ra_set_wc_prop_func_t) ((arg1)->set_wc_prop);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_push_wc_prop_set) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_ra_push_wc_prop_func_t arg2 = (svn_ra_push_wc_prop_func_t) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_push_wc_prop_set(self,push_wc_prop);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_push_wc_prop_set. Expected _p_svn_ra_callbacks2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks2_t_push_wc_prop_set. Expected _p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->push_wc_prop = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_push_wc_prop_get) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_ra_push_wc_prop_func_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_push_wc_prop_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_push_wc_prop_get. Expected _p_svn_ra_callbacks2_t");
            }
        }
        result = (svn_ra_push_wc_prop_func_t) ((arg1)->push_wc_prop);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_invalidate_wc_props_set) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_ra_invalidate_wc_props_func_t arg2 = (svn_ra_invalidate_wc_props_func_t) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_invalidate_wc_props_set(self,invalidate_wc_props);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_invalidate_wc_props_set. Expected _p_svn_ra_callbacks2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks2_t_invalidate_wc_props_set. Expected _p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->invalidate_wc_props = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_invalidate_wc_props_get) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_ra_invalidate_wc_props_func_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_invalidate_wc_props_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_invalidate_wc_props_get. Expected _p_svn_ra_callbacks2_t");
            }
        }
        result = (svn_ra_invalidate_wc_props_func_t) ((arg1)->invalidate_wc_props);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_progress_func_set) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_ra_progress_notify_func_t arg2 = (svn_ra_progress_notify_func_t) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_progress_func_set(self,progress_func);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_progress_func_set. Expected _p_svn_ra_callbacks2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks2_t_progress_func_set. Expected _p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void");
            }
        }
        if (arg1) (arg1)->progress_func = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_progress_func_get) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        svn_ra_progress_notify_func_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_progress_func_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_progress_func_get. Expected _p_svn_ra_callbacks2_t");
            }
        }
        result = (svn_ra_progress_notify_func_t) ((arg1)->progress_func);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_progress_baton_set) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_progress_baton_set(self,progress_baton);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_progress_baton_set. Expected _p_svn_ra_callbacks2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks2_t_progress_baton_set. Expected _p_void");
            }
        }
        if (arg1) (arg1)->progress_baton = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_t_progress_baton_get) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        void *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks2_t_progress_baton_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_t_progress_baton_get. Expected _p_svn_ra_callbacks2_t");
            }
        }
        result = (void *) ((arg1)->progress_baton);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_void, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_new_svn_ra_callbacks2_t) {
    {
        svn_ra_callbacks2_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 0) || (items > 0)) {
            SWIG_croak("Usage: new_svn_ra_callbacks2_t();");
        }
        {
            result = (svn_ra_callbacks2_t *)(svn_ra_callbacks2_t *) calloc(1, sizeof(svn_ra_callbacks2_t));
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_ra_callbacks2_t, SWIG_SHADOW|SWIG_OWNER);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_delete_svn_ra_callbacks2_t) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: delete_svn_ra_callbacks2_t(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of delete_svn_ra_callbacks2_t. Expected _p_svn_ra_callbacks2_t");
            }
        }
        {
            free((char *) arg1);
            
            
            
            
        }
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_open_tmp_file_set) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_error_t *(*arg2)(apr_file_t **,void *,apr_pool_t *) = (svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_open_tmp_file_set(self,open_tmp_file);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_open_tmp_file_set. Expected _p_svn_ra_callbacks_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks_t_open_tmp_file_set. Expected _p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->open_tmp_file = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_open_tmp_file_get) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_error_t *(*result)(apr_file_t **,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_open_tmp_file_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_open_tmp_file_get. Expected _p_svn_ra_callbacks_t");
            }
        }
        result = (svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)) ((arg1)->open_tmp_file);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_auth_baton_set) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_auth_baton_t *arg2 = (svn_auth_baton_t *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_auth_baton_set(self,auth_baton);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_auth_baton_set. Expected _p_svn_ra_callbacks_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_svn_auth_baton_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks_t_auth_baton_set. Expected _p_svn_auth_baton_t");
            }
        }
        if (arg1) (arg1)->auth_baton = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_auth_baton_get) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_auth_baton_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_auth_baton_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_auth_baton_get. Expected _p_svn_ra_callbacks_t");
            }
        }
        result = (svn_auth_baton_t *) ((arg1)->auth_baton);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_auth_baton_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_get_wc_prop_set) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_ra_get_wc_prop_func_t arg2 = (svn_ra_get_wc_prop_func_t) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_get_wc_prop_set(self,get_wc_prop);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_get_wc_prop_set. Expected _p_svn_ra_callbacks_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks_t_get_wc_prop_set. Expected _p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_wc_prop = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_get_wc_prop_get) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_ra_get_wc_prop_func_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_get_wc_prop_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_get_wc_prop_get. Expected _p_svn_ra_callbacks_t");
            }
        }
        result = (svn_ra_get_wc_prop_func_t) ((arg1)->get_wc_prop);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_set_wc_prop_set) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_ra_set_wc_prop_func_t arg2 = (svn_ra_set_wc_prop_func_t) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_set_wc_prop_set(self,set_wc_prop);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_set_wc_prop_set. Expected _p_svn_ra_callbacks_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks_t_set_wc_prop_set. Expected _p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->set_wc_prop = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_set_wc_prop_get) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_ra_set_wc_prop_func_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_set_wc_prop_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_set_wc_prop_get. Expected _p_svn_ra_callbacks_t");
            }
        }
        result = (svn_ra_set_wc_prop_func_t) ((arg1)->set_wc_prop);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_push_wc_prop_set) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_ra_push_wc_prop_func_t arg2 = (svn_ra_push_wc_prop_func_t) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_push_wc_prop_set(self,push_wc_prop);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_push_wc_prop_set. Expected _p_svn_ra_callbacks_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks_t_push_wc_prop_set. Expected _p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->push_wc_prop = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_push_wc_prop_get) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_ra_push_wc_prop_func_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_push_wc_prop_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_push_wc_prop_get. Expected _p_svn_ra_callbacks_t");
            }
        }
        result = (svn_ra_push_wc_prop_func_t) ((arg1)->push_wc_prop);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_invalidate_wc_props_set) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_ra_invalidate_wc_props_func_t arg2 = (svn_ra_invalidate_wc_props_func_t) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_invalidate_wc_props_set(self,invalidate_wc_props);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_invalidate_wc_props_set. Expected _p_svn_ra_callbacks_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_callbacks_t_invalidate_wc_props_set. Expected _p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->invalidate_wc_props = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_t_invalidate_wc_props_get) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        svn_ra_invalidate_wc_props_func_t result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_callbacks_t_invalidate_wc_props_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_t_invalidate_wc_props_get. Expected _p_svn_ra_callbacks_t");
            }
        }
        result = (svn_ra_invalidate_wc_props_func_t) ((arg1)->invalidate_wc_props);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_new_svn_ra_callbacks_t) {
    {
        svn_ra_callbacks_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 0) || (items > 0)) {
            SWIG_croak("Usage: new_svn_ra_callbacks_t();");
        }
        {
            result = (svn_ra_callbacks_t *)(svn_ra_callbacks_t *) calloc(1, sizeof(svn_ra_callbacks_t));
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_ra_callbacks_t, SWIG_SHADOW|SWIG_OWNER);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_delete_svn_ra_callbacks_t) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: delete_svn_ra_callbacks_t(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of delete_svn_ra_callbacks_t. Expected _p_svn_ra_callbacks_t");
            }
        }
        {
            free((char *) arg1);
            
            
            
            
        }
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_initialize) {
    {
        apr_pool_t *arg1 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg1 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 0) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_initialize(pool);");
        }
        if (items > 0) {
            
        }
        {
            result = (svn_error_t *)svn_ra_initialize(arg1);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_create_callbacks) {
    {
        svn_ra_callbacks2_t **arg1 = (svn_ra_callbacks2_t **) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_create_callbacks(callbacks,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_create_callbacks. Expected _p_p_svn_ra_callbacks2_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (svn_error_t *)svn_ra_create_callbacks(arg1,arg2);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_open2) {
    {
        svn_ra_session_t **arg1 = (svn_ra_session_t **) 0 ;
        char *arg2 = (char *) 0 ;
        svn_ra_callbacks2_t *arg3 = (svn_ra_callbacks2_t *) 0 ;
        void *arg4 = (void *) 0 ;
        apr_hash_t *arg5 = (apr_hash_t *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_ra_session_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_ra_session_t **)&temp1;
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_ra_open2(repos_URL,callbacks,callback_baton,config,pool);");
        }
        if (!SvOK((SV*) ST(0))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(0), PL_na);
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg3, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_ra_open2. Expected _p_svn_ra_callbacks2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg4, 0,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_ra_open2. Expected _p_void");
            }
        }
        {
            arg5 = svn_swig_pl_objs_to_hash_by_name (ST(3), "svn_config_t *",
            _global_pool);
        }
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_ra_open2(arg1,(char const *)arg2,(struct svn_ra_callbacks2_t const *)arg3,arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_ra_session_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_open) {
    {
        svn_ra_session_t **arg1 = (svn_ra_session_t **) 0 ;
        char *arg2 = (char *) 0 ;
        svn_ra_callbacks_t *arg3 = (svn_ra_callbacks_t *) 0 ;
        void *arg4 = (void *) 0 ;
        apr_hash_t *arg5 = (apr_hash_t *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_ra_session_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_ra_session_t **)&temp1;
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_ra_open(repos_URL,callbacks,callback_baton,config,pool);");
        }
        if (!SvOK((SV*) ST(0))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(0), PL_na);
        {
            svn_ra_make_callbacks(&arg3, &arg4, ST(1), _global_pool);
        }
        {
            arg5 = svn_swig_pl_objs_to_hash_by_name (ST(2), "svn_config_t *",
            _global_pool);
        }
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_ra_open(arg1,(char const *)arg2,(struct svn_ra_callbacks_t const *)arg3,arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_ra_session_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reparent) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        char *arg2 = (char *) 0 ;
        apr_pool_t *arg3 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg3 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_reparent(ra_session,url,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reparent. Expected _p_svn_ra_session_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_reparent(arg1,(char const *)arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_latest_revnum) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_revnum_t *arg2 = (svn_revnum_t *) 0 ;
        apr_pool_t *arg3 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        long temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg3 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg2 = &temp2;
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_get_latest_revnum(session,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_latest_revnum. Expected _p_svn_ra_session_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_latest_revnum(arg1,arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg2));
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_dated_revision) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_revnum_t *arg2 = (svn_revnum_t *) 0 ;
        apr_time_t arg3 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        long temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg2 = &temp2;
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_get_dated_revision(session,tm,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_dated_revision. Expected _p_svn_ra_session_t");
            }
        }
        arg3 = (apr_time_t) strtoll(SvPV(ST(1), PL_na), 0, 0);
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_dated_revision(arg1,arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg2));
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_change_rev_prop) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_revnum_t arg2 ;
        char *arg3 = (char *) 0 ;
        svn_string_t *arg4 = (svn_string_t *) 0 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_string_t value4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_ra_change_rev_prop(session,rev,name,value,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_change_rev_prop. Expected _p_svn_ra_session_t");
            }
        }
        arg2 = (svn_revnum_t) SvIV(ST(1));
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        {
            if (SvOK(ST(3))) {
                value4.data = SvPV(ST(3), value4.len);
                arg4 = &value4;
            }
            else {
                arg4 = NULL;
            }
        }
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_ra_change_rev_prop(arg1,arg2,(char const *)arg3,(struct svn_string_t const *)arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_rev_proplist) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_revnum_t arg2 ;
        apr_hash_t **arg3 = (apr_hash_t **) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        apr_hash_t *temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg3 = &temp3;
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_rev_proplist(session,rev,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_rev_proplist. Expected _p_svn_ra_session_t");
            }
        }
        arg2 = (svn_revnum_t) SvIV(ST(1));
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_rev_proplist(arg1,arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = svn_swig_pl_prophash_to_hash(*arg3);
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_rev_prop) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_revnum_t arg2 ;
        char *arg3 = (char *) 0 ;
        svn_string_t **arg4 = (svn_string_t **) 0 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_string_t *temp4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg4 = &temp4;
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_ra_rev_prop(session,rev,name,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_rev_prop. Expected _p_svn_ra_session_t");
            }
        }
        arg2 = (svn_revnum_t) SvIV(ST(1));
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_ra_rev_prop(arg1,arg2,(char const *)arg3,arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (*arg4) {
                ST(argvi) = sv_newmortal();
                sv_setpvn (ST(argvi), (*arg4)->data, (*arg4)->len);
            }
            else
            ST(argvi) = &PL_sv_undef;
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_commit_editor2) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_delta_editor_t **arg2 = (svn_delta_editor_t **) 0 ;
        void **arg3 = (void **) 0 ;
        char *arg4 = (char *) 0 ;
        svn_commit_callback2_t arg5 = (svn_commit_callback2_t) 0 ;
        void *arg6 = (void *) 0 ;
        apr_hash_t *arg7 = (apr_hash_t *) 0 ;
        svn_boolean_t arg8 ;
        apr_pool_t *arg9 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_delta_editor_t const *temp2 ;
        void *temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg9 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (svn_delta_editor_t **)&temp2;
        }
        {
            arg3 = (void **)&temp3;
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_ra_get_commit_editor2(session,log_msg,callback,callback_baton,lock_tokens,keep_locks,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_commit_editor2. Expected _p_svn_ra_session_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(1), PL_na);
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg5, SWIGTYPE_p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 5 of svn_ra_get_commit_editor2. Expected _p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(3), (void **) &arg6, 0,0) < 0) {
                SWIG_croak("Type error in argument 6 of svn_ra_get_commit_editor2. Expected _p_void");
            }
        }
        {
            arg7 = svn_swig_pl_strings_to_hash (ST(4), _global_pool);
        }
        arg8 = (svn_boolean_t) SvIV(ST(5));
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_commit_editor2(arg1,(struct svn_delta_editor_t const **)arg2,arg3,(char const *)arg4,arg5,arg6,arg7,arg8,arg9);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_svn_delta_editor_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg3, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_commit_editor) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_delta_editor_t **arg2 = (svn_delta_editor_t **) 0 ;
        void **arg3 = (void **) 0 ;
        char *arg4 = (char *) 0 ;
        svn_commit_callback_t arg5 = (svn_commit_callback_t) 0 ;
        void *arg6 = (void *) 0 ;
        apr_hash_t *arg7 = (apr_hash_t *) 0 ;
        svn_boolean_t arg8 ;
        apr_pool_t *arg9 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_delta_editor_t const *temp2 ;
        void *temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg9 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (svn_delta_editor_t **)&temp2;
        }
        {
            arg3 = (void **)&temp3;
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_ra_get_commit_editor(session,log_msg,callback,callback_baton,lock_tokens,keep_locks,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_commit_editor. Expected _p_svn_ra_session_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(1), PL_na);
        {
            arg5 = svn_swig_pl_thunk_commit_callback;
            arg6 = (void *)ST(2);
            svn_swig_pl_hold_ref_in_pool (_global_pool, ST(2));
        }
        {
            arg7 = svn_swig_pl_strings_to_hash (ST(3), _global_pool);
        }
        arg8 = (svn_boolean_t) SvIV(ST(4));
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_commit_editor(arg1,(struct svn_delta_editor_t const **)arg2,arg3,(char const *)arg4,arg5,arg6,arg7,arg8,arg9);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_svn_delta_editor_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg3, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_file) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_revnum_t arg3 ;
        svn_stream_t *arg4 = (svn_stream_t *) 0 ;
        svn_revnum_t *arg5 = (svn_revnum_t *) 0 ;
        apr_hash_t **arg6 = (apr_hash_t **) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        long temp5 ;
        apr_hash_t *temp6 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg5 = &temp5;
        arg6 = &temp6;
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_ra_get_file(session,path,revision,stream,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_file. Expected _p_svn_ra_session_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        arg3 = (svn_revnum_t) SvIV(ST(2));
        {
            svn_swig_pl_make_stream (&arg4, ST(3));
        }
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_file(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg5));
            argvi++;
        }
        {
            ST(argvi) = svn_swig_pl_prophash_to_hash(*arg6);
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_dir2) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        apr_hash_t **arg2 = (apr_hash_t **) 0 ;
        svn_revnum_t *arg3 = (svn_revnum_t *) 0 ;
        apr_hash_t **arg4 = (apr_hash_t **) 0 ;
        char *arg5 = (char *) 0 ;
        svn_revnum_t arg6 ;
        apr_uint32_t arg7 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        apr_hash_t *temp2 ;
        long temp3 ;
        apr_hash_t *temp4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg2 = &temp2;
        arg3 = &temp3;
        arg4 = &temp4;
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_ra_get_dir2(session,path,revision,dirent_fields,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_dir2. Expected _p_svn_ra_session_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(1), PL_na);
        arg6 = (svn_revnum_t) SvIV(ST(2));
        arg7 = (apr_uint32_t) SvUV(ST(3));
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_dir2(arg1,arg2,arg3,arg4,(char const *)arg5,arg6,arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi++) = svn_swig_pl_convert_hash
            (*arg2, SWIGTYPE_p_svn_dirent_t);
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg3));
            argvi++;
        }
        {
            ST(argvi) = svn_swig_pl_prophash_to_hash(*arg4);
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_dir) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_revnum_t arg3 ;
        apr_hash_t **arg4 = (apr_hash_t **) 0 ;
        svn_revnum_t *arg5 = (svn_revnum_t *) 0 ;
        apr_hash_t **arg6 = (apr_hash_t **) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        apr_hash_t *temp4 ;
        long temp5 ;
        apr_hash_t *temp6 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg4 = &temp4;
        arg5 = &temp5;
        arg6 = &temp6;
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_ra_get_dir(session,path,revision,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_dir. Expected _p_svn_ra_session_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        arg3 = (svn_revnum_t) SvIV(ST(2));
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_dir(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi++) = svn_swig_pl_convert_hash
            (*arg4, SWIGTYPE_p_svn_dirent_t);
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg5));
            argvi++;
        }
        {
            ST(argvi) = svn_swig_pl_prophash_to_hash(*arg6);
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_do_update) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_ra_reporter2_t **arg2 = (svn_ra_reporter2_t **) 0 ;
        void **arg3 = (void **) 0 ;
        svn_revnum_t arg4 ;
        char *arg5 = (char *) 0 ;
        svn_boolean_t arg6 ;
        svn_delta_editor_t *arg7 = (svn_delta_editor_t *) 0 ;
        void *arg8 = (void *) 0 ;
        apr_pool_t *arg9 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_ra_reporter2_t const *temp2 ;
        void *temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg9 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (svn_ra_reporter2_t **)&temp2;
        }
        {
            arg3 = (void **)&temp3;
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_ra_do_update(session,revision_to_update_to,update_target,recurse,update_editor,update_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_do_update. Expected _p_svn_ra_session_t");
            }
        }
        arg4 = (svn_revnum_t) SvIV(ST(1));
        if (!SvOK((SV*) ST(2))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(2), PL_na);
        arg6 = (svn_boolean_t) SvIV(ST(3));
        {
            svn_delta_make_editor(&arg7, &arg8, ST(4), _global_pool);
        }
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_ra_do_update(arg1,(struct svn_ra_reporter2_t const **)arg2,arg3,arg4,(char const *)arg5,arg6,(struct svn_delta_editor_t const *)arg7,arg8,arg9);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_svn_ra_reporter2_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg3, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_do_switch) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_ra_reporter2_t **arg2 = (svn_ra_reporter2_t **) 0 ;
        void **arg3 = (void **) 0 ;
        svn_revnum_t arg4 ;
        char *arg5 = (char *) 0 ;
        svn_boolean_t arg6 ;
        char *arg7 = (char *) 0 ;
        svn_delta_editor_t *arg8 = (svn_delta_editor_t *) 0 ;
        void *arg9 = (void *) 0 ;
        apr_pool_t *arg10 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_ra_reporter2_t const *temp2 ;
        void *temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg10 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (svn_ra_reporter2_t **)&temp2;
        }
        {
            arg3 = (void **)&temp3;
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_ra_do_switch(session,revision_to_switch_to,switch_target,recurse,switch_url,switch_editor,switch_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_do_switch. Expected _p_svn_ra_session_t");
            }
        }
        arg4 = (svn_revnum_t) SvIV(ST(1));
        if (!SvOK((SV*) ST(2))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(2), PL_na);
        arg6 = (svn_boolean_t) SvIV(ST(3));
        if (!SvOK((SV*) ST(4))) arg7 = 0;
        else arg7 = (char *) SvPV(ST(4), PL_na);
        {
            svn_delta_make_editor(&arg8, &arg9, ST(5), _global_pool);
        }
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_ra_do_switch(arg1,(struct svn_ra_reporter2_t const **)arg2,arg3,arg4,(char const *)arg5,arg6,(char const *)arg7,(struct svn_delta_editor_t const *)arg8,arg9,arg10);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_svn_ra_reporter2_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg3, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_do_status) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_ra_reporter2_t **arg2 = (svn_ra_reporter2_t **) 0 ;
        void **arg3 = (void **) 0 ;
        char *arg4 = (char *) 0 ;
        svn_revnum_t arg5 ;
        svn_boolean_t arg6 ;
        svn_delta_editor_t *arg7 = (svn_delta_editor_t *) 0 ;
        void *arg8 = (void *) 0 ;
        apr_pool_t *arg9 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_ra_reporter2_t const *temp2 ;
        void *temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg9 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (svn_ra_reporter2_t **)&temp2;
        }
        {
            arg3 = (void **)&temp3;
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_ra_do_status(session,status_target,revision,recurse,status_editor,status_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_do_status. Expected _p_svn_ra_session_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(1), PL_na);
        arg5 = (svn_revnum_t) SvIV(ST(2));
        arg6 = (svn_boolean_t) SvIV(ST(3));
        {
            svn_delta_make_editor(&arg7, &arg8, ST(4), _global_pool);
        }
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_ra_do_status(arg1,(struct svn_ra_reporter2_t const **)arg2,arg3,(char const *)arg4,arg5,arg6,(struct svn_delta_editor_t const *)arg7,arg8,arg9);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_svn_ra_reporter2_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg3, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_do_diff2) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_ra_reporter2_t **arg2 = (svn_ra_reporter2_t **) 0 ;
        void **arg3 = (void **) 0 ;
        svn_revnum_t arg4 ;
        char *arg5 = (char *) 0 ;
        svn_boolean_t arg6 ;
        svn_boolean_t arg7 ;
        svn_boolean_t arg8 ;
        char *arg9 = (char *) 0 ;
        svn_delta_editor_t *arg10 = (svn_delta_editor_t *) 0 ;
        void *arg11 = (void *) 0 ;
        apr_pool_t *arg12 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_ra_reporter2_t const *temp2 ;
        void *temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg12 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (svn_ra_reporter2_t **)&temp2;
        }
        {
            arg3 = (void **)&temp3;
        }
        if ((items < 8) || (items > 9)) {
            SWIG_croak("Usage: svn_ra_do_diff2(session,revision,diff_target,recurse,ignore_ancestry,text_deltas,versus_url,diff_editor,diff_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_do_diff2. Expected _p_svn_ra_session_t");
            }
        }
        arg4 = (svn_revnum_t) SvIV(ST(1));
        if (!SvOK((SV*) ST(2))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(2), PL_na);
        arg6 = (svn_boolean_t) SvIV(ST(3));
        arg7 = (svn_boolean_t) SvIV(ST(4));
        arg8 = (svn_boolean_t) SvIV(ST(5));
        if (!SvOK((SV*) ST(6))) arg9 = 0;
        else arg9 = (char *) SvPV(ST(6), PL_na);
        {
            svn_delta_make_editor(&arg10, &arg11, ST(7), _global_pool);
        }
        if (items > 8) {
            
        }
        {
            result = (svn_error_t *)svn_ra_do_diff2(arg1,(struct svn_ra_reporter2_t const **)arg2,arg3,arg4,(char const *)arg5,arg6,arg7,arg8,(char const *)arg9,(struct svn_delta_editor_t const *)arg10,arg11,arg12);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_svn_ra_reporter2_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg3, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_do_diff) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_ra_reporter2_t **arg2 = (svn_ra_reporter2_t **) 0 ;
        void **arg3 = (void **) 0 ;
        svn_revnum_t arg4 ;
        char *arg5 = (char *) 0 ;
        svn_boolean_t arg6 ;
        svn_boolean_t arg7 ;
        char *arg8 = (char *) 0 ;
        svn_delta_editor_t *arg9 = (svn_delta_editor_t *) 0 ;
        void *arg10 = (void *) 0 ;
        apr_pool_t *arg11 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_ra_reporter2_t const *temp2 ;
        void *temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg11 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (svn_ra_reporter2_t **)&temp2;
        }
        {
            arg3 = (void **)&temp3;
        }
        if ((items < 7) || (items > 8)) {
            SWIG_croak("Usage: svn_ra_do_diff(session,revision,diff_target,recurse,ignore_ancestry,versus_url,diff_editor,diff_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_do_diff. Expected _p_svn_ra_session_t");
            }
        }
        arg4 = (svn_revnum_t) SvIV(ST(1));
        if (!SvOK((SV*) ST(2))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(2), PL_na);
        arg6 = (svn_boolean_t) SvIV(ST(3));
        arg7 = (svn_boolean_t) SvIV(ST(4));
        if (!SvOK((SV*) ST(5))) arg8 = 0;
        else arg8 = (char *) SvPV(ST(5), PL_na);
        {
            svn_delta_make_editor(&arg9, &arg10, ST(6), _global_pool);
        }
        if (items > 7) {
            
        }
        {
            result = (svn_error_t *)svn_ra_do_diff(arg1,(struct svn_ra_reporter2_t const **)arg2,arg3,arg4,(char const *)arg5,arg6,arg7,(char const *)arg8,(struct svn_delta_editor_t const *)arg9,arg10,arg11);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_svn_ra_reporter2_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg3, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_log) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
        svn_revnum_t arg3 ;
        svn_revnum_t arg4 ;
        int arg5 ;
        svn_boolean_t arg6 ;
        svn_boolean_t arg7 ;
        svn_log_message_receiver_t arg8 = (svn_log_message_receiver_t) 0 ;
        void *arg9 = (void *) 0 ;
        apr_pool_t *arg10 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg10 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 8) || (items > 9)) {
            SWIG_croak("Usage: svn_ra_get_log(session,paths,start,end,limit,discover_changed_paths,strict_node_history,receiver,receiver_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_log. Expected _p_svn_ra_session_t");
            }
        }
        {
            arg2 = (apr_array_header_t *) svn_swig_pl_strings_to_array(ST(1),
            _global_pool);
        }
        arg3 = (svn_revnum_t) SvIV(ST(2));
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (int) SvIV(ST(4));
        arg6 = (svn_boolean_t) SvIV(ST(5));
        arg7 = (svn_boolean_t) SvIV(ST(6));
        {
            arg8 = svn_swig_pl_thunk_log_receiver;
            arg9 = (void *)ST(7);
        }
        if (items > 8) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_log(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_check_path) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_revnum_t arg3 ;
        svn_node_kind_t *arg4 = (svn_node_kind_t *) 0 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        long temp4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg4 = &temp4;
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_ra_check_path(session,path,revision,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_check_path. Expected _p_svn_ra_session_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        arg3 = (svn_revnum_t) SvIV(ST(2));
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_ra_check_path(arg1,(char const *)arg2,arg3,arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg4));
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_stat) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_revnum_t arg3 ;
        svn_dirent_t **arg4 = (svn_dirent_t **) 0 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_dirent_t *temp4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg4 = (svn_dirent_t **)&temp4;
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_ra_stat(session,path,revision,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_stat. Expected _p_svn_ra_session_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        arg3 = (svn_revnum_t) SvIV(ST(2));
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_ra_stat(arg1,(char const *)arg2,arg3,arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg4, SWIGTYPE_p_svn_dirent_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_uuid) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        char **arg2 = (char **) 0 ;
        apr_pool_t *arg3 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        char const *temp2 = NULL ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg3 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg2 = (char **)&temp2;
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_get_uuid(session,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_uuid. Expected _p_svn_ra_session_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_uuid(arg1,(char const **)arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (*arg2 == NULL)
            ST(argvi) = &PL_sv_undef;
            else
            ST(argvi) = sv_2mortal(newSVpv(*arg2, 0));
            ++argvi;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_repos_root) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        char **arg2 = (char **) 0 ;
        apr_pool_t *arg3 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        char const *temp2 = NULL ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg3 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg2 = (char **)&temp2;
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_get_repos_root(session,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_repos_root. Expected _p_svn_ra_session_t");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_repos_root(arg1,(char const **)arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (*arg2 == NULL)
            ST(argvi) = &PL_sv_undef;
            else
            ST(argvi) = sv_2mortal(newSVpv(*arg2, 0));
            ++argvi;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_locations) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        apr_hash_t **arg2 = (apr_hash_t **) 0 ;
        char *arg3 = (char *) 0 ;
        svn_revnum_t arg4 ;
        apr_array_header_t *arg5 = (apr_array_header_t *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_ra_get_locations(session,locations,path,peg_revision,location_revisions,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_locations. Expected _p_svn_ra_session_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_p_apr_hash_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_get_locations. Expected _p_p_apr_hash_t");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_revnum_t) SvIV(ST(3));
        {
            if (SWIG_ConvertPtr(ST(4), (void **) &arg5, SWIGTYPE_p_apr_array_header_t,0) < 0) {
                SWIG_croak("Type error in argument 5 of svn_ra_get_locations. Expected _p_apr_array_header_t");
            }
        }
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_locations(arg1,arg2,(char const *)arg3,arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_file_revs) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        char *arg2 = (char *) 0 ;
        svn_revnum_t arg3 ;
        svn_revnum_t arg4 ;
        svn_ra_file_rev_handler_t arg5 = (svn_ra_file_rev_handler_t) 0 ;
        void *arg6 = (void *) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_ra_get_file_revs(session,path,start,end,handler,handler_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_file_revs. Expected _p_svn_ra_session_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        arg3 = (svn_revnum_t) SvIV(ST(2));
        arg4 = (svn_revnum_t) SvIV(ST(3));
        {
            if (SWIG_ConvertPtr(ST(4), (void **) &arg5, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 5 of svn_ra_get_file_revs. Expected _p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(5), (void **) &arg6, 0,0) < 0) {
                SWIG_croak("Type error in argument 6 of svn_ra_get_file_revs. Expected _p_void");
            }
        }
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_file_revs(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_lock) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        apr_hash_t *arg2 = (apr_hash_t *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_boolean_t arg4 ;
        svn_ra_lock_callback_t arg5 = (svn_ra_lock_callback_t) 0 ;
        void *arg6 = (void *) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_ra_lock(session,path_revs,comment,steal_lock,lock_func,lock_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_lock. Expected _p_svn_ra_session_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_apr_hash_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_lock. Expected _p_apr_hash_t");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_boolean_t) SvIV(ST(3));
        {
            if (SWIG_ConvertPtr(ST(4), (void **) &arg5, SWIGTYPE_p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 5 of svn_ra_lock. Expected _p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(5), (void **) &arg6, 0,0) < 0) {
                SWIG_croak("Type error in argument 6 of svn_ra_lock. Expected _p_void");
            }
        }
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_ra_lock(arg1,arg2,(char const *)arg3,arg4,arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_unlock) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        apr_hash_t *arg2 = (apr_hash_t *) 0 ;
        svn_boolean_t arg3 ;
        svn_ra_lock_callback_t arg4 = (svn_ra_lock_callback_t) 0 ;
        void *arg5 = (void *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_ra_unlock(session,path_tokens,break_lock,lock_func,lock_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_unlock. Expected _p_svn_ra_session_t");
            }
        }
        {
            arg2 = svn_swig_pl_strings_to_hash (ST(1), _global_pool);
        }
        arg3 = (svn_boolean_t) SvIV(ST(2));
        {
            if (SWIG_ConvertPtr(ST(3), (void **) &arg4, SWIGTYPE_p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 4 of svn_ra_unlock. Expected _p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(4), (void **) &arg5, 0,0) < 0) {
                SWIG_croak("Type error in argument 5 of svn_ra_unlock. Expected _p_void");
            }
        }
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_ra_unlock(arg1,arg2,arg3,arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_lock) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_lock_t **arg2 = (svn_lock_t **) 0 ;
        char *arg3 = (char *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_lock_t *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (svn_lock_t **)&temp2;
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_get_lock(session,path,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_lock. Expected _p_svn_ra_session_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(1), PL_na);
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_lock(arg1,arg2,(char const *)arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_svn_lock_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_locks) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        apr_hash_t **arg2 = (apr_hash_t **) 0 ;
        char *arg3 = (char *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_ra_get_locks(session,locks,path,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_get_locks. Expected _p_svn_ra_session_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_p_apr_hash_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_get_locks. Expected _p_p_apr_hash_t");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_locks(arg1,arg2,(char const *)arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_replay) {
    {
        svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
        svn_revnum_t arg2 ;
        svn_revnum_t arg3 ;
        svn_boolean_t arg4 ;
        svn_delta_editor_t *arg5 = (svn_delta_editor_t *) 0 ;
        void *arg6 = (void *) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_ra_replay(session,revision,low_water_mark,send_deltas,editor,edit_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_session_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_replay. Expected _p_svn_ra_session_t");
            }
        }
        arg2 = (svn_revnum_t) SvIV(ST(1));
        arg3 = (svn_revnum_t) SvIV(ST(2));
        arg4 = (svn_boolean_t) SvIV(ST(3));
        {
            svn_delta_make_editor(&arg5, &arg6, ST(4), _global_pool);
        }
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_ra_replay(arg1,arg2,arg3,arg4,(struct svn_delta_editor_t const *)arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_print_modules) {
    {
        svn_stringbuf_t *arg1 = (svn_stringbuf_t *) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_print_modules(output,pool);");
        }
        {
            apr_size_t len;
            char *buf;
            
            if (!SvOK(ST(0))) {
                arg1 = NULL;
            } else if (SvPOK(ST(0))) {
                buf = SvPV(ST(0), len);
                /* Another case of ugly pool handling, this should use the current
                           default pool, or make a new one if it doesn't exist yet */
                arg1 = svn_stringbuf_ncreate(buf,len,
                svn_swig_pl_make_pool ((SV *)NULL));
            } else {
                croak("Not a string");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (svn_error_t *)svn_ra_print_modules(arg1,arg2);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_print_ra_libraries) {
    {
        svn_stringbuf_t **arg1 = (svn_stringbuf_t **) 0 ;
        void *arg2 = (void *) 0 ;
        apr_pool_t *arg3 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_stringbuf_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg3 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = &temp1;
        }
        if ((items < 1) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_print_ra_libraries(ra_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_print_ra_libraries. Expected _p_void");
            }
        }
        if (items > 1) {
            
        }
        {
            result = (svn_error_t *)svn_ra_print_ra_libraries(arg1,arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (*arg1) {
                ST(argvi) = sv_newmortal();
                sv_setpvn (ST(argvi), (*arg1)->data, (*arg1)->len);
            }
            else
            ST(argvi) = &PL_sv_undef;
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_name_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        char *arg2 = (char *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_name_set(self,name);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_name_set. Expected _p_svn_ra_plugin_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        {
            apr_size_t len = strlen(arg2) + 1;
            char *copied;
            if (arg1->name) free((char *)arg1->name);
            copied = malloc(len);
            memcpy(copied, arg2, len);
            arg1->name = copied;
        }
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_name_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        char *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_name_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_name_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (char *) ((arg1)->name);
        
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_description_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        char *arg2 = (char *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_description_set(self,description);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_description_set. Expected _p_svn_ra_plugin_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg2 = 0;
        else arg2 = (char *) SvPV(ST(1), PL_na);
        {
            apr_size_t len = strlen(arg2) + 1;
            char *copied;
            if (arg1->description) free((char *)arg1->description);
            copied = malloc(len);
            memcpy(copied, arg2, len);
            arg1->description = copied;
        }
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_description_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        char *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_description_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_description_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (char *) ((arg1)->description);
        
        ST(argvi) = sv_newmortal();
        if (result) {
            sv_setpv((SV*)ST(argvi++), (char *) result);
        } else {
            sv_setsv((SV*)ST(argvi++), &PL_sv_undef);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_open_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *) = (svn_error_t *(*)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_open_set(self,open);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_open_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_open_set. Expected _p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->open = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_open_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_open_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_open_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *)) ((arg1)->open);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_latest_revnum_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,svn_revnum_t *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_revnum_t *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_latest_revnum_set(self,get_latest_revnum);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_latest_revnum_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_get_latest_revnum_set. Expected _p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_latest_revnum = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_latest_revnum_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,svn_revnum_t *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_latest_revnum_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_latest_revnum_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,svn_revnum_t *,apr_pool_t *)) ((arg1)->get_latest_revnum);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_dated_revision_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *) = (svn_error_t *(*)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_dated_revision_set(self,get_dated_revision);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_dated_revision_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_get_dated_revision_set. Expected _p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_dated_revision = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_dated_revision_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_dated_revision_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_dated_revision_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *)) ((arg1)->get_dated_revision);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_change_rev_prop_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_change_rev_prop_set(self,change_rev_prop);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_change_rev_prop_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_change_rev_prop_set. Expected _p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->change_rev_prop = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_change_rev_prop_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_change_rev_prop_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_change_rev_prop_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *)) ((arg1)->change_rev_prop);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_rev_proplist_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *) = (svn_error_t *(*)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_rev_proplist_set(self,rev_proplist);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_rev_proplist_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_rev_proplist_set. Expected _p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->rev_proplist = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_rev_proplist_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_rev_proplist_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_rev_proplist_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *)) ((arg1)->rev_proplist);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_rev_prop_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *) = (svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_rev_prop_set(self,rev_prop);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_rev_prop_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_rev_prop_set. Expected _p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->rev_prop = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_rev_prop_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_rev_prop_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_rev_prop_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *)) ((arg1)->rev_prop);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_commit_editor_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_commit_editor_set(self,get_commit_editor);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_commit_editor_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_get_commit_editor_set. Expected _p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_commit_editor = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_commit_editor_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_commit_editor_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_commit_editor_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *)) ((arg1)->get_commit_editor);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_file_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_file_set(self,get_file);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_file_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_get_file_set. Expected _p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_file = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_file_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_file_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_file_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *)) ((arg1)->get_file);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_dir_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_dir_set(self,get_dir);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_dir_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_get_dir_set. Expected _p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_dir = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_dir_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_dir_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_dir_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *)) ((arg1)->get_dir);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_do_update_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_do_update_set(self,do_update);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_do_update_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_do_update_set. Expected _p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->do_update = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_do_update_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_do_update_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_do_update_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)) ((arg1)->do_update);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_do_switch_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_do_switch_set(self,do_switch);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_do_switch_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_do_switch_set. Expected _p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->do_switch = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_do_switch_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_do_switch_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_do_switch_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)) ((arg1)->do_switch);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_do_status_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_do_status_set(self,do_status);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_do_status_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_do_status_set. Expected _p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->do_status = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_do_status_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_do_status_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_do_status_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)) ((arg1)->do_status);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_do_diff_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_do_diff_set(self,do_diff);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_do_diff_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_do_diff_set. Expected _p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->do_diff = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_do_diff_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_do_diff_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_do_diff_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)) ((arg1)->do_diff);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_log_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_log_set(self,get_log);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_log_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_get_log_set. Expected _p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_log = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_log_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_log_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_log_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *)) ((arg1)->get_log);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_check_path_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_check_path_set(self,check_path);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_check_path_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_check_path_set. Expected _p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->check_path = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_check_path_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_check_path_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_check_path_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *)) ((arg1)->check_path);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_uuid_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const **,apr_pool_t *) = (svn_error_t *(*)(void *,char const **,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_uuid_set(self,get_uuid);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_uuid_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_get_uuid_set. Expected _p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_uuid = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_uuid_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,char const **,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_uuid_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_uuid_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const **,apr_pool_t *)) ((arg1)->get_uuid);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_repos_root_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const **,apr_pool_t *) = (svn_error_t *(*)(void *,char const **,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_repos_root_set(self,get_repos_root);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_repos_root_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_get_repos_root_set. Expected _p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_repos_root = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_repos_root_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,char const **,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_repos_root_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_repos_root_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const **,apr_pool_t *)) ((arg1)->get_repos_root);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_locations_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_locations_set(self,get_locations);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_locations_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_get_locations_set. Expected _p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_locations = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_locations_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_locations_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_locations_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *)) ((arg1)->get_locations);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_file_revs_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_file_revs_set(self,get_file_revs);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_file_revs_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_get_file_revs_set. Expected _p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t");
            }
        }
        if (arg1) (arg1)->get_file_revs = arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_file_revs_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_error_t *(*result)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_file_revs_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_file_revs_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *)) ((arg1)->get_file_revs);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_version_set) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_version_t *(*arg2)(void) = (svn_version_t *(*)(void)) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 2) || (items > 2)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_version_set(self,get_version);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_version_set. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, SWIGTYPE_p_f_void__p_svn_version_t,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_t_get_version_set. Expected _p_f_void__p_svn_version_t");
            }
        }
        if (arg1) (arg1)->get_version = (svn_version_t const *(*)(void))arg2;
        
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_t_get_version_get) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        svn_version_t *(*result)(void);
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_plugin_t_get_version_get(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_t_get_version_get. Expected _p_svn_ra_plugin_t");
            }
        }
        result = (svn_version_t *(*)(void)) ((arg1)->get_version);
        
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_f_void__p_svn_version_t, 0|0);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_new_svn_ra_plugin_t) {
    {
        svn_ra_plugin_t *result;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 0) || (items > 0)) {
            SWIG_croak("Usage: new_svn_ra_plugin_t();");
        }
        {
            result = (svn_ra_plugin_t *)(svn_ra_plugin_t *) calloc(1, sizeof(svn_ra_plugin_t));
            
            
            
            
        }
        ST(argvi) = sv_newmortal();
        SWIG_MakePtr(ST(argvi++), (void *) result, SWIGTYPE_p_svn_ra_plugin_t, SWIG_SHADOW|SWIG_OWNER);
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_delete_svn_ra_plugin_t) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        int argvi = 0;
        dXSARGS;
        
        if ((items < 1) || (items > 1)) {
            SWIG_croak("Usage: delete_svn_ra_plugin_t(self);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of delete_svn_ra_plugin_t. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            free((char *) arg1);
            
            
            
            
        }
        
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_init_ra_libs) {
    {
        void **arg1 = (void **) 0 ;
        apr_pool_t *arg2 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        void *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg2 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (void **)&temp1;
        }
        if ((items < 0) || (items > 1)) {
            SWIG_croak("Usage: svn_ra_init_ra_libs(pool);");
        }
        if (items > 0) {
            
        }
        {
            result = (svn_error_t *)svn_ra_init_ra_libs(arg1,arg2);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_get_ra_library) {
    {
        svn_ra_plugin_t **arg1 = (svn_ra_plugin_t **) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_ra_plugin_t *temp1 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg1 = (svn_ra_plugin_t **)&temp1;
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_get_ra_library(ra_baton,url,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_get_ra_library. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(1))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(1), PL_na);
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_get_ra_library(arg1,arg2,(char const *)arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg1, SWIGTYPE_p_svn_ra_plugin_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_invoke_set_path) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_revnum_t arg4 ;
        svn_boolean_t arg5 ;
        char *arg6 = (char *) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_ra_reporter2_invoke_set_path(_obj,report_baton,path,revision,start_empty,lock_token,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_invoke_set_path. Expected _p_svn_ra_reporter2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter2_invoke_set_path. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (svn_boolean_t) SvIV(ST(4));
        if (!SvOK((SV*) ST(5))) arg6 = 0;
        else arg6 = (char *) SvPV(ST(5), PL_na);
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_ra_reporter2_invoke_set_path(arg1,arg2,(char const *)arg3,arg4,arg5,(char const *)arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_invoke_delete_path) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_ra_reporter2_invoke_delete_path(_obj,report_baton,path,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_invoke_delete_path. Expected _p_svn_ra_reporter2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter2_invoke_delete_path. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_ra_reporter2_invoke_delete_path(arg1,arg2,(char const *)arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_invoke_link_path) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        char *arg4 = (char *) 0 ;
        svn_revnum_t arg5 ;
        svn_boolean_t arg6 ;
        char *arg7 = (char *) 0 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 7) || (items > 8)) {
            SWIG_croak("Usage: svn_ra_reporter2_invoke_link_path(_obj,report_baton,path,url,revision,start_empty,lock_token,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_invoke_link_path. Expected _p_svn_ra_reporter2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter2_invoke_link_path. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        if (!SvOK((SV*) ST(3))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(3), PL_na);
        arg5 = (svn_revnum_t) SvIV(ST(4));
        arg6 = (svn_boolean_t) SvIV(ST(5));
        if (!SvOK((SV*) ST(6))) arg7 = 0;
        else arg7 = (char *) SvPV(ST(6), PL_na);
        if (items > 7) {
            
        }
        {
            result = (svn_error_t *)svn_ra_reporter2_invoke_link_path(arg1,arg2,(char const *)arg3,(char const *)arg4,arg5,arg6,(char const *)arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_invoke_finish_report) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        apr_pool_t *arg3 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg3 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_reporter2_invoke_finish_report(_obj,report_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_invoke_finish_report. Expected _p_svn_ra_reporter2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter2_invoke_finish_report. Expected _p_void");
            }
        }
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_reporter2_invoke_finish_report(arg1,arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter2_invoke_abort_report) {
    {
        svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
        void *arg2 = (void *) 0 ;
        apr_pool_t *arg3 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg3 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_reporter2_invoke_abort_report(_obj,report_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter2_invoke_abort_report. Expected _p_svn_ra_reporter2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter2_invoke_abort_report. Expected _p_void");
            }
        }
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_reporter2_invoke_abort_report(arg1,arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_invoke_set_path) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_revnum_t arg4 ;
        svn_boolean_t arg5 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_ra_reporter_invoke_set_path(_obj,report_baton,path,revision,start_empty,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_invoke_set_path. Expected _p_svn_ra_reporter_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter_invoke_set_path. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (svn_boolean_t) SvIV(ST(4));
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_ra_reporter_invoke_set_path(arg1,arg2,(char const *)arg3,arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_invoke_delete_path) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_ra_reporter_invoke_delete_path(_obj,report_baton,path,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_invoke_delete_path. Expected _p_svn_ra_reporter_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter_invoke_delete_path. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_ra_reporter_invoke_delete_path(arg1,arg2,(char const *)arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_invoke_link_path) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        char *arg4 = (char *) 0 ;
        svn_revnum_t arg5 ;
        svn_boolean_t arg6 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_ra_reporter_invoke_link_path(_obj,report_baton,path,url,revision,start_empty,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_invoke_link_path. Expected _p_svn_ra_reporter_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter_invoke_link_path. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        if (!SvOK((SV*) ST(3))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(3), PL_na);
        arg5 = (svn_revnum_t) SvIV(ST(4));
        arg6 = (svn_boolean_t) SvIV(ST(5));
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_ra_reporter_invoke_link_path(arg1,arg2,(char const *)arg3,(char const *)arg4,arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_invoke_finish_report) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        void *arg2 = (void *) 0 ;
        apr_pool_t *arg3 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg3 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_reporter_invoke_finish_report(_obj,report_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_invoke_finish_report. Expected _p_svn_ra_reporter_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter_invoke_finish_report. Expected _p_void");
            }
        }
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_reporter_invoke_finish_report(arg1,arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_reporter_invoke_abort_report) {
    {
        svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
        void *arg2 = (void *) 0 ;
        apr_pool_t *arg3 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg3 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_reporter_invoke_abort_report(_obj,report_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_reporter_invoke_abort_report. Expected _p_svn_ra_reporter_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_reporter_invoke_abort_report. Expected _p_void");
            }
        }
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_reporter_invoke_abort_report(arg1,arg2,arg3);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks2_invoke_open_tmp_file) {
    {
        svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
        apr_file_t **arg2 = (apr_file_t **) 0 ;
        void *arg3 = (void *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        apr_file_t *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg2 = &temp2;
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_callbacks2_invoke_open_tmp_file(_obj,callback_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks2_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks2_invoke_open_tmp_file. Expected _p_svn_ra_callbacks2_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg3, 0,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_ra_callbacks2_invoke_open_tmp_file. Expected _p_void");
            }
        }
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_callbacks2_invoke_open_tmp_file(arg1,arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_apr_file_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_callbacks_invoke_open_tmp_file) {
    {
        svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
        apr_file_t **arg2 = (apr_file_t **) 0 ;
        void *arg3 = (void *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        apr_file_t *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg2 = &temp2;
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_callbacks_invoke_open_tmp_file(_obj,callback_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_callbacks_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_callbacks_invoke_open_tmp_file. Expected _p_svn_ra_callbacks_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg3, 0,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_ra_callbacks_invoke_open_tmp_file. Expected _p_void");
            }
        }
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_callbacks_invoke_open_tmp_file(arg1,arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_apr_file_t,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_open) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void **arg2 = (void **) 0 ;
        char *arg3 = (char *) 0 ;
        svn_ra_callbacks_t *arg4 = (svn_ra_callbacks_t *) 0 ;
        void *arg5 = (void *) 0 ;
        apr_hash_t *arg6 = (apr_hash_t *) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        void *temp2 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg2 = (void **)&temp2;
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_open(_obj,repos_URL,callbacks,callback_baton,config,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_open. Expected _p_svn_ra_plugin_t");
            }
        }
        if (!SvOK((SV*) ST(1))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(1), PL_na);
        {
            svn_ra_make_callbacks(&arg4, &arg5, ST(2), _global_pool);
        }
        {
            arg6 = svn_swig_pl_objs_to_hash_by_name (ST(3), "svn_config_t *",
            _global_pool);
        }
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_open(arg1,arg2,(char const *)arg3,(struct svn_ra_callbacks_t const *)arg4,arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg2, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_get_latest_revnum) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_revnum_t *arg3 = (svn_revnum_t *) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        long temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg3 = &temp3;
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_get_latest_revnum(_obj,session_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_get_latest_revnum. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_get_latest_revnum. Expected _p_void");
            }
        }
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_get_latest_revnum(arg1,arg2,arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg3));
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_get_dated_revision) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_revnum_t *arg3 = (svn_revnum_t *) 0 ;
        apr_time_t arg4 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        long temp3 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg3 = &temp3;
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_get_dated_revision(_obj,session_baton,tm,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_get_dated_revision. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_get_dated_revision. Expected _p_void");
            }
        }
        arg4 = (apr_time_t) strtoll(SvPV(ST(2), PL_na), 0, 0);
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_get_dated_revision(arg1,arg2,arg3,arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg3));
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_change_rev_prop) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_revnum_t arg3 ;
        char *arg4 = (char *) 0 ;
        svn_string_t *arg5 = (svn_string_t *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_string_t value5 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_change_rev_prop(_obj,session_baton,rev,name,value,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_change_rev_prop. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_change_rev_prop. Expected _p_void");
            }
        }
        arg3 = (svn_revnum_t) SvIV(ST(2));
        if (!SvOK((SV*) ST(3))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(3), PL_na);
        {
            if (SvOK(ST(4))) {
                value5.data = SvPV(ST(4), value5.len);
                arg5 = &value5;
            }
            else {
                arg5 = NULL;
            }
        }
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_change_rev_prop(arg1,arg2,arg3,(char const *)arg4,(struct svn_string_t const *)arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_rev_proplist) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_revnum_t arg3 ;
        apr_hash_t **arg4 = (apr_hash_t **) 0 ;
        apr_pool_t *arg5 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        apr_hash_t *temp4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg5 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg4 = &temp4;
        if ((items < 3) || (items > 4)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_rev_proplist(_obj,session_baton,rev,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_rev_proplist. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_rev_proplist. Expected _p_void");
            }
        }
        arg3 = (svn_revnum_t) SvIV(ST(2));
        if (items > 3) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_rev_proplist(arg1,arg2,arg3,arg4,arg5);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = svn_swig_pl_prophash_to_hash(*arg4);
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_rev_prop) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_revnum_t arg3 ;
        char *arg4 = (char *) 0 ;
        svn_string_t **arg5 = (svn_string_t **) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_string_t *temp5 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg5 = &temp5;
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_rev_prop(_obj,session_baton,rev,name,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_rev_prop. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_rev_prop. Expected _p_void");
            }
        }
        arg3 = (svn_revnum_t) SvIV(ST(2));
        if (!SvOK((SV*) ST(3))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(3), PL_na);
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_rev_prop(arg1,arg2,arg3,(char const *)arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (*arg5) {
                ST(argvi) = sv_newmortal();
                sv_setpvn (ST(argvi), (*arg5)->data, (*arg5)->len);
            }
            else
            ST(argvi) = &PL_sv_undef;
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_get_commit_editor) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_delta_editor_t **arg3 = (svn_delta_editor_t **) 0 ;
        void **arg4 = (void **) 0 ;
        char *arg5 = (char *) 0 ;
        svn_commit_callback_t arg6 = (svn_commit_callback_t) 0 ;
        void *arg7 = (void *) 0 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        svn_delta_editor_t const *temp3 ;
        void *temp4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg3 = (svn_delta_editor_t **)&temp3;
        }
        {
            arg4 = (void **)&temp4;
        }
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_get_commit_editor(_obj,session_baton,log_msg,callback,callback_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_get_commit_editor. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_get_commit_editor. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(2), PL_na);
        {
            arg6 = svn_swig_pl_thunk_commit_callback;
            arg7 = (void *)ST(3);
            svn_swig_pl_hold_ref_in_pool (_global_pool, ST(3));
        }
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_get_commit_editor(arg1,arg2,(struct svn_delta_editor_t const **)arg3,arg4,(char const *)arg5,arg6,arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg3, SWIGTYPE_p_svn_delta_editor_t,0);
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg4, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_get_file) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_revnum_t arg4 ;
        svn_stream_t *arg5 = (svn_stream_t *) 0 ;
        svn_revnum_t *arg6 = (svn_revnum_t *) 0 ;
        apr_hash_t **arg7 = (apr_hash_t **) 0 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        long temp6 ;
        apr_hash_t *temp7 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg6 = &temp6;
        arg7 = &temp7;
        if ((items < 5) || (items > 6)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_get_file(_obj,session_baton,path,revision,stream,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_get_file. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_get_file. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_revnum_t) SvIV(ST(3));
        {
            svn_swig_pl_make_stream (&arg5, ST(4));
        }
        if (items > 5) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_get_file(arg1,arg2,(char const *)arg3,arg4,arg5,arg6,arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg6));
            argvi++;
        }
        {
            ST(argvi) = svn_swig_pl_prophash_to_hash(*arg7);
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_get_dir) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_revnum_t arg4 ;
        apr_hash_t **arg5 = (apr_hash_t **) 0 ;
        svn_revnum_t *arg6 = (svn_revnum_t *) 0 ;
        apr_hash_t **arg7 = (apr_hash_t **) 0 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        apr_hash_t *temp5 ;
        long temp6 ;
        apr_hash_t *temp7 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg5 = &temp5;
        arg6 = &temp6;
        arg7 = &temp7;
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_get_dir(_obj,session_baton,path,revision,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_get_dir. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_get_dir. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_revnum_t) SvIV(ST(3));
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_get_dir(arg1,arg2,(char const *)arg3,arg4,arg5,arg6,arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi++) = svn_swig_pl_convert_hash
            (*arg5, SWIGTYPE_p_svn_dirent_t);
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg6));
            argvi++;
        }
        {
            ST(argvi) = svn_swig_pl_prophash_to_hash(*arg7);
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_do_update) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_ra_reporter_t **arg3 = (svn_ra_reporter_t **) 0 ;
        void **arg4 = (void **) 0 ;
        svn_revnum_t arg5 ;
        char *arg6 = (char *) 0 ;
        svn_boolean_t arg7 ;
        svn_delta_editor_t *arg8 = (svn_delta_editor_t *) 0 ;
        void *arg9 = (void *) 0 ;
        apr_pool_t *arg10 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        void *temp4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg10 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg4 = (void **)&temp4;
        }
        if ((items < 7) || (items > 8)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_do_update(_obj,session_baton,reporter,revision_to_update_to,update_target,recurse,update_editor,update_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_do_update. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_do_update. Expected _p_void");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg3, SWIGTYPE_p_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_ra_plugin_invoke_do_update. Expected _p_p_svn_ra_reporter_t");
            }
        }
        arg5 = (svn_revnum_t) SvIV(ST(3));
        if (!SvOK((SV*) ST(4))) arg6 = 0;
        else arg6 = (char *) SvPV(ST(4), PL_na);
        arg7 = (svn_boolean_t) SvIV(ST(5));
        {
            svn_delta_make_editor(&arg8, &arg9, ST(6), _global_pool);
        }
        if (items > 7) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_do_update(arg1,arg2,(struct svn_ra_reporter_t const **)arg3,arg4,arg5,(char const *)arg6,arg7,(struct svn_delta_editor_t const *)arg8,arg9,arg10);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg4, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_do_switch) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_ra_reporter_t **arg3 = (svn_ra_reporter_t **) 0 ;
        void **arg4 = (void **) 0 ;
        svn_revnum_t arg5 ;
        char *arg6 = (char *) 0 ;
        svn_boolean_t arg7 ;
        char *arg8 = (char *) 0 ;
        svn_delta_editor_t *arg9 = (svn_delta_editor_t *) 0 ;
        void *arg10 = (void *) 0 ;
        apr_pool_t *arg11 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        void *temp4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg11 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg4 = (void **)&temp4;
        }
        if ((items < 8) || (items > 9)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_do_switch(_obj,session_baton,reporter,revision_to_switch_to,switch_target,recurse,switch_url,switch_editor,switch_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_do_switch. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_do_switch. Expected _p_void");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg3, SWIGTYPE_p_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_ra_plugin_invoke_do_switch. Expected _p_p_svn_ra_reporter_t");
            }
        }
        arg5 = (svn_revnum_t) SvIV(ST(3));
        if (!SvOK((SV*) ST(4))) arg6 = 0;
        else arg6 = (char *) SvPV(ST(4), PL_na);
        arg7 = (svn_boolean_t) SvIV(ST(5));
        if (!SvOK((SV*) ST(6))) arg8 = 0;
        else arg8 = (char *) SvPV(ST(6), PL_na);
        {
            svn_delta_make_editor(&arg9, &arg10, ST(7), _global_pool);
        }
        if (items > 8) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_do_switch(arg1,arg2,(struct svn_ra_reporter_t const **)arg3,arg4,arg5,(char const *)arg6,arg7,(char const *)arg8,(struct svn_delta_editor_t const *)arg9,arg10,arg11);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg4, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_do_status) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_ra_reporter_t **arg3 = (svn_ra_reporter_t **) 0 ;
        void **arg4 = (void **) 0 ;
        char *arg5 = (char *) 0 ;
        svn_revnum_t arg6 ;
        svn_boolean_t arg7 ;
        svn_delta_editor_t *arg8 = (svn_delta_editor_t *) 0 ;
        void *arg9 = (void *) 0 ;
        apr_pool_t *arg10 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        void *temp4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg10 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg4 = (void **)&temp4;
        }
        if ((items < 7) || (items > 8)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_do_status(_obj,session_baton,reporter,status_target,revision,recurse,status_editor,status_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_do_status. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_do_status. Expected _p_void");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg3, SWIGTYPE_p_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_ra_plugin_invoke_do_status. Expected _p_p_svn_ra_reporter_t");
            }
        }
        if (!SvOK((SV*) ST(3))) arg5 = 0;
        else arg5 = (char *) SvPV(ST(3), PL_na);
        arg6 = (svn_revnum_t) SvIV(ST(4));
        arg7 = (svn_boolean_t) SvIV(ST(5));
        {
            svn_delta_make_editor(&arg8, &arg9, ST(6), _global_pool);
        }
        if (items > 7) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_do_status(arg1,arg2,(struct svn_ra_reporter_t const **)arg3,arg4,(char const *)arg5,arg6,arg7,(struct svn_delta_editor_t const *)arg8,arg9,arg10);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg4, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_do_diff) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        svn_ra_reporter_t **arg3 = (svn_ra_reporter_t **) 0 ;
        void **arg4 = (void **) 0 ;
        svn_revnum_t arg5 ;
        char *arg6 = (char *) 0 ;
        svn_boolean_t arg7 ;
        svn_boolean_t arg8 ;
        char *arg9 = (char *) 0 ;
        svn_delta_editor_t *arg10 = (svn_delta_editor_t *) 0 ;
        void *arg11 = (void *) 0 ;
        apr_pool_t *arg12 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        void *temp4 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg12 = svn_swig_pl_make_pool (ST(items-1));
        }
        {
            arg4 = (void **)&temp4;
        }
        if ((items < 9) || (items > 10)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_do_diff(_obj,session_baton,reporter,revision,diff_target,recurse,ignore_ancestry,versus_url,diff_editor,diff_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_do_diff. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_do_diff. Expected _p_void");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg3, SWIGTYPE_p_p_svn_ra_reporter_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_ra_plugin_invoke_do_diff. Expected _p_p_svn_ra_reporter_t");
            }
        }
        arg5 = (svn_revnum_t) SvIV(ST(3));
        if (!SvOK((SV*) ST(4))) arg6 = 0;
        else arg6 = (char *) SvPV(ST(4), PL_na);
        arg7 = (svn_boolean_t) SvIV(ST(5));
        arg8 = (svn_boolean_t) SvIV(ST(6));
        if (!SvOK((SV*) ST(7))) arg9 = 0;
        else arg9 = (char *) SvPV(ST(7), PL_na);
        {
            svn_delta_make_editor(&arg10, &arg11, ST(8), _global_pool);
        }
        if (items > 9) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_do_diff(arg1,arg2,(struct svn_ra_reporter_t const **)arg3,arg4,arg5,(char const *)arg6,arg7,arg8,(char const *)arg9,(struct svn_delta_editor_t const *)arg10,arg11,arg12);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            ST(argvi) = sv_newmortal();
            SWIG_MakePtr(ST(argvi++), (void *)*arg4, SWIGTYPE_p_void,0);
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_get_log) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        apr_array_header_t *arg3 = (apr_array_header_t *) 0 ;
        svn_revnum_t arg4 ;
        svn_revnum_t arg5 ;
        svn_boolean_t arg6 ;
        svn_boolean_t arg7 ;
        svn_log_message_receiver_t arg8 = (svn_log_message_receiver_t) 0 ;
        void *arg9 = (void *) 0 ;
        apr_pool_t *arg10 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg10 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 8) || (items > 9)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_get_log(_obj,session_baton,paths,start,end,discover_changed_paths,strict_node_history,receiver,receiver_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_get_log. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_get_log. Expected _p_void");
            }
        }
        {
            arg3 = (apr_array_header_t *) svn_swig_pl_strings_to_array(ST(2),
            _global_pool);
        }
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (svn_revnum_t) SvIV(ST(4));
        arg6 = (svn_boolean_t) SvIV(ST(5));
        arg7 = (svn_boolean_t) SvIV(ST(6));
        {
            arg8 = svn_swig_pl_thunk_log_receiver;
            arg9 = (void *)ST(7);
        }
        if (items > 8) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_get_log(arg1,arg2,(apr_array_header_t const *)arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_check_path) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_revnum_t arg4 ;
        svn_node_kind_t *arg5 = (svn_node_kind_t *) 0 ;
        apr_pool_t *arg6 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        long temp5 ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg6 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg5 = &temp5;
        if ((items < 4) || (items > 5)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_check_path(_obj,session_baton,path,revision,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_check_path. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_check_path. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_revnum_t) SvIV(ST(3));
        if (items > 4) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_check_path(arg1,arg2,(char const *)arg3,arg4,arg5,arg6);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (argvi >= items) {
                EXTEND(sp,1);
            }
            ST(argvi) = sv_newmortal();
            sv_setiv(ST(argvi),(IV) *(arg5));
            argvi++;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_get_uuid) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char **arg3 = (char **) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        char const *temp3 = NULL ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg3 = (char **)&temp3;
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_get_uuid(_obj,session_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_get_uuid. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_get_uuid. Expected _p_void");
            }
        }
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_get_uuid(arg1,arg2,(char const **)arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (*arg3 == NULL)
            ST(argvi) = &PL_sv_undef;
            else
            ST(argvi) = sv_2mortal(newSVpv(*arg3, 0));
            ++argvi;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_get_repos_root) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char **arg3 = (char **) 0 ;
        apr_pool_t *arg4 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        char const *temp3 = NULL ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg4 = svn_swig_pl_make_pool (ST(items-1));
        }
        arg3 = (char **)&temp3;
        if ((items < 2) || (items > 3)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_get_repos_root(_obj,session_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_get_repos_root. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_get_repos_root. Expected _p_void");
            }
        }
        if (items > 2) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_get_repos_root(arg1,arg2,(char const **)arg3,arg4);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        {
            if (*arg3 == NULL)
            ST(argvi) = &PL_sv_undef;
            else
            ST(argvi) = sv_2mortal(newSVpv(*arg3, 0));
            ++argvi;
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_get_locations) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        apr_hash_t **arg3 = (apr_hash_t **) 0 ;
        char *arg4 = (char *) 0 ;
        svn_revnum_t arg5 ;
        apr_array_header_t *arg6 = (apr_array_header_t *) 0 ;
        apr_pool_t *arg7 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg7 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 6) || (items > 7)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_get_locations(_obj,session_baton,locations,path,peg_revision,location_revisions,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_get_locations. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_get_locations. Expected _p_void");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(2), (void **) &arg3, SWIGTYPE_p_p_apr_hash_t,0) < 0) {
                SWIG_croak("Type error in argument 3 of svn_ra_plugin_invoke_get_locations. Expected _p_p_apr_hash_t");
            }
        }
        if (!SvOK((SV*) ST(3))) arg4 = 0;
        else arg4 = (char *) SvPV(ST(3), PL_na);
        arg5 = (svn_revnum_t) SvIV(ST(4));
        {
            if (SWIG_ConvertPtr(ST(5), (void **) &arg6, SWIGTYPE_p_apr_array_header_t,0) < 0) {
                SWIG_croak("Type error in argument 6 of svn_ra_plugin_invoke_get_locations. Expected _p_apr_array_header_t");
            }
        }
        if (items > 6) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_get_locations(arg1,arg2,arg3,(char const *)arg4,arg5,arg6,arg7);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}


XS(_wrap_svn_ra_plugin_invoke_get_file_revs) {
    {
        svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
        void *arg2 = (void *) 0 ;
        char *arg3 = (char *) 0 ;
        svn_revnum_t arg4 ;
        svn_revnum_t arg5 ;
        svn_ra_file_rev_handler_t arg6 = (svn_ra_file_rev_handler_t) 0 ;
        void *arg7 = (void *) 0 ;
        apr_pool_t *arg8 = (apr_pool_t *) 0 ;
        svn_error_t *result;
        apr_pool_t *_global_pool ;
        int argvi = 0;
        dXSARGS;
        
        {
            _global_pool = arg8 = svn_swig_pl_make_pool (ST(items-1));
        }
        if ((items < 7) || (items > 8)) {
            SWIG_croak("Usage: svn_ra_plugin_invoke_get_file_revs(_obj,session_baton,path,start,end,handler,handler_baton,pool);");
        }
        {
            if (SWIG_ConvertPtr(ST(0), (void **) &arg1, SWIGTYPE_p_svn_ra_plugin_t,0) < 0) {
                SWIG_croak("Type error in argument 1 of svn_ra_plugin_invoke_get_file_revs. Expected _p_svn_ra_plugin_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(1), (void **) &arg2, 0,0) < 0) {
                SWIG_croak("Type error in argument 2 of svn_ra_plugin_invoke_get_file_revs. Expected _p_void");
            }
        }
        if (!SvOK((SV*) ST(2))) arg3 = 0;
        else arg3 = (char *) SvPV(ST(2), PL_na);
        arg4 = (svn_revnum_t) SvIV(ST(3));
        arg5 = (svn_revnum_t) SvIV(ST(4));
        {
            if (SWIG_ConvertPtr(ST(5), (void **) &arg6, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,0) < 0) {
                SWIG_croak("Type error in argument 6 of svn_ra_plugin_invoke_get_file_revs. Expected _p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t");
            }
        }
        {
            if (SWIG_ConvertPtr(ST(6), (void **) &arg7, 0,0) < 0) {
                SWIG_croak("Type error in argument 7 of svn_ra_plugin_invoke_get_file_revs. Expected _p_void");
            }
        }
        if (items > 7) {
            
        }
        {
            result = (svn_error_t *)svn_ra_plugin_invoke_get_file_revs(arg1,arg2,(char const *)arg3,arg4,arg5,arg6,arg7,arg8);
            
            
            
            
        }
        {
            if (result) {
                SV *exception_handler = perl_get_sv ("SVN::Error::handler", FALSE);
                
                if (SvOK(exception_handler)) {
                    SV *callback_result;
                    
                    svn_swig_pl_callback_thunk (CALL_SV, exception_handler,
                    &callback_result, "S", result,
                    SWIGTYPE_p_svn_error_t);
                } else {
                    ST(argvi) = sv_newmortal();
                    SWIG_MakePtr (ST(argvi), (void *)result, SWIGTYPE_p_svn_error_t ,0);
                    argvi++;
                }
            }
        }
        XSRETURN(argvi);
        fail:
        ;
    }
    croak(Nullch);
}



/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (BEGIN) -------- */

static swig_type_info _swigt__p_apr_array_header_t = {"_p_apr_array_header_t", "apr_array_header_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_file_t = {"_p_apr_file_t", "apr_file_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_hash_t = {"_p_apr_hash_t", "apr_hash_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int32_t = {"_p_apr_int32_t", "apr_int32_t *|time_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int64_t = {"_p_apr_int64_t", "apr_int64_t *|svn_filesize_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_pool_t = {"_p_apr_pool_t", "apr_pool_t *", 0, 0, 0};
static swig_type_info _swigt__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void = {"_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void", "void (*)(apr_off_t,apr_off_t,void *,apr_pool_t *)|svn_ra_progress_notify_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(apr_getopt_t *,void *,apr_pool_t *)|svn_opt_subcommand_t *", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)|svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *)|svn_error_t *(*)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_commit_info_t const *,void *,apr_pool_t *)|svn_commit_callback2_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_hash_t *,svn_revnum_t,char const *,char const *,char const *,apr_pool_t *)|svn_log_message_receiver_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_pool_t *)|svn_error_t *(*)(void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *)|svn_error_t *(*)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const **,apr_pool_t *)|svn_error_t *(*)(void *,char const **,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *)|svn_error_t *(*)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)|svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)|svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)|svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)|svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *)|svn_error_t *(*)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,char const *,apr_pool_t *)|svn_ra_invalidate_wc_props_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,char const *,svn_string_t const **,apr_pool_t *)|svn_ra_get_wc_prop_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,char const *,svn_string_t const *,apr_pool_t *)|svn_ra_push_wc_prop_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)|svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_boolean_t,svn_lock_t const *,svn_error_t *,apr_pool_t *)|svn_ra_lock_callback_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t *,svn_txdelta_window_handler_t *,void **,apr_array_header_t *,apr_pool_t *)|svn_ra_file_rev_handler_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *)|svn_error_t *(*)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t *,apr_pool_t *)|svn_error_t *(*)(void *,svn_revnum_t *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *)|svn_error_t *(*)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *)|svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *)|svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t = {"_p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t", "struct svn_error_t *(*)(svn_revnum_t,char const *,char const *,void *)|svn_commit_callback_t", 0, 0, 0};
static swig_type_info _swigt__p_f_void__p_svn_version_t = {"_p_f_void__p_svn_version_t", "struct svn_version_t *(*)(void)|svn_version_t *(*)(void)", 0, 0, 0};
static swig_type_info _swigt__p_int = {"_p_int", "int *|svn_boolean_t *", 0, 0, 0};
static swig_type_info _swigt__p_long = {"_p_long", "long *|svn_revnum_t *", 0, 0, 0};
static swig_type_info _swigt__p_p_apr_file_t = {"_p_p_apr_file_t", "apr_file_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_apr_hash_t = {"_p_p_apr_hash_t", "apr_hash_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_char = {"_p_p_char", "char **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_delta_editor_t = {"_p_p_svn_delta_editor_t", "struct svn_delta_editor_t **|svn_delta_editor_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_dirent_t = {"_p_p_svn_dirent_t", "struct svn_dirent_t **|svn_dirent_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_lock_t = {"_p_p_svn_lock_t", "struct svn_lock_t **|svn_lock_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_ra_callbacks2_t = {"_p_p_svn_ra_callbacks2_t", "struct svn_ra_callbacks2_t **|svn_ra_callbacks2_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_ra_plugin_t = {"_p_p_svn_ra_plugin_t", "struct svn_ra_plugin_t **|svn_ra_plugin_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_ra_reporter2_t = {"_p_p_svn_ra_reporter2_t", "struct svn_ra_reporter2_t **|svn_ra_reporter2_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_ra_reporter_t = {"_p_p_svn_ra_reporter_t", "struct svn_ra_reporter_t **|svn_ra_reporter_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_ra_session_t = {"_p_p_svn_ra_session_t", "struct svn_ra_session_t **|svn_ra_session_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_string_t = {"_p_p_svn_string_t", "struct svn_string_t **|svn_string_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_stringbuf_t = {"_p_p_svn_stringbuf_t", "struct svn_stringbuf_t **|svn_stringbuf_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_void = {"_p_p_void", "void **", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_baton_t = {"_p_svn_auth_baton_t", "struct svn_auth_baton_t *|svn_auth_baton_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_simple_t = {"_p_svn_auth_cred_simple_t", "struct svn_auth_cred_simple_t *|svn_auth_cred_simple_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_pw_t = {"_p_svn_auth_cred_ssl_client_cert_pw_t", "struct svn_auth_cred_ssl_client_cert_pw_t *|svn_auth_cred_ssl_client_cert_pw_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_t = {"_p_svn_auth_cred_ssl_client_cert_t", "struct svn_auth_cred_ssl_client_cert_t *|svn_auth_cred_ssl_client_cert_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_server_trust_t = {"_p_svn_auth_cred_ssl_server_trust_t", "struct svn_auth_cred_ssl_server_trust_t *|svn_auth_cred_ssl_server_trust_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_username_t = {"_p_svn_auth_cred_username_t", "struct svn_auth_cred_username_t *|svn_auth_cred_username_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_iterstate_t = {"_p_svn_auth_iterstate_t", "struct svn_auth_iterstate_t *|svn_auth_iterstate_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_object_t = {"_p_svn_auth_provider_object_t", "struct svn_auth_provider_object_t *|svn_auth_provider_object_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_t = {"_p_svn_auth_provider_t", "struct svn_auth_provider_t *|svn_auth_provider_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_ssl_server_cert_info_t = {"_p_svn_auth_ssl_server_cert_info_t", "struct svn_auth_ssl_server_cert_info_t *|svn_auth_ssl_server_cert_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_commit_info_t = {"_p_svn_commit_info_t", "struct svn_commit_info_t *|svn_commit_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_config_t = {"_p_svn_config_t", "struct svn_config_t *|svn_config_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_delta_editor_t = {"_p_svn_delta_editor_t", "struct svn_delta_editor_t *|svn_delta_editor_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_datasource_e = {"_p_svn_diff_datasource_e", "enum svn_diff_datasource_e *|svn_diff_datasource_e *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_file_ignore_space_t = {"_p_svn_diff_file_ignore_space_t", "enum svn_diff_file_ignore_space_t *|svn_diff_file_ignore_space_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_file_options_t = {"_p_svn_diff_file_options_t", "struct svn_diff_file_options_t *|svn_diff_file_options_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_fns_t = {"_p_svn_diff_fns_t", "struct svn_diff_fns_t *|svn_diff_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_output_fns_t = {"_p_svn_diff_output_fns_t", "struct svn_diff_output_fns_t *|svn_diff_output_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_t = {"_p_svn_diff_t", "struct svn_diff_t *|svn_diff_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_dirent_t = {"_p_svn_dirent_t", "struct svn_dirent_t *|svn_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_errno_t = {"_p_svn_errno_t", "enum svn_errno_t *|svn_errno_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_error_t = {"_p_svn_error_t", "struct svn_error_t *|svn_error_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_dirent_t = {"_p_svn_io_dirent_t", "struct svn_io_dirent_t *|svn_io_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_file_del_t = {"_p_svn_io_file_del_t", "enum svn_io_file_del_t *|svn_io_file_del_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_lock_t = {"_p_svn_lock_t", "struct svn_lock_t *|svn_lock_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_log_changed_path_t = {"_p_svn_log_changed_path_t", "struct svn_log_changed_path_t *|svn_log_changed_path_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_node_kind_t = {"_p_svn_node_kind_t", "enum svn_node_kind_t *|svn_node_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_t = {"_p_svn_opt_revision_t", "struct svn_opt_revision_t *|svn_opt_revision_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_value_t = {"_p_svn_opt_revision_value_t", "union svn_opt_revision_value_t *|svn_opt_revision_value_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc2_t = {"_p_svn_opt_subcommand_desc2_t", "struct svn_opt_subcommand_desc2_t *|svn_opt_subcommand_desc2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc_t = {"_p_svn_opt_subcommand_desc_t", "struct svn_opt_subcommand_desc_t *|svn_opt_subcommand_desc_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_prop_kind = {"_p_svn_prop_kind", "enum svn_prop_kind *|svn_prop_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_callbacks2_t = {"_p_svn_ra_callbacks2_t", "struct svn_ra_callbacks2_t *|svn_ra_callbacks2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_callbacks_t = {"_p_svn_ra_callbacks_t", "struct svn_ra_callbacks_t *|svn_ra_callbacks_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_plugin_t = {"_p_svn_ra_plugin_t", "struct svn_ra_plugin_t *|svn_ra_plugin_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_reporter2_t = {"_p_svn_ra_reporter2_t", "struct svn_ra_reporter2_t *|svn_ra_reporter2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_reporter_t = {"_p_svn_ra_reporter_t", "struct svn_ra_reporter_t *|svn_ra_reporter_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_session_t = {"_p_svn_ra_session_t", "struct svn_ra_session_t *|svn_ra_session_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stream_t = {"_p_svn_stream_t", "struct svn_stream_t *|svn_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_string_t = {"_p_svn_string_t", "struct svn_string_t *|svn_string_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stringbuf_t = {"_p_svn_stringbuf_t", "struct svn_stringbuf_t *|svn_stringbuf_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_op_t = {"_p_svn_txdelta_op_t", "struct svn_txdelta_op_t *|svn_txdelta_op_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_stream_t = {"_p_svn_txdelta_stream_t", "struct svn_txdelta_stream_t *|svn_txdelta_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_window_t = {"_p_svn_txdelta_window_t", "struct svn_txdelta_window_t *|svn_txdelta_window_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_checklist_t = {"_p_svn_version_checklist_t", "struct svn_version_checklist_t *|svn_version_checklist_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_t = {"_p_svn_version_t", "struct svn_version_t *|svn_version_t *", 0, 0, 0};
static swig_type_info _swigt__p_void = {"_p_void", "void *", 0, 0, 0};

static swig_type_info *swig_type_initial[] = {
  &_swigt__p_apr_array_header_t,
  &_swigt__p_apr_file_t,
  &_swigt__p_apr_hash_t,
  &_swigt__p_apr_int32_t,
  &_swigt__p_apr_int64_t,
  &_swigt__p_apr_pool_t,
  &_swigt__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void,
  &_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t,
  &_swigt__p_f_void__p_svn_version_t,
  &_swigt__p_int,
  &_swigt__p_long,
  &_swigt__p_p_apr_file_t,
  &_swigt__p_p_apr_hash_t,
  &_swigt__p_p_char,
  &_swigt__p_p_svn_delta_editor_t,
  &_swigt__p_p_svn_dirent_t,
  &_swigt__p_p_svn_lock_t,
  &_swigt__p_p_svn_ra_callbacks2_t,
  &_swigt__p_p_svn_ra_plugin_t,
  &_swigt__p_p_svn_ra_reporter2_t,
  &_swigt__p_p_svn_ra_reporter_t,
  &_swigt__p_p_svn_ra_session_t,
  &_swigt__p_p_svn_string_t,
  &_swigt__p_p_svn_stringbuf_t,
  &_swigt__p_p_void,
  &_swigt__p_svn_auth_baton_t,
  &_swigt__p_svn_auth_cred_simple_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_pw_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_t,
  &_swigt__p_svn_auth_cred_ssl_server_trust_t,
  &_swigt__p_svn_auth_cred_username_t,
  &_swigt__p_svn_auth_iterstate_t,
  &_swigt__p_svn_auth_provider_object_t,
  &_swigt__p_svn_auth_provider_t,
  &_swigt__p_svn_auth_ssl_server_cert_info_t,
  &_swigt__p_svn_commit_info_t,
  &_swigt__p_svn_config_t,
  &_swigt__p_svn_delta_editor_t,
  &_swigt__p_svn_diff_datasource_e,
  &_swigt__p_svn_diff_file_ignore_space_t,
  &_swigt__p_svn_diff_file_options_t,
  &_swigt__p_svn_diff_fns_t,
  &_swigt__p_svn_diff_output_fns_t,
  &_swigt__p_svn_diff_t,
  &_swigt__p_svn_dirent_t,
  &_swigt__p_svn_errno_t,
  &_swigt__p_svn_error_t,
  &_swigt__p_svn_io_dirent_t,
  &_swigt__p_svn_io_file_del_t,
  &_swigt__p_svn_lock_t,
  &_swigt__p_svn_log_changed_path_t,
  &_swigt__p_svn_node_kind_t,
  &_swigt__p_svn_opt_revision_t,
  &_swigt__p_svn_opt_revision_value_t,
  &_swigt__p_svn_opt_subcommand_desc2_t,
  &_swigt__p_svn_opt_subcommand_desc_t,
  &_swigt__p_svn_prop_kind,
  &_swigt__p_svn_ra_callbacks2_t,
  &_swigt__p_svn_ra_callbacks_t,
  &_swigt__p_svn_ra_plugin_t,
  &_swigt__p_svn_ra_reporter2_t,
  &_swigt__p_svn_ra_reporter_t,
  &_swigt__p_svn_ra_session_t,
  &_swigt__p_svn_stream_t,
  &_swigt__p_svn_string_t,
  &_swigt__p_svn_stringbuf_t,
  &_swigt__p_svn_txdelta_op_t,
  &_swigt__p_svn_txdelta_stream_t,
  &_swigt__p_svn_txdelta_window_t,
  &_swigt__p_svn_version_checklist_t,
  &_swigt__p_svn_version_t,
  &_swigt__p_void,
};

static swig_cast_info _swigc__p_apr_array_header_t[] = {  {&_swigt__p_apr_array_header_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_file_t[] = {  {&_swigt__p_apr_file_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_hash_t[] = {  {&_swigt__p_apr_hash_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int32_t[] = {  {&_swigt__p_apr_int32_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int64_t[] = {  {&_swigt__p_apr_int64_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_pool_t[] = {  {&_swigt__p_apr_pool_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void[] = {  {&_swigt__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t[] = {  {&_swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_void__p_svn_version_t[] = {  {&_swigt__p_f_void__p_svn_version_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_int[] = {  {&_swigt__p_int, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_long[] = {  {&_swigt__p_long, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_apr_file_t[] = {  {&_swigt__p_p_apr_file_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_apr_hash_t[] = {  {&_swigt__p_p_apr_hash_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_char[] = {  {&_swigt__p_p_char, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_delta_editor_t[] = {  {&_swigt__p_p_svn_delta_editor_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_dirent_t[] = {  {&_swigt__p_p_svn_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_lock_t[] = {  {&_swigt__p_p_svn_lock_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_ra_callbacks2_t[] = {  {&_swigt__p_p_svn_ra_callbacks2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_ra_plugin_t[] = {  {&_swigt__p_p_svn_ra_plugin_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_ra_reporter2_t[] = {  {&_swigt__p_p_svn_ra_reporter2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_ra_reporter_t[] = {  {&_swigt__p_p_svn_ra_reporter_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_ra_session_t[] = {  {&_swigt__p_p_svn_ra_session_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_string_t[] = {  {&_swigt__p_p_svn_string_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_stringbuf_t[] = {  {&_swigt__p_p_svn_stringbuf_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_void[] = {  {&_swigt__p_p_void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_baton_t[] = {  {&_swigt__p_svn_auth_baton_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_simple_t[] = {  {&_swigt__p_svn_auth_cred_simple_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_pw_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_pw_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_server_trust_t[] = {  {&_swigt__p_svn_auth_cred_ssl_server_trust_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_username_t[] = {  {&_swigt__p_svn_auth_cred_username_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_iterstate_t[] = {  {&_swigt__p_svn_auth_iterstate_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_object_t[] = {  {&_swigt__p_svn_auth_provider_object_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_t[] = {  {&_swigt__p_svn_auth_provider_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_ssl_server_cert_info_t[] = {  {&_swigt__p_svn_auth_ssl_server_cert_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_commit_info_t[] = {  {&_swigt__p_svn_commit_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_config_t[] = {  {&_swigt__p_svn_config_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_delta_editor_t[] = {  {&_swigt__p_svn_delta_editor_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_datasource_e[] = {  {&_swigt__p_svn_diff_datasource_e, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_file_ignore_space_t[] = {  {&_swigt__p_svn_diff_file_ignore_space_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_file_options_t[] = {  {&_swigt__p_svn_diff_file_options_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_fns_t[] = {  {&_swigt__p_svn_diff_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_output_fns_t[] = {  {&_swigt__p_svn_diff_output_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_t[] = {  {&_swigt__p_svn_diff_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_dirent_t[] = {  {&_swigt__p_svn_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_errno_t[] = {  {&_swigt__p_svn_errno_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_error_t[] = {  {&_swigt__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_dirent_t[] = {  {&_swigt__p_svn_io_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_file_del_t[] = {  {&_swigt__p_svn_io_file_del_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_lock_t[] = {  {&_swigt__p_svn_lock_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_log_changed_path_t[] = {  {&_swigt__p_svn_log_changed_path_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_node_kind_t[] = {  {&_swigt__p_svn_node_kind_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_t[] = {  {&_swigt__p_svn_opt_revision_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_value_t[] = {  {&_swigt__p_svn_opt_revision_value_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc2_t[] = {  {&_swigt__p_svn_opt_subcommand_desc2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc_t[] = {  {&_swigt__p_svn_opt_subcommand_desc_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_prop_kind[] = {  {&_swigt__p_svn_prop_kind, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_callbacks2_t[] = {  {&_swigt__p_svn_ra_callbacks2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_callbacks_t[] = {  {&_swigt__p_svn_ra_callbacks_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_plugin_t[] = {  {&_swigt__p_svn_ra_plugin_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_reporter2_t[] = {  {&_swigt__p_svn_ra_reporter2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_reporter_t[] = {  {&_swigt__p_svn_ra_reporter_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_session_t[] = {  {&_swigt__p_svn_ra_session_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stream_t[] = {  {&_swigt__p_svn_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_string_t[] = {  {&_swigt__p_svn_string_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stringbuf_t[] = {  {&_swigt__p_svn_stringbuf_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_op_t[] = {  {&_swigt__p_svn_txdelta_op_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_stream_t[] = {  {&_swigt__p_svn_txdelta_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_window_t[] = {  {&_swigt__p_svn_txdelta_window_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_checklist_t[] = {  {&_swigt__p_svn_version_checklist_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_t[] = {  {&_swigt__p_svn_version_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_void[] = {  {&_swigt__p_void, 0, 0, 0},{0, 0, 0, 0}};

static swig_cast_info *swig_cast_initial[] = {
  _swigc__p_apr_array_header_t,
  _swigc__p_apr_file_t,
  _swigc__p_apr_hash_t,
  _swigc__p_apr_int32_t,
  _swigc__p_apr_int64_t,
  _swigc__p_apr_pool_t,
  _swigc__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void,
  _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t,
  _swigc__p_f_void__p_svn_version_t,
  _swigc__p_int,
  _swigc__p_long,
  _swigc__p_p_apr_file_t,
  _swigc__p_p_apr_hash_t,
  _swigc__p_p_char,
  _swigc__p_p_svn_delta_editor_t,
  _swigc__p_p_svn_dirent_t,
  _swigc__p_p_svn_lock_t,
  _swigc__p_p_svn_ra_callbacks2_t,
  _swigc__p_p_svn_ra_plugin_t,
  _swigc__p_p_svn_ra_reporter2_t,
  _swigc__p_p_svn_ra_reporter_t,
  _swigc__p_p_svn_ra_session_t,
  _swigc__p_p_svn_string_t,
  _swigc__p_p_svn_stringbuf_t,
  _swigc__p_p_void,
  _swigc__p_svn_auth_baton_t,
  _swigc__p_svn_auth_cred_simple_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_pw_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_t,
  _swigc__p_svn_auth_cred_ssl_server_trust_t,
  _swigc__p_svn_auth_cred_username_t,
  _swigc__p_svn_auth_iterstate_t,
  _swigc__p_svn_auth_provider_object_t,
  _swigc__p_svn_auth_provider_t,
  _swigc__p_svn_auth_ssl_server_cert_info_t,
  _swigc__p_svn_commit_info_t,
  _swigc__p_svn_config_t,
  _swigc__p_svn_delta_editor_t,
  _swigc__p_svn_diff_datasource_e,
  _swigc__p_svn_diff_file_ignore_space_t,
  _swigc__p_svn_diff_file_options_t,
  _swigc__p_svn_diff_fns_t,
  _swigc__p_svn_diff_output_fns_t,
  _swigc__p_svn_diff_t,
  _swigc__p_svn_dirent_t,
  _swigc__p_svn_errno_t,
  _swigc__p_svn_error_t,
  _swigc__p_svn_io_dirent_t,
  _swigc__p_svn_io_file_del_t,
  _swigc__p_svn_lock_t,
  _swigc__p_svn_log_changed_path_t,
  _swigc__p_svn_node_kind_t,
  _swigc__p_svn_opt_revision_t,
  _swigc__p_svn_opt_revision_value_t,
  _swigc__p_svn_opt_subcommand_desc2_t,
  _swigc__p_svn_opt_subcommand_desc_t,
  _swigc__p_svn_prop_kind,
  _swigc__p_svn_ra_callbacks2_t,
  _swigc__p_svn_ra_callbacks_t,
  _swigc__p_svn_ra_plugin_t,
  _swigc__p_svn_ra_reporter2_t,
  _swigc__p_svn_ra_reporter_t,
  _swigc__p_svn_ra_session_t,
  _swigc__p_svn_stream_t,
  _swigc__p_svn_string_t,
  _swigc__p_svn_stringbuf_t,
  _swigc__p_svn_txdelta_op_t,
  _swigc__p_svn_txdelta_stream_t,
  _swigc__p_svn_txdelta_window_t,
  _swigc__p_svn_version_checklist_t,
  _swigc__p_svn_version_t,
  _swigc__p_void,
};


/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (END) -------- */

static swig_constant_info swig_constants[] = {
{ SWIG_INT,     (char *) SWIG_prefix "SVN_RA_ABI_VERSION", (long) 2, 0, 0, 0},
{0,0,0,0,0,0}
};
#ifdef __cplusplus
}
#endif
static swig_variable_info swig_variables[] = {
{0,0,0,0}
};
static swig_command_info swig_commands[] = {
{"SVN::_Ra::svn_ra_version", _wrap_svn_ra_version},
{"SVN::_Ra::svn_ra_reporter2_t_set_path_set", _wrap_svn_ra_reporter2_t_set_path_set},
{"SVN::_Ra::svn_ra_reporter2_t_set_path_get", _wrap_svn_ra_reporter2_t_set_path_get},
{"SVN::_Ra::svn_ra_reporter2_t_delete_path_set", _wrap_svn_ra_reporter2_t_delete_path_set},
{"SVN::_Ra::svn_ra_reporter2_t_delete_path_get", _wrap_svn_ra_reporter2_t_delete_path_get},
{"SVN::_Ra::svn_ra_reporter2_t_link_path_set", _wrap_svn_ra_reporter2_t_link_path_set},
{"SVN::_Ra::svn_ra_reporter2_t_link_path_get", _wrap_svn_ra_reporter2_t_link_path_get},
{"SVN::_Ra::svn_ra_reporter2_t_finish_report_set", _wrap_svn_ra_reporter2_t_finish_report_set},
{"SVN::_Ra::svn_ra_reporter2_t_finish_report_get", _wrap_svn_ra_reporter2_t_finish_report_get},
{"SVN::_Ra::svn_ra_reporter2_t_abort_report_set", _wrap_svn_ra_reporter2_t_abort_report_set},
{"SVN::_Ra::svn_ra_reporter2_t_abort_report_get", _wrap_svn_ra_reporter2_t_abort_report_get},
{"SVN::_Ra::new_svn_ra_reporter2_t", _wrap_new_svn_ra_reporter2_t},
{"SVN::_Ra::delete_svn_ra_reporter2_t", _wrap_delete_svn_ra_reporter2_t},
{"SVN::_Ra::svn_ra_reporter_t_set_path_set", _wrap_svn_ra_reporter_t_set_path_set},
{"SVN::_Ra::svn_ra_reporter_t_set_path_get", _wrap_svn_ra_reporter_t_set_path_get},
{"SVN::_Ra::svn_ra_reporter_t_delete_path_set", _wrap_svn_ra_reporter_t_delete_path_set},
{"SVN::_Ra::svn_ra_reporter_t_delete_path_get", _wrap_svn_ra_reporter_t_delete_path_get},
{"SVN::_Ra::svn_ra_reporter_t_link_path_set", _wrap_svn_ra_reporter_t_link_path_set},
{"SVN::_Ra::svn_ra_reporter_t_link_path_get", _wrap_svn_ra_reporter_t_link_path_get},
{"SVN::_Ra::svn_ra_reporter_t_finish_report_set", _wrap_svn_ra_reporter_t_finish_report_set},
{"SVN::_Ra::svn_ra_reporter_t_finish_report_get", _wrap_svn_ra_reporter_t_finish_report_get},
{"SVN::_Ra::svn_ra_reporter_t_abort_report_set", _wrap_svn_ra_reporter_t_abort_report_set},
{"SVN::_Ra::svn_ra_reporter_t_abort_report_get", _wrap_svn_ra_reporter_t_abort_report_get},
{"SVN::_Ra::new_svn_ra_reporter_t", _wrap_new_svn_ra_reporter_t},
{"SVN::_Ra::delete_svn_ra_reporter_t", _wrap_delete_svn_ra_reporter_t},
{"SVN::_Ra::svn_ra_callbacks2_t_open_tmp_file_set", _wrap_svn_ra_callbacks2_t_open_tmp_file_set},
{"SVN::_Ra::svn_ra_callbacks2_t_open_tmp_file_get", _wrap_svn_ra_callbacks2_t_open_tmp_file_get},
{"SVN::_Ra::svn_ra_callbacks2_t_auth_baton_set", _wrap_svn_ra_callbacks2_t_auth_baton_set},
{"SVN::_Ra::svn_ra_callbacks2_t_auth_baton_get", _wrap_svn_ra_callbacks2_t_auth_baton_get},
{"SVN::_Ra::svn_ra_callbacks2_t_get_wc_prop_set", _wrap_svn_ra_callbacks2_t_get_wc_prop_set},
{"SVN::_Ra::svn_ra_callbacks2_t_get_wc_prop_get", _wrap_svn_ra_callbacks2_t_get_wc_prop_get},
{"SVN::_Ra::svn_ra_callbacks2_t_set_wc_prop_set", _wrap_svn_ra_callbacks2_t_set_wc_prop_set},
{"SVN::_Ra::svn_ra_callbacks2_t_set_wc_prop_get", _wrap_svn_ra_callbacks2_t_set_wc_prop_get},
{"SVN::_Ra::svn_ra_callbacks2_t_push_wc_prop_set", _wrap_svn_ra_callbacks2_t_push_wc_prop_set},
{"SVN::_Ra::svn_ra_callbacks2_t_push_wc_prop_get", _wrap_svn_ra_callbacks2_t_push_wc_prop_get},
{"SVN::_Ra::svn_ra_callbacks2_t_invalidate_wc_props_set", _wrap_svn_ra_callbacks2_t_invalidate_wc_props_set},
{"SVN::_Ra::svn_ra_callbacks2_t_invalidate_wc_props_get", _wrap_svn_ra_callbacks2_t_invalidate_wc_props_get},
{"SVN::_Ra::svn_ra_callbacks2_t_progress_func_set", _wrap_svn_ra_callbacks2_t_progress_func_set},
{"SVN::_Ra::svn_ra_callbacks2_t_progress_func_get", _wrap_svn_ra_callbacks2_t_progress_func_get},
{"SVN::_Ra::svn_ra_callbacks2_t_progress_baton_set", _wrap_svn_ra_callbacks2_t_progress_baton_set},
{"SVN::_Ra::svn_ra_callbacks2_t_progress_baton_get", _wrap_svn_ra_callbacks2_t_progress_baton_get},
{"SVN::_Ra::new_svn_ra_callbacks2_t", _wrap_new_svn_ra_callbacks2_t},
{"SVN::_Ra::delete_svn_ra_callbacks2_t", _wrap_delete_svn_ra_callbacks2_t},
{"SVN::_Ra::svn_ra_callbacks_t_open_tmp_file_set", _wrap_svn_ra_callbacks_t_open_tmp_file_set},
{"SVN::_Ra::svn_ra_callbacks_t_open_tmp_file_get", _wrap_svn_ra_callbacks_t_open_tmp_file_get},
{"SVN::_Ra::svn_ra_callbacks_t_auth_baton_set", _wrap_svn_ra_callbacks_t_auth_baton_set},
{"SVN::_Ra::svn_ra_callbacks_t_auth_baton_get", _wrap_svn_ra_callbacks_t_auth_baton_get},
{"SVN::_Ra::svn_ra_callbacks_t_get_wc_prop_set", _wrap_svn_ra_callbacks_t_get_wc_prop_set},
{"SVN::_Ra::svn_ra_callbacks_t_get_wc_prop_get", _wrap_svn_ra_callbacks_t_get_wc_prop_get},
{"SVN::_Ra::svn_ra_callbacks_t_set_wc_prop_set", _wrap_svn_ra_callbacks_t_set_wc_prop_set},
{"SVN::_Ra::svn_ra_callbacks_t_set_wc_prop_get", _wrap_svn_ra_callbacks_t_set_wc_prop_get},
{"SVN::_Ra::svn_ra_callbacks_t_push_wc_prop_set", _wrap_svn_ra_callbacks_t_push_wc_prop_set},
{"SVN::_Ra::svn_ra_callbacks_t_push_wc_prop_get", _wrap_svn_ra_callbacks_t_push_wc_prop_get},
{"SVN::_Ra::svn_ra_callbacks_t_invalidate_wc_props_set", _wrap_svn_ra_callbacks_t_invalidate_wc_props_set},
{"SVN::_Ra::svn_ra_callbacks_t_invalidate_wc_props_get", _wrap_svn_ra_callbacks_t_invalidate_wc_props_get},
{"SVN::_Ra::new_svn_ra_callbacks_t", _wrap_new_svn_ra_callbacks_t},
{"SVN::_Ra::delete_svn_ra_callbacks_t", _wrap_delete_svn_ra_callbacks_t},
{"SVN::_Ra::svn_ra_initialize", _wrap_svn_ra_initialize},
{"SVN::_Ra::svn_ra_create_callbacks", _wrap_svn_ra_create_callbacks},
{"SVN::_Ra::svn_ra_open2", _wrap_svn_ra_open2},
{"SVN::_Ra::svn_ra_open", _wrap_svn_ra_open},
{"SVN::_Ra::svn_ra_reparent", _wrap_svn_ra_reparent},
{"SVN::_Ra::svn_ra_get_latest_revnum", _wrap_svn_ra_get_latest_revnum},
{"SVN::_Ra::svn_ra_get_dated_revision", _wrap_svn_ra_get_dated_revision},
{"SVN::_Ra::svn_ra_change_rev_prop", _wrap_svn_ra_change_rev_prop},
{"SVN::_Ra::svn_ra_rev_proplist", _wrap_svn_ra_rev_proplist},
{"SVN::_Ra::svn_ra_rev_prop", _wrap_svn_ra_rev_prop},
{"SVN::_Ra::svn_ra_get_commit_editor2", _wrap_svn_ra_get_commit_editor2},
{"SVN::_Ra::svn_ra_get_commit_editor", _wrap_svn_ra_get_commit_editor},
{"SVN::_Ra::svn_ra_get_file", _wrap_svn_ra_get_file},
{"SVN::_Ra::svn_ra_get_dir2", _wrap_svn_ra_get_dir2},
{"SVN::_Ra::svn_ra_get_dir", _wrap_svn_ra_get_dir},
{"SVN::_Ra::svn_ra_do_update", _wrap_svn_ra_do_update},
{"SVN::_Ra::svn_ra_do_switch", _wrap_svn_ra_do_switch},
{"SVN::_Ra::svn_ra_do_status", _wrap_svn_ra_do_status},
{"SVN::_Ra::svn_ra_do_diff2", _wrap_svn_ra_do_diff2},
{"SVN::_Ra::svn_ra_do_diff", _wrap_svn_ra_do_diff},
{"SVN::_Ra::svn_ra_get_log", _wrap_svn_ra_get_log},
{"SVN::_Ra::svn_ra_check_path", _wrap_svn_ra_check_path},
{"SVN::_Ra::svn_ra_stat", _wrap_svn_ra_stat},
{"SVN::_Ra::svn_ra_get_uuid", _wrap_svn_ra_get_uuid},
{"SVN::_Ra::svn_ra_get_repos_root", _wrap_svn_ra_get_repos_root},
{"SVN::_Ra::svn_ra_get_locations", _wrap_svn_ra_get_locations},
{"SVN::_Ra::svn_ra_get_file_revs", _wrap_svn_ra_get_file_revs},
{"SVN::_Ra::svn_ra_lock", _wrap_svn_ra_lock},
{"SVN::_Ra::svn_ra_unlock", _wrap_svn_ra_unlock},
{"SVN::_Ra::svn_ra_get_lock", _wrap_svn_ra_get_lock},
{"SVN::_Ra::svn_ra_get_locks", _wrap_svn_ra_get_locks},
{"SVN::_Ra::svn_ra_replay", _wrap_svn_ra_replay},
{"SVN::_Ra::svn_ra_print_modules", _wrap_svn_ra_print_modules},
{"SVN::_Ra::svn_ra_print_ra_libraries", _wrap_svn_ra_print_ra_libraries},
{"SVN::_Ra::svn_ra_plugin_t_name_set", _wrap_svn_ra_plugin_t_name_set},
{"SVN::_Ra::svn_ra_plugin_t_name_get", _wrap_svn_ra_plugin_t_name_get},
{"SVN::_Ra::svn_ra_plugin_t_description_set", _wrap_svn_ra_plugin_t_description_set},
{"SVN::_Ra::svn_ra_plugin_t_description_get", _wrap_svn_ra_plugin_t_description_get},
{"SVN::_Ra::svn_ra_plugin_t_open_set", _wrap_svn_ra_plugin_t_open_set},
{"SVN::_Ra::svn_ra_plugin_t_open_get", _wrap_svn_ra_plugin_t_open_get},
{"SVN::_Ra::svn_ra_plugin_t_get_latest_revnum_set", _wrap_svn_ra_plugin_t_get_latest_revnum_set},
{"SVN::_Ra::svn_ra_plugin_t_get_latest_revnum_get", _wrap_svn_ra_plugin_t_get_latest_revnum_get},
{"SVN::_Ra::svn_ra_plugin_t_get_dated_revision_set", _wrap_svn_ra_plugin_t_get_dated_revision_set},
{"SVN::_Ra::svn_ra_plugin_t_get_dated_revision_get", _wrap_svn_ra_plugin_t_get_dated_revision_get},
{"SVN::_Ra::svn_ra_plugin_t_change_rev_prop_set", _wrap_svn_ra_plugin_t_change_rev_prop_set},
{"SVN::_Ra::svn_ra_plugin_t_change_rev_prop_get", _wrap_svn_ra_plugin_t_change_rev_prop_get},
{"SVN::_Ra::svn_ra_plugin_t_rev_proplist_set", _wrap_svn_ra_plugin_t_rev_proplist_set},
{"SVN::_Ra::svn_ra_plugin_t_rev_proplist_get", _wrap_svn_ra_plugin_t_rev_proplist_get},
{"SVN::_Ra::svn_ra_plugin_t_rev_prop_set", _wrap_svn_ra_plugin_t_rev_prop_set},
{"SVN::_Ra::svn_ra_plugin_t_rev_prop_get", _wrap_svn_ra_plugin_t_rev_prop_get},
{"SVN::_Ra::svn_ra_plugin_t_get_commit_editor_set", _wrap_svn_ra_plugin_t_get_commit_editor_set},
{"SVN::_Ra::svn_ra_plugin_t_get_commit_editor_get", _wrap_svn_ra_plugin_t_get_commit_editor_get},
{"SVN::_Ra::svn_ra_plugin_t_get_file_set", _wrap_svn_ra_plugin_t_get_file_set},
{"SVN::_Ra::svn_ra_plugin_t_get_file_get", _wrap_svn_ra_plugin_t_get_file_get},
{"SVN::_Ra::svn_ra_plugin_t_get_dir_set", _wrap_svn_ra_plugin_t_get_dir_set},
{"SVN::_Ra::svn_ra_plugin_t_get_dir_get", _wrap_svn_ra_plugin_t_get_dir_get},
{"SVN::_Ra::svn_ra_plugin_t_do_update_set", _wrap_svn_ra_plugin_t_do_update_set},
{"SVN::_Ra::svn_ra_plugin_t_do_update_get", _wrap_svn_ra_plugin_t_do_update_get},
{"SVN::_Ra::svn_ra_plugin_t_do_switch_set", _wrap_svn_ra_plugin_t_do_switch_set},
{"SVN::_Ra::svn_ra_plugin_t_do_switch_get", _wrap_svn_ra_plugin_t_do_switch_get},
{"SVN::_Ra::svn_ra_plugin_t_do_status_set", _wrap_svn_ra_plugin_t_do_status_set},
{"SVN::_Ra::svn_ra_plugin_t_do_status_get", _wrap_svn_ra_plugin_t_do_status_get},
{"SVN::_Ra::svn_ra_plugin_t_do_diff_set", _wrap_svn_ra_plugin_t_do_diff_set},
{"SVN::_Ra::svn_ra_plugin_t_do_diff_get", _wrap_svn_ra_plugin_t_do_diff_get},
{"SVN::_Ra::svn_ra_plugin_t_get_log_set", _wrap_svn_ra_plugin_t_get_log_set},
{"SVN::_Ra::svn_ra_plugin_t_get_log_get", _wrap_svn_ra_plugin_t_get_log_get},
{"SVN::_Ra::svn_ra_plugin_t_check_path_set", _wrap_svn_ra_plugin_t_check_path_set},
{"SVN::_Ra::svn_ra_plugin_t_check_path_get", _wrap_svn_ra_plugin_t_check_path_get},
{"SVN::_Ra::svn_ra_plugin_t_get_uuid_set", _wrap_svn_ra_plugin_t_get_uuid_set},
{"SVN::_Ra::svn_ra_plugin_t_get_uuid_get", _wrap_svn_ra_plugin_t_get_uuid_get},
{"SVN::_Ra::svn_ra_plugin_t_get_repos_root_set", _wrap_svn_ra_plugin_t_get_repos_root_set},
{"SVN::_Ra::svn_ra_plugin_t_get_repos_root_get", _wrap_svn_ra_plugin_t_get_repos_root_get},
{"SVN::_Ra::svn_ra_plugin_t_get_locations_set", _wrap_svn_ra_plugin_t_get_locations_set},
{"SVN::_Ra::svn_ra_plugin_t_get_locations_get", _wrap_svn_ra_plugin_t_get_locations_get},
{"SVN::_Ra::svn_ra_plugin_t_get_file_revs_set", _wrap_svn_ra_plugin_t_get_file_revs_set},
{"SVN::_Ra::svn_ra_plugin_t_get_file_revs_get", _wrap_svn_ra_plugin_t_get_file_revs_get},
{"SVN::_Ra::svn_ra_plugin_t_get_version_set", _wrap_svn_ra_plugin_t_get_version_set},
{"SVN::_Ra::svn_ra_plugin_t_get_version_get", _wrap_svn_ra_plugin_t_get_version_get},
{"SVN::_Ra::new_svn_ra_plugin_t", _wrap_new_svn_ra_plugin_t},
{"SVN::_Ra::delete_svn_ra_plugin_t", _wrap_delete_svn_ra_plugin_t},
{"SVN::_Ra::svn_ra_init_ra_libs", _wrap_svn_ra_init_ra_libs},
{"SVN::_Ra::svn_ra_get_ra_library", _wrap_svn_ra_get_ra_library},
{"SVN::_Ra::svn_ra_reporter2_invoke_set_path", _wrap_svn_ra_reporter2_invoke_set_path},
{"SVN::_Ra::svn_ra_reporter2_invoke_delete_path", _wrap_svn_ra_reporter2_invoke_delete_path},
{"SVN::_Ra::svn_ra_reporter2_invoke_link_path", _wrap_svn_ra_reporter2_invoke_link_path},
{"SVN::_Ra::svn_ra_reporter2_invoke_finish_report", _wrap_svn_ra_reporter2_invoke_finish_report},
{"SVN::_Ra::svn_ra_reporter2_invoke_abort_report", _wrap_svn_ra_reporter2_invoke_abort_report},
{"SVN::_Ra::svn_ra_reporter_invoke_set_path", _wrap_svn_ra_reporter_invoke_set_path},
{"SVN::_Ra::svn_ra_reporter_invoke_delete_path", _wrap_svn_ra_reporter_invoke_delete_path},
{"SVN::_Ra::svn_ra_reporter_invoke_link_path", _wrap_svn_ra_reporter_invoke_link_path},
{"SVN::_Ra::svn_ra_reporter_invoke_finish_report", _wrap_svn_ra_reporter_invoke_finish_report},
{"SVN::_Ra::svn_ra_reporter_invoke_abort_report", _wrap_svn_ra_reporter_invoke_abort_report},
{"SVN::_Ra::svn_ra_callbacks2_invoke_open_tmp_file", _wrap_svn_ra_callbacks2_invoke_open_tmp_file},
{"SVN::_Ra::svn_ra_callbacks_invoke_open_tmp_file", _wrap_svn_ra_callbacks_invoke_open_tmp_file},
{"SVN::_Ra::svn_ra_plugin_invoke_open", _wrap_svn_ra_plugin_invoke_open},
{"SVN::_Ra::svn_ra_plugin_invoke_get_latest_revnum", _wrap_svn_ra_plugin_invoke_get_latest_revnum},
{"SVN::_Ra::svn_ra_plugin_invoke_get_dated_revision", _wrap_svn_ra_plugin_invoke_get_dated_revision},
{"SVN::_Ra::svn_ra_plugin_invoke_change_rev_prop", _wrap_svn_ra_plugin_invoke_change_rev_prop},
{"SVN::_Ra::svn_ra_plugin_invoke_rev_proplist", _wrap_svn_ra_plugin_invoke_rev_proplist},
{"SVN::_Ra::svn_ra_plugin_invoke_rev_prop", _wrap_svn_ra_plugin_invoke_rev_prop},
{"SVN::_Ra::svn_ra_plugin_invoke_get_commit_editor", _wrap_svn_ra_plugin_invoke_get_commit_editor},
{"SVN::_Ra::svn_ra_plugin_invoke_get_file", _wrap_svn_ra_plugin_invoke_get_file},
{"SVN::_Ra::svn_ra_plugin_invoke_get_dir", _wrap_svn_ra_plugin_invoke_get_dir},
{"SVN::_Ra::svn_ra_plugin_invoke_do_update", _wrap_svn_ra_plugin_invoke_do_update},
{"SVN::_Ra::svn_ra_plugin_invoke_do_switch", _wrap_svn_ra_plugin_invoke_do_switch},
{"SVN::_Ra::svn_ra_plugin_invoke_do_status", _wrap_svn_ra_plugin_invoke_do_status},
{"SVN::_Ra::svn_ra_plugin_invoke_do_diff", _wrap_svn_ra_plugin_invoke_do_diff},
{"SVN::_Ra::svn_ra_plugin_invoke_get_log", _wrap_svn_ra_plugin_invoke_get_log},
{"SVN::_Ra::svn_ra_plugin_invoke_check_path", _wrap_svn_ra_plugin_invoke_check_path},
{"SVN::_Ra::svn_ra_plugin_invoke_get_uuid", _wrap_svn_ra_plugin_invoke_get_uuid},
{"SVN::_Ra::svn_ra_plugin_invoke_get_repos_root", _wrap_svn_ra_plugin_invoke_get_repos_root},
{"SVN::_Ra::svn_ra_plugin_invoke_get_locations", _wrap_svn_ra_plugin_invoke_get_locations},
{"SVN::_Ra::svn_ra_plugin_invoke_get_file_revs", _wrap_svn_ra_plugin_invoke_get_file_revs},
{0,0}
};
/*************************************************************************
 * Type initialization:
 * This problem is tough by the requirement that no dynamic 
 * memory is used. Also, since swig_type_info structures store pointers to 
 * swig_cast_info structures and swig_cast_info structures store pointers back
 * to swig_type_info structures, we need some lookup code at initialization. 
 * The idea is that swig generates all the structures that are needed. 
 * The runtime then collects these partially filled structures. 
 * The SWIG_InitializeModule function takes these initial arrays out of 
 * swig_module, and does all the lookup, filling in the swig_module.types
 * array with the correct data and linking the correct swig_cast_info
 * structures together.

 * The generated swig_type_info structures are assigned staticly to an initial 
 * array. We just loop though that array, and handle each type individually.
 * First we lookup if this type has been already loaded, and if so, use the
 * loaded structure instead of the generated one. Then we have to fill in the
 * cast linked list. The cast data is initially stored in something like a
 * two-dimensional array. Each row corresponds to a type (there are the same
 * number of rows as there are in the swig_type_initial array). Each entry in
 * a column is one of the swig_cast_info structures for that type.
 * The cast_initial array is actually an array of arrays, because each row has
 * a variable number of columns. So to actually build the cast linked list,
 * we find the array of casts associated with the type, and loop through it 
 * adding the casts to the list. The one last trick we need to do is making
 * sure the type pointer in the swig_cast_info struct is correct.

 * First off, we lookup the cast->type name to see if it is already loaded. 
 * There are three cases to handle:
 *  1) If the cast->type has already been loaded AND the type we are adding
 *     casting info to has not been loaded (it is in this module), THEN we
 *     replace the cast->type pointer with the type pointer that has already
 *     been loaded.
 *  2) If BOTH types (the one we are adding casting info to, and the 
 *     cast->type) are loaded, THEN the cast info has already been loaded by
 *     the previous module so we just ignore it.
 *  3) Finally, if cast->type has not already been loaded, then we add that
 *     swig_cast_info to the linked list (because the cast->type) pointer will
 *     be correct.
**/

#ifdef __cplusplus
extern "C" {
#endif
    
    SWIGRUNTIME void
    SWIG_InitializeModule(void *clientdata) {
        swig_type_info *type, *ret;
        swig_cast_info *cast;
        size_t i;
        swig_module_info *module_head;
        static int init_run = 0;
        
        clientdata = clientdata;
        
        if (init_run) return;
        init_run = 1;
        
        /* Initialize the swig_module */
        swig_module.type_initial = swig_type_initial;
        swig_module.cast_initial = swig_cast_initial;
        
        /* Try and load any already created modules */
        module_head = SWIG_GetModule(clientdata);
        if (module_head) {
            swig_module.next = module_head->next;
            module_head->next = &swig_module;
        } else {
            /* This is the first module loaded */
            swig_module.next = &swig_module;
            SWIG_SetModule(clientdata, &swig_module);
        }
        
        /* Now work on filling in swig_module.types */
        for (i = 0; i < swig_module.size; ++i) {
            type = 0;
            
            /* if there is another module already loaded */
            if (swig_module.next != &swig_module) {
                type = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, swig_module.type_initial[i]->name);
            }
            if (type) {
                /* Overwrite clientdata field */
                if (swig_module.type_initial[i]->clientdata) type->clientdata = swig_module.type_initial[i]->clientdata;
            } else {
                type = swig_module.type_initial[i];
            }
            
            /* Insert casting types */
            cast = swig_module.cast_initial[i];
            while (cast->type) {
                /* Don't need to add information already in the list */
                ret = 0;
                if (swig_module.next != &swig_module) {
                    ret = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, cast->type->name);
                }
                if (ret && type == swig_module.type_initial[i]) {
                    cast->type = ret;
                    ret = 0;
                }
                
                if (!ret) {
                    if (type->cast) {
                        type->cast->prev = cast;
                        cast->next = type->cast;
                    }
                    type->cast = cast;
                }
                
                cast++;
            }
            
            /* Set entry in modules->types array equal to the type */
            swig_module.types[i] = type;
        }
    }
    
    /* This function will propagate the clientdata field of type to
    * any new swig_type_info structures that have been added into the list
    * of equivalent types.  It is like calling
    * SWIG_TypeClientData(type, clientdata) a second time.
    */
    SWIGRUNTIME void
    SWIG_PropagateClientData(void) {
        size_t i;
        swig_cast_info *equiv;
        static int init_run = 0;
        
        if (init_run) return;
        init_run = 1;
        
        for (i = 0; i < swig_module.size; i++) {
            if (swig_module.types[i]->clientdata) {
                equiv = swig_module.types[i]->cast;
                while (equiv) {
                    if (!equiv->converter) {
                        if (equiv->type && !equiv->type->clientdata)
                        SWIG_TypeClientData(equiv->type, swig_module.types[i]->clientdata);
                    }
                    equiv = equiv->next;
                }
            }
        }
    }
    
#ifdef __cplusplus
}
#endif



#ifdef __cplusplus
extern "C"
#endif

XS(SWIG_init) {
    dXSARGS;
    int i;
    
    SWIG_InitializeModule(0);
    
    /* Install commands */
    for (i = 0; swig_commands[i].name; i++) {
        newXS((char*) swig_commands[i].name,swig_commands[i].wrapper, (char*)__FILE__);
    }
    
    /* Install variables */
    for (i = 0; swig_variables[i].name; i++) {
        SV *sv;
        sv = perl_get_sv((char*) swig_variables[i].name, TRUE | 0x2);
        if (swig_variables[i].type) {
            SWIG_MakePtr(sv,(void *)1, *swig_variables[i].type,0);
        } else {
            sv_setiv(sv,(IV) 0);
        }
        swig_create_magic(sv, (char *) swig_variables[i].name, swig_variables[i].set, swig_variables[i].get); 
    }
    
    /* Install constant */
    for (i = 0; swig_constants[i].type; i++) {
        SV *sv;
        sv = perl_get_sv((char*)swig_constants[i].name, TRUE | 0x2);
        switch(swig_constants[i].type) {
            case SWIG_INT:
            sv_setiv(sv, (IV) swig_constants[i].lvalue);
            break;
            case SWIG_FLOAT:
            sv_setnv(sv, (double) swig_constants[i].dvalue);
            break;
            case SWIG_STRING:
            sv_setpv(sv, (char *) swig_constants[i].pvalue);
            break;
            case SWIG_POINTER:
            SWIG_MakePtr(sv, swig_constants[i].pvalue, *(swig_constants[i].ptype),0);
            break;
            case SWIG_BINARY:
            SWIG_MakePackedObj(sv, swig_constants[i].pvalue, swig_constants[i].lvalue, *(swig_constants[i].ptype));
            break;
            default:
            break;
        }
        SvREADONLY_on(sv);
    }
    
    ST(0) = &PL_sv_yes;
    XSRETURN(1);
}

