/* ----------------------------------------------------------------------------
 * This file was automatically generated by SWIG (http://www.swig.org).
 * Version 1.3.25
 * 
 * This file is not intended to be easily readable and contains a number of 
 * coding conventions designed to improve portability and efficiency. Do not make
 * changes to this file unless you know what you are doing--modify the SWIG 
 * interface file instead. 
 * ----------------------------------------------------------------------------- */

/***********************************************************************
 *
 *  This section contains generic SWIG labels for method/variable
 *  declarations/attributes, and other compiler dependent labels.
 *
 ************************************************************************/

/* template workaround for compilers that cannot correctly implement the C++ standard */
#ifndef SWIGTEMPLATEDISAMBIGUATOR
#  if defined(__SUNPRO_CC) && (__SUNPRO_CC <= 0x560)
#    define SWIGTEMPLATEDISAMBIGUATOR template
#  else
#    define SWIGTEMPLATEDISAMBIGUATOR 
#  endif
#endif

/* inline attribute */
#ifndef SWIGINLINE
# if defined(__cplusplus) || (defined(__GNUC__) && !defined(__STRICT_ANSI__))
#   define SWIGINLINE inline
# else
#   define SWIGINLINE
# endif
#endif

/* attribute recognised by some compilers to avoid 'unused' warnings */
#ifndef SWIGUNUSED
# if defined(__GNUC__) || defined(__ICC)
#   define SWIGUNUSED __attribute__ ((unused)) 
# else
#   define SWIGUNUSED 
# endif
#endif

/* internal SWIG method */
#ifndef SWIGINTERN
# define SWIGINTERN static SWIGUNUSED
#endif

/* internal inline SWIG method */
#ifndef SWIGINTERNINLINE
# define SWIGINTERNINLINE SWIGINTERN SWIGINLINE
#endif

/* exporting methods for Windows DLLs */
#ifndef SWIGEXPORT
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   if defined(STATIC_LINKED)
#     define SWIGEXPORT
#   else
#     define SWIGEXPORT __declspec(dllexport)
#   endif
# else
#   define SWIGEXPORT
# endif
#endif

/* calling conventions for Windows */
#ifndef SWIGSTDCALL
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   define SWIGSTDCALL __stdcall
# else
#   define SWIGSTDCALL
# endif 
#endif


/* ruby.swg */
/* Implementation : RUBY */
#define SWIGRUBY 1

#include "ruby.h"

/* Flags for pointer conversion */
#define SWIG_POINTER_EXCEPTION     0x1
#define SWIG_POINTER_DISOWN        0x2

#define NUM2USHRT(n) (\
    (0 <= NUM2UINT(n) && NUM2UINT(n) <= USHRT_MAX)\
    ? (unsigned short) NUM2UINT(n) \
    : (rb_raise(rb_eArgError, "integer %d out of range of `unsigned short'",\
               NUM2UINT(n)), (short)0)\
)

#define NUM2SHRT(n) (\
    (SHRT_MIN <= NUM2INT(n) && NUM2INT(n) <= SHRT_MAX)\
    ? (short)NUM2INT(n)\
    : (rb_raise(rb_eArgError, "integer %d out of range of `short'",\
               NUM2INT(n)), (short)0)\
)

/* Ruby 1.7 defines NUM2LL(), LL2NUM() and ULL2NUM() macros */
#ifndef NUM2LL
#define NUM2LL(x) NUM2LONG((x))
#endif
#ifndef LL2NUM
#define LL2NUM(x) INT2NUM((long) (x))
#endif
#ifndef ULL2NUM
#define ULL2NUM(x) UINT2NUM((unsigned long) (x))
#endif

/* Ruby 1.7 doesn't (yet) define NUM2ULL() */
#ifndef NUM2ULL
#ifdef HAVE_LONG_LONG
#define NUM2ULL(x) rb_num2ull((x))
#else
#define NUM2ULL(x) NUM2ULONG(x)
#endif
#endif

/*
 * Need to be very careful about how these macros are defined, especially
 * when compiling C++ code or C code with an ANSI C compiler.
 *
 * VALUEFUNC(f) is a macro used to typecast a C function that implements
 * a Ruby method so that it can be passed as an argument to API functions
 * like rb_define_method() and rb_define_singleton_method().
 *
 * VOIDFUNC(f) is a macro used to typecast a C function that implements
 * either the "mark" or "free" stuff for a Ruby Data object, so that it
 * can be passed as an argument to API functions like Data_Wrap_Struct()
 * and Data_Make_Struct().
 */
 
#ifdef __cplusplus
#  ifndef RUBY_METHOD_FUNC /* These definitions should work for Ruby 1.4.6 */
#    define PROTECTFUNC(f) ((VALUE (*)()) f)
#    define VALUEFUNC(f) ((VALUE (*)()) f)
#    define VOIDFUNC(f)  ((void (*)()) f)
#  else
#    ifndef ANYARGS /* These definitions should work for Ruby 1.6 */
#      define PROTECTFUNC(f) ((VALUE (*)()) f)
#      define VALUEFUNC(f) ((VALUE (*)()) f)
#      define VOIDFUNC(f)  ((RUBY_DATA_FUNC) f)
#    else /* These definitions should work for Ruby 1.7+ */
#      define PROTECTFUNC(f) ((VALUE (*)(VALUE)) f)
#      define VALUEFUNC(f) ((VALUE (*)(ANYARGS)) f)
#      define VOIDFUNC(f)  ((RUBY_DATA_FUNC) f)
#    endif
#  endif
#else
#  define VALUEFUNC(f) (f)
#  define VOIDFUNC(f) (f)
#endif

typedef struct {
  VALUE klass;
  VALUE mImpl;
  void  (*mark)(void *);
  void  (*destroy)(void *);
} swig_class;

/* Don't use for expressions have side effect */
#ifndef RB_STRING_VALUE
#define RB_STRING_VALUE(s) (TYPE(s) == T_STRING ? (s) : (*(volatile VALUE *)&(s) = rb_str_to_str(s)))
#endif
#ifndef StringValue
#define StringValue(s) RB_STRING_VALUE(s)
#endif
#ifndef StringValuePtr
#define StringValuePtr(s) RSTRING(RB_STRING_VALUE(s))->ptr
#endif
#ifndef StringValueLen
#define StringValueLen(s) RSTRING(RB_STRING_VALUE(s))->len
#endif
#ifndef SafeStringValue
#define SafeStringValue(v) do {\
    StringValue(v);\
    rb_check_safe_str(v);\
} while (0)
#endif

#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
#define rb_define_alloc_func(klass, func) rb_define_singleton_method((klass), "new", VALUEFUNC((func)), -1)
#define rb_undef_alloc_func(klass) rb_undef_method(CLASS_OF((klass)), "new")
#endif

/* Contract support */

#define SWIG_contract_assert(expr, msg) if (!(expr)) { rb_raise(rb_eRuntimeError, (char *) msg ); } else



/***********************************************************************
 * swigrun.swg
 *
 *     This file contains generic CAPI SWIG runtime support for pointer
 *     type checking.
 *
 ************************************************************************/

/* This should only be incremented when either the layout of swig_type_info changes,
   or for whatever reason, the runtime changes incompatibly */
#define SWIG_RUNTIME_VERSION "2"

/* define SWIG_TYPE_TABLE_NAME as "SWIG_TYPE_TABLE" */
#ifdef SWIG_TYPE_TABLE
# define SWIG_QUOTE_STRING(x) #x
# define SWIG_EXPAND_AND_QUOTE_STRING(x) SWIG_QUOTE_STRING(x)
# define SWIG_TYPE_TABLE_NAME SWIG_EXPAND_AND_QUOTE_STRING(SWIG_TYPE_TABLE)
#else
# define SWIG_TYPE_TABLE_NAME
#endif

/*
  You can use the SWIGRUNTIME and SWIGRUNTIMEINLINE macros for
  creating a static or dynamic library from the swig runtime code.
  In 99.9% of the cases, swig just needs to declare them as 'static'.
  
  But only do this if is strictly necessary, ie, if you have problems
  with your compiler or so.
*/

#ifndef SWIGRUNTIME
# define SWIGRUNTIME SWIGINTERN
#endif

#ifndef SWIGRUNTIMEINLINE
# define SWIGRUNTIMEINLINE SWIGRUNTIME SWIGINLINE
#endif

#include <string.h>

#ifdef __cplusplus
extern "C" {
#endif

typedef void *(*swig_converter_func)(void *);
typedef struct swig_type_info *(*swig_dycast_func)(void **);

/* Structure to store inforomation on one type */
typedef struct swig_type_info {
  const char             *name;			/* mangled name of this type */
  const char             *str;			/* human readable name of this type */
  swig_dycast_func        dcast;		/* dynamic cast function down a hierarchy */
  struct swig_cast_info  *cast;			/* linked list of types that can cast into this type */
  void                   *clientdata;		/* language specific type data */
} swig_type_info;

/* Structure to store a type and conversion function used for casting */
typedef struct swig_cast_info {
  swig_type_info         *type;			/* pointer to type that is equivalent to this type */
  swig_converter_func     converter;		/* function to cast the void pointers */
  struct swig_cast_info  *next;			/* pointer to next cast in linked list */
  struct swig_cast_info  *prev;			/* pointer to the previous cast */
} swig_cast_info;

/* Structure used to store module information
 * Each module generates one structure like this, and the runtime collects
 * all of these structures and stores them in a circularly linked list.*/
typedef struct swig_module_info {
  swig_type_info         **types;		/* Array of pointers to swig_type_info structures that are in this module */
  size_t                 size;		        /* Number of types in this module */
  struct swig_module_info *next;		/* Pointer to next element in circularly linked list */
  swig_type_info         **type_initial;	/* Array of initially generated type structures */
  swig_cast_info         **cast_initial;	/* Array of initially generated casting structures */
  void                    *clientdata;		/* Language specific module data */
} swig_module_info;


/* 
  Compare two type names skipping the space characters, therefore
  "char*" == "char *" and "Class<int>" == "Class<int >", etc.

  Return 0 when the two name types are equivalent, as in
  strncmp, but skipping ' '.
*/
SWIGRUNTIME int
SWIG_TypeNameComp(const char *f1, const char *l1,
		  const char *f2, const char *l2) {
  for (;(f1 != l1) && (f2 != l2); ++f1, ++f2) {
    while ((*f1 == ' ') && (f1 != l1)) ++f1;
    while ((*f2 == ' ') && (f2 != l2)) ++f2;
    if (*f1 != *f2) return (int)(*f1 - *f2);
  }
  return (l1 - f1) - (l2 - f2);
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if not equal, 1 if equal
*/
SWIGRUNTIME int
SWIG_TypeEquiv(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if equal, -1 if nb < tb, 1 if nb > tb
*/
SWIGRUNTIME int
SWIG_TypeCompare(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}


/* think of this as a c++ template<> or a scheme macro */
#define SWIG_TypeCheck_Template(comparison, ty)         \
  if (ty) {                                             \
    swig_cast_info *iter = ty->cast;                    \
    while (iter) {                                      \
      if (comparison) {                                 \
        if (iter == ty->cast) return iter;              \
        /* Move iter to the top of the linked list */   \
        iter->prev->next = iter->next;                  \
        if (iter->next)                                 \
          iter->next->prev = iter->prev;                \
        iter->next = ty->cast;                          \
        iter->prev = 0;                                 \
        if (ty->cast) ty->cast->prev = iter;            \
        ty->cast = iter;                                \
        return iter;                                    \
      }                                                 \
      iter = iter->next;                                \
    }                                                   \
  }                                                     \
  return 0

/*
  Check the typename
*/
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheck(const char *c, swig_type_info *ty) {
  SWIG_TypeCheck_Template(strcmp(iter->type->name, c) == 0, ty);
}

/* Same as previous function, except strcmp is replaced with a pointer comparison */
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheckStruct(swig_type_info *from, swig_type_info *into) {
  SWIG_TypeCheck_Template(iter->type == from, into);
}

/*
  Cast a pointer up an inheritance hierarchy
*/
SWIGRUNTIMEINLINE void *
SWIG_TypeCast(swig_cast_info *ty, void *ptr) {
  return ((!ty) || (!ty->converter)) ? ptr : (*ty->converter)(ptr);
}

/* 
   Dynamic pointer casting. Down an inheritance hierarchy
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeDynamicCast(swig_type_info *ty, void **ptr) {
  swig_type_info *lastty = ty;
  if (!ty || !ty->dcast) return ty;
  while (ty && (ty->dcast)) {
    ty = (*ty->dcast)(ptr);
    if (ty) lastty = ty;
  }
  return lastty;
}

/*
  Return the name associated with this type
*/
SWIGRUNTIMEINLINE const char *
SWIG_TypeName(const swig_type_info *ty) {
  return ty->name;
}

/*
  Return the pretty name associated with this type,
  that is an unmangled type name in a form presentable to the user.
*/
SWIGRUNTIME const char *
SWIG_TypePrettyName(const swig_type_info *type) {
  /* The "str" field contains the equivalent pretty names of the
     type, separated by vertical-bar characters.  We choose
     to print the last name, as it is often (?) the most
     specific. */
  if (type->str != NULL) {
    const char *last_name = type->str;
    const char *s;
    for (s = type->str; *s; s++)
      if (*s == '|') last_name = s+1;
    return last_name;
  }
  else
    return type->name;
}

/* 
   Set the clientdata field for a type
*/
SWIGRUNTIME void
SWIG_TypeClientData(swig_type_info *ti, void *clientdata) {
  if (!ti->clientdata) {
    swig_cast_info *cast = ti->cast;
    /* if (ti->clientdata == clientdata) return; */
    ti->clientdata = clientdata;
    
    while (cast) {
      if (!cast->converter)
	SWIG_TypeClientData(cast->type, clientdata);
      cast = cast->next;
    }
  }
}

/*
  Search for a swig_type_info structure only by mangled name
  Search is a O(log #types)
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_MangledTypeQueryModule(swig_module_info *start, 
                            swig_module_info *end, 
		            const char *name) {
  swig_module_info *iter = start;
  do {
    if (iter->size) {
      register size_t l = 0;
      register size_t r = iter->size - 1;
      do {
	/* since l+r >= 0, we can (>> 1) instead (/ 2) */
	register size_t i = (l + r) >> 1; 
	const char *iname = iter->types[i]->name;
	if (iname) {
	  register int compare = strcmp(name, iname);
	  if (compare == 0) {	    
	    return iter->types[i];
	  } else if (compare < 0) {
	    if (i) {
	      r = i - 1;
	    } else {
	      break;
	    }
	  } else if (compare > 0) {
	    l = i + 1;
	  }
	} else {
	  break; /* should never happen */
	}
      } while (l <= r);
    }
    iter = iter->next;
  } while (iter != end);
  return 0;
}

/*
  Search for a swig_type_info structure for either a mangled name or a human readable name.
  It first searches the mangled names of the types, which is a O(log #types)
  If a type is not found it then searches the human readable names, which is O(#types).
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeQueryModule(swig_module_info *start, 
                     swig_module_info *end, 
		     const char *name) {
  /* STEP 1: Search the name field using binary search */
  swig_type_info *ret = SWIG_MangledTypeQueryModule(start, end, name);
  if (ret) {
    return ret;
  } else {
    /* STEP 2: If the type hasn't been found, do a complete search
       of the str field (the human readable name) */
    swig_module_info *iter = start;
    do {
      register size_t i = 0;
      for (; i < iter->size; ++i) {
	if (iter->types[i]->str && (SWIG_TypeEquiv(iter->types[i]->str, name)))
	  return iter->types[i];
      }
      iter = iter->next;
    } while (iter != end);
  }
  
  /* neither found a match */
  return 0;
}


/* 
   Pack binary data into a string
*/
SWIGRUNTIME char *
SWIG_PackData(char *c, void *ptr, size_t sz) {
  static const char hex[17] = "0123456789abcdef";
  register const unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu =  u + sz;
  for (; u != eu; ++u) {
    register unsigned char uu = *u;
    *(c++) = hex[(uu & 0xf0) >> 4];
    *(c++) = hex[uu & 0xf];
  }
  return c;
}

/* 
   Unpack binary data from a string
*/
SWIGRUNTIME const char *
SWIG_UnpackData(const char *c, void *ptr, size_t sz) {
  register unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu = u + sz;
  for (; u != eu; ++u) {
    register char d = *(c++);
    register unsigned char uu = 0;
    if ((d >= '0') && (d <= '9'))
      uu = ((d - '0') << 4);
    else if ((d >= 'a') && (d <= 'f'))
      uu = ((d - ('a'-10)) << 4);
    else 
      return (char *) 0;
    d = *(c++);
    if ((d >= '0') && (d <= '9'))
      uu |= (d - '0');
    else if ((d >= 'a') && (d <= 'f'))
      uu |= (d - ('a'-10));
    else 
      return (char *) 0;
    *u = uu;
  }
  return c;
}

/* 
   Pack 'void *' into a string buffer.
*/
SWIGRUNTIME char *
SWIG_PackVoidPtr(char *buff, void *ptr, const char *name, size_t bsz) {
  char *r = buff;
  if ((2*sizeof(void *) + 2) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,&ptr,sizeof(void *));
  if (strlen(name) + 1 > (bsz - (r - buff))) return 0;
  strcpy(r,name);
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackVoidPtr(const char *c, void **ptr, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      *ptr = (void *) 0;
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sizeof(void *));
}

SWIGRUNTIME char *
SWIG_PackDataName(char *buff, void *ptr, size_t sz, const char *name, size_t bsz) {
  char *r = buff;
  size_t lname = (name ? strlen(name) : 0);
  if ((2*sz + 2 + lname) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,ptr,sz);
  if (lname) {
    strncpy(r,name,lname+1);
  } else {
    *r = 0;
  }
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackDataName(const char *c, void *ptr, size_t sz, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      memset(ptr,0,sz);
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sz);
}

#ifdef __cplusplus
}
#endif


/* Common SWIG API */
#define SWIG_ConvertPtr(obj, pp, type, flags) \
  SWIG_Ruby_ConvertPtr(obj, pp, type, flags)
#define SWIG_NewPointerObj(p, type, flags) \
  SWIG_Ruby_NewPointerObj(p, type, flags)
#define SWIG_MustGetPtr(p, type, argnum, flags) \
  SWIG_Ruby_MustGetPtr(p, type, argnum, flags)
#define SWIG_GetModule(clientdata) \
  SWIG_Ruby_GetModule()
#define SWIG_SetModule(clientdata, pointer) \
  SWIG_Ruby_SetModule(pointer)

/* Ruby-specific SWIG API */

#define SWIG_InitRuntime() \
  SWIG_Ruby_InitRuntime()
#define SWIG_define_class(ty) \
  SWIG_Ruby_define_class(ty)
#define SWIG_NewClassInstance(value, ty) \
  SWIG_Ruby_NewClassInstance(value, ty)
#define SWIG_MangleStr(value) \
  SWIG_Ruby_MangleStr(value)
#define SWIG_CheckConvert(value, ty) \
  SWIG_Ruby_CheckConvert(value, ty)
#define SWIG_NewPackedObj(ptr, sz, ty) \
  SWIG_Ruby_NewPackedObj(ptr, sz, ty)
#define SWIG_ConvertPacked(obj, ptr, sz, ty, flags) \
  SWIG_Ruby_ConvertPacked(obj, ptr, sz, ty, flags)

/* rubydef.swg */
#ifdef __cplusplus
extern "C" {
#endif

static VALUE _mSWIG = Qnil;
static VALUE _cSWIG_Pointer = Qnil;
static VALUE swig_runtime_data_type_pointer = Qnil;

/* Initialize Ruby runtime support */
static void
SWIG_Ruby_InitRuntime(void)
{
    if (_mSWIG == Qnil) {
        _mSWIG = rb_define_module("SWIG");
    }
}

/* Define Ruby class for C type */
static void
SWIG_Ruby_define_class(swig_type_info *type)
{
    VALUE klass;
    char *klass_name = (char *) malloc(4 + strlen(type->name) + 1);
    sprintf(klass_name, "TYPE%s", type->name);
    if (NIL_P(_cSWIG_Pointer)) {
	_cSWIG_Pointer = rb_define_class_under(_mSWIG, "Pointer", rb_cObject);
	rb_undef_method(CLASS_OF(_cSWIG_Pointer), "new");
    }
    klass = rb_define_class_under(_mSWIG, klass_name, _cSWIG_Pointer);
    free((void *) klass_name);
}

/* Create a new pointer object */
static VALUE
SWIG_Ruby_NewPointerObj(void *ptr, swig_type_info *type, int own)
{
    char *klass_name;
    swig_class *sklass;
    VALUE klass;
    VALUE obj;
    
    if (!ptr)
	return Qnil;
    
    if (type->clientdata) {
      sklass = (swig_class *) type->clientdata;
      obj = Data_Wrap_Struct(sklass->klass, VOIDFUNC(sklass->mark), (own ? VOIDFUNC(sklass->destroy) : 0), ptr);
    } else {
      klass_name = (char *) malloc(4 + strlen(type->name) + 1);
      sprintf(klass_name, "TYPE%s", type->name);
      klass = rb_const_get(_mSWIG, rb_intern(klass_name));
      free((void *) klass_name);
      obj = Data_Wrap_Struct(klass, 0, 0, ptr);
    }
    rb_iv_set(obj, "__swigtype__", rb_str_new2(type->name));
    return obj;
}

/* Create a new class instance (always owned) */
static VALUE
SWIG_Ruby_NewClassInstance(VALUE klass, swig_type_info *type)
{
    VALUE obj;
    swig_class *sklass = (swig_class *) type->clientdata;
    obj = Data_Wrap_Struct(klass, VOIDFUNC(sklass->mark), VOIDFUNC(sklass->destroy), 0);
    rb_iv_set(obj, "__swigtype__", rb_str_new2(type->name));
    return obj;
}

/* Get type mangle from class name */
static SWIGINLINE char *
SWIG_Ruby_MangleStr(VALUE obj)
{
  VALUE stype = rb_iv_get(obj, "__swigtype__");
  return StringValuePtr(stype);
}

/* Convert a pointer value */
static int
SWIG_Ruby_ConvertPtr(VALUE obj, void **ptr, swig_type_info *ty, int flags)
{
  char *c;
  swig_cast_info *tc;

  /* Grab the pointer */
  if (NIL_P(obj)) {
    *ptr = 0;
    return 0;
  } else {
    Data_Get_Struct(obj, void, *ptr);
  }
  
  /* Do type-checking if type info was provided */
  if (ty) {
    if (ty->clientdata) {
        if (rb_obj_is_kind_of(obj, ((swig_class *) (ty->clientdata))->klass)) {
          if (*ptr == 0)
            rb_raise(rb_eRuntimeError, "This %s already released", ty->str);
          return 0;
        }
    }
    if ((c = SWIG_MangleStr(obj)) == NULL) {
      if (flags & SWIG_POINTER_EXCEPTION)
        rb_raise(rb_eTypeError, "Expected %s", ty->str);
      else
        return -1;
    }
    tc = SWIG_TypeCheck(c, ty);
    if (!tc) {
      if (flags & SWIG_POINTER_EXCEPTION)
        rb_raise(rb_eTypeError, "Expected %s", ty->str);
      else
        return -1;
    }
    *ptr = SWIG_TypeCast(tc, *ptr);
  }
  return 0;
}

/* Convert a pointer value, signal an exception on a type mismatch */
static SWIGINLINE void *
SWIG_Ruby_MustGetPtr(VALUE obj, swig_type_info *ty, int argnum, int flags)
{
  void *result;
  SWIG_ConvertPtr(obj, &result, ty, flags | SWIG_POINTER_EXCEPTION);
  return result;
}

/* Check convert */
static SWIGINLINE int
SWIG_Ruby_CheckConvert(VALUE obj, swig_type_info *ty)
{
  char *c = SWIG_MangleStr(obj);
  if (!c)
    return 0;
  return SWIG_TypeCheck(c,ty) != 0;
}

static VALUE
SWIG_Ruby_NewPackedObj(void *ptr, int sz, swig_type_info *type) {
  char result[1024];
  char *r = result;
  if ((2*sz + 1 + strlen(type->name)) > 1000) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r, ptr, sz);
  strcpy(r, type->name);
  return rb_str_new2(result);
}

/* Convert a packed value value */
static void
SWIG_Ruby_ConvertPacked(VALUE obj, void *ptr, int sz, swig_type_info *ty, int flags) {
  swig_cast_info *tc;
  const char  *c;

  if (TYPE(obj) != T_STRING) goto type_error;
  c = StringValuePtr(obj);
  /* Pointer values must start with leading underscore */
  if (*c != '_') goto type_error;
  c++;
  c = SWIG_UnpackData(c, ptr, sz);
  if (ty) {
    tc = SWIG_TypeCheck(c, ty);
    if (!tc) goto type_error;
  }
  return;

type_error:

  if (flags) {
    if (ty) {
      rb_raise(rb_eTypeError, "Type error. Expected %s", ty->name);
    } else {
      rb_raise(rb_eTypeError, "Expected a pointer");
    }
  }
}

static swig_module_info *SWIG_Ruby_GetModule() {
    VALUE pointer;
    swig_module_info *ret = 0;

   /* first check if pointer already created */
    pointer = rb_gv_get("$swig_runtime_data_type_pointer" SWIG_RUNTIME_VERSION SWIG_TYPE_TABLE_NAME);
    if (pointer != Qnil) {
      Data_Get_Struct(pointer, swig_module_info, ret);
    }
    return ret;
}

static void SWIG_Ruby_SetModule(swig_module_info *pointer) {
      /* register a new class */
      VALUE cl = rb_define_class("swig_runtime_data", rb_cObject);
      /* create and store the structure pointer to a global variable */
      swig_runtime_data_type_pointer = Data_Wrap_Struct(cl, 0, 0, pointer);
      rb_define_readonly_variable("$swig_runtime_data_type_pointer" SWIG_RUNTIME_VERSION SWIG_TYPE_TABLE_NAME, &swig_runtime_data_type_pointer);
}

#ifdef __cplusplus
}
#endif




  #include <apr.h>
  #include <apr_pools.h>

  static apr_pool_t *
  _svn_client_pool(void) 
  {
    static apr_pool_t *__svn_client_pool = NULL;
    if (!__svn_client_pool) {
      apr_pool_create(&__svn_client_pool, NULL);
    }
    return __svn_client_pool;
  }

  static apr_pool_t *
  _svn_client_config_pool(void) 
  {
    static apr_pool_t *__svn_client_config_pool = NULL;
    if (!__svn_client_config_pool) {
      apr_pool_create(&__svn_client_config_pool, _svn_client_pool());
    }
    return __svn_client_config_pool;
  }


/* -------- TYPES TABLE (BEGIN) -------- */

#define SWIGTYPE_p_apr_array_header_t swig_types[0]
#define SWIGTYPE_p_apr_file_t swig_types[1]
#define SWIGTYPE_p_apr_hash_t swig_types[2]
#define SWIGTYPE_p_apr_int32_t swig_types[3]
#define SWIGTYPE_p_apr_int64_t swig_types[4]
#define SWIGTYPE_p_apr_pool_t swig_types[5]
#define SWIGTYPE_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void swig_types[6]
#define SWIGTYPE_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[7]
#define SWIGTYPE_p_f_p_p_q_const__char_p_p_q_const__char_p_apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[8]
#define SWIGTYPE_p_f_p_p_q_const__char_p_p_q_const__char_p_q_const__apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[9]
#define SWIGTYPE_p_f_p_p_svn_auth_cred_simple_t_p_void_p_q_const__char_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t swig_types[10]
#define SWIGTYPE_p_f_p_p_svn_auth_cred_ssl_client_cert_pw_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t swig_types[11]
#define SWIGTYPE_p_f_p_p_svn_auth_cred_ssl_client_cert_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t swig_types[12]
#define SWIGTYPE_p_f_p_p_svn_auth_cred_ssl_server_trust_t_p_void_p_q_const__char_apr_uint32_t_p_q_const__svn_auth_ssl_server_cert_info_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t swig_types[13]
#define SWIGTYPE_p_f_p_p_svn_auth_cred_username_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t swig_types[14]
#define SWIGTYPE_p_f_p_q_const__svn_client_diff_summarize_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[15]
#define SWIGTYPE_p_f_p_void__p_svn_error_t swig_types[16]
#define SWIGTYPE_p_f_p_void_apr_int64_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[17]
#define SWIGTYPE_p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[18]
#define SWIGTYPE_p_f_p_void_p_q_const__char_enum_svn_wc_notify_action_t_enum_svn_node_kind_t_p_q_const__char_enum_svn_wc_notify_state_t_enum_svn_wc_notify_state_t_long__void swig_types[19]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_dirent_t_p_q_const__svn_lock_t_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[20]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_info_t_p_apr_pool_t__p_svn_error_t swig_types[21]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_struct_svn_wc_status2_t__void swig_types[22]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_struct_svn_wc_status_t__void swig_types[23]
#define SWIGTYPE_p_f_p_void_p_q_const__struct_svn_wc_notify_t_p_apr_pool_t__void swig_types[24]
#define SWIGTYPE_p_int swig_types[25]
#define SWIGTYPE_p_long swig_types[26]
#define SWIGTYPE_p_p_apr_array_header_t swig_types[27]
#define SWIGTYPE_p_p_apr_hash_t swig_types[28]
#define SWIGTYPE_p_p_char swig_types[29]
#define SWIGTYPE_p_p_svn_auth_provider_object_t swig_types[30]
#define SWIGTYPE_p_p_svn_client_commit_info_t swig_types[31]
#define SWIGTYPE_p_p_svn_client_ctx_t swig_types[32]
#define SWIGTYPE_p_p_svn_commit_info_t swig_types[33]
#define SWIGTYPE_p_p_svn_ra_session_t swig_types[34]
#define SWIGTYPE_p_p_svn_string_t swig_types[35]
#define SWIGTYPE_p_svn_auth_baton_t swig_types[36]
#define SWIGTYPE_p_svn_auth_cred_simple_t swig_types[37]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_pw_t swig_types[38]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_t swig_types[39]
#define SWIGTYPE_p_svn_auth_cred_ssl_server_trust_t swig_types[40]
#define SWIGTYPE_p_svn_auth_cred_username_t swig_types[41]
#define SWIGTYPE_p_svn_auth_iterstate_t swig_types[42]
#define SWIGTYPE_p_svn_auth_provider_object_t swig_types[43]
#define SWIGTYPE_p_svn_auth_provider_t swig_types[44]
#define SWIGTYPE_p_svn_auth_ssl_server_cert_info_t swig_types[45]
#define SWIGTYPE_p_svn_client_commit_info_t swig_types[46]
#define SWIGTYPE_p_svn_client_commit_item2_t swig_types[47]
#define SWIGTYPE_p_svn_client_commit_item_t swig_types[48]
#define SWIGTYPE_p_svn_client_ctx_t swig_types[49]
#define SWIGTYPE_p_svn_client_diff_summarize_kind_t swig_types[50]
#define SWIGTYPE_p_svn_client_diff_summarize_t swig_types[51]
#define SWIGTYPE_p_svn_client_proplist_item_t swig_types[52]
#define SWIGTYPE_p_svn_commit_info_t swig_types[53]
#define SWIGTYPE_p_svn_config_t swig_types[54]
#define SWIGTYPE_p_svn_delta_editor_t swig_types[55]
#define SWIGTYPE_p_svn_diff_datasource_e swig_types[56]
#define SWIGTYPE_p_svn_diff_file_ignore_space_t swig_types[57]
#define SWIGTYPE_p_svn_diff_file_options_t swig_types[58]
#define SWIGTYPE_p_svn_diff_fns_t swig_types[59]
#define SWIGTYPE_p_svn_diff_output_fns_t swig_types[60]
#define SWIGTYPE_p_svn_diff_t swig_types[61]
#define SWIGTYPE_p_svn_dirent_t swig_types[62]
#define SWIGTYPE_p_svn_errno_t swig_types[63]
#define SWIGTYPE_p_svn_error_t swig_types[64]
#define SWIGTYPE_p_svn_info_t swig_types[65]
#define SWIGTYPE_p_svn_io_dirent_t swig_types[66]
#define SWIGTYPE_p_svn_io_file_del_t swig_types[67]
#define SWIGTYPE_p_svn_lock_t swig_types[68]
#define SWIGTYPE_p_svn_log_changed_path_t swig_types[69]
#define SWIGTYPE_p_svn_node_kind_t swig_types[70]
#define SWIGTYPE_p_svn_opt_revision_t swig_types[71]
#define SWIGTYPE_p_svn_opt_revision_value_t swig_types[72]
#define SWIGTYPE_p_svn_opt_subcommand_desc2_t swig_types[73]
#define SWIGTYPE_p_svn_opt_subcommand_desc_t swig_types[74]
#define SWIGTYPE_p_svn_prop_kind swig_types[75]
#define SWIGTYPE_p_svn_prop_t swig_types[76]
#define SWIGTYPE_p_svn_ra_callbacks2_t swig_types[77]
#define SWIGTYPE_p_svn_ra_callbacks_t swig_types[78]
#define SWIGTYPE_p_svn_ra_plugin_t swig_types[79]
#define SWIGTYPE_p_svn_ra_reporter2_t swig_types[80]
#define SWIGTYPE_p_svn_ra_reporter_t swig_types[81]
#define SWIGTYPE_p_svn_ra_session_t swig_types[82]
#define SWIGTYPE_p_svn_stream_t swig_types[83]
#define SWIGTYPE_p_svn_string_t swig_types[84]
#define SWIGTYPE_p_svn_stringbuf_t swig_types[85]
#define SWIGTYPE_p_svn_txdelta_op_t swig_types[86]
#define SWIGTYPE_p_svn_txdelta_stream_t swig_types[87]
#define SWIGTYPE_p_svn_txdelta_window_t swig_types[88]
#define SWIGTYPE_p_svn_version_checklist_t swig_types[89]
#define SWIGTYPE_p_svn_version_t swig_types[90]
#define SWIGTYPE_p_svn_wc_adm_access_t swig_types[91]
#define SWIGTYPE_p_svn_wc_diff_callbacks2_t swig_types[92]
#define SWIGTYPE_p_svn_wc_diff_callbacks_t swig_types[93]
#define SWIGTYPE_p_svn_wc_entry_callbacks_t swig_types[94]
#define SWIGTYPE_p_svn_wc_entry_t swig_types[95]
#define SWIGTYPE_p_svn_wc_external_item_t swig_types[96]
#define SWIGTYPE_p_svn_wc_merge_outcome_t swig_types[97]
#define SWIGTYPE_p_svn_wc_notify_action_t swig_types[98]
#define SWIGTYPE_p_svn_wc_notify_lock_state_t swig_types[99]
#define SWIGTYPE_p_svn_wc_notify_state_t swig_types[100]
#define SWIGTYPE_p_svn_wc_notify_t swig_types[101]
#define SWIGTYPE_p_svn_wc_revision_status_t swig_types[102]
#define SWIGTYPE_p_svn_wc_schedule_t swig_types[103]
#define SWIGTYPE_p_svn_wc_status2_t swig_types[104]
#define SWIGTYPE_p_svn_wc_status_t swig_types[105]
#define SWIGTYPE_p_svn_wc_traversal_info_t swig_types[106]
#define SWIGTYPE_p_unsigned_long swig_types[107]
#define SWIGTYPE_p_void swig_types[108]
static swig_type_info *swig_types[109];
static swig_module_info swig_module = {swig_types, 109, 0, 0, 0, 0};
#define SWIG_TypeQuery(name) SWIG_TypeQueryModule(&swig_module, &swig_module, name)
#define SWIG_MangledTypeQuery(name) SWIG_MangledTypeQueryModule(&swig_module, &swig_module, name)

/* -------- TYPES TABLE (END) -------- */

#define SWIG_init    Init_client
#define SWIG_name    "Svn::Ext::Client"

static VALUE mClient;

static void SWIG_AsVal(VALUE obj, int *val)
{
    *val = (int) NUM2INT(obj);
}


#ifdef __cplusplus
extern "C" {
#endif
#ifdef HAVE_SYS_TIME_H
# include <sys/time.h>
struct timeval rb_time_timeval(VALUE);
#endif
#ifdef __cplusplus
}
#endif


#ifdef __cplusplus
extern "C" {
#endif
#include "rubyio.h"
#ifdef __cplusplus
}
#endif


static VALUE _global_svn_swig_rb_pool = Qnil;


#include "svn_time.h"
#include "svn_pools.h"


#ifdef SWIGPYTHON
#include "swigutil_py.h"
#endif

#ifdef SWIGPERL
#include "swigutil_pl.h"
#endif

#ifdef SWIGRUBY
#include <apu.h>
#include <apr_xlate.h>
#include "swigutil_rb.h"
#endif


#include "svn_client.h"


static VALUE output_helper(VALUE target, VALUE o) {
    if (NIL_P(target)) {
	target = o;
    } else {
	if (TYPE(target) != T_ARRAY) {
	    VALUE o2 = target;
	    target = rb_ary_new();
	    rb_ary_push(target, o2);
	}
	rb_ary_push(target, o);
    }
    return target;
}




static VALUE
svn_client_set_log_msg_func2(svn_client_ctx_t *ctx,
                             svn_client_get_commit_log2_t log_msg_func2,
                             void *log_msg_baton2,
                             apr_pool_t *pool)
{
  ctx->log_msg_func2 = log_msg_func2;
  ctx->log_msg_baton2 = log_msg_baton2;
  return (VALUE)log_msg_baton2;
}
 
static VALUE
svn_client_set_notify_func2(svn_client_ctx_t *ctx,
                            svn_wc_notify_func2_t notify_func2,
                            void *notify_baton2,
                            apr_pool_t *pool)
{
  ctx->notify_func2 = notify_func2;
  ctx->notify_baton2 = notify_baton2;
  return (VALUE)notify_baton2;
}

static VALUE
svn_client_set_cancel_func(svn_client_ctx_t *ctx,
                           svn_cancel_func_t cancel_func,
                           void *cancel_baton,
                           apr_pool_t *pool)
{
  ctx->cancel_func = cancel_func;
  ctx->cancel_baton = cancel_baton;
  return (VALUE)cancel_baton;
}

static VALUE
_wrap_svn_client_version(int argc, VALUE *argv, VALUE self) {
    svn_version_t *result;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_version_t *)svn_client_version();
        
        
        
        
    }
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_version_t,0);
    return vresult;
}


static VALUE
_wrap_svn_client_get_simple_prompt_provider(int argc, VALUE *argv, VALUE self) {
    svn_auth_provider_object_t **arg1 = (svn_auth_provider_object_t **) 0 ;
    svn_auth_simple_prompt_func_t arg2 = (svn_auth_simple_prompt_func_t) 0 ;
    void *arg3 = (void *) 0 ;
    int arg4 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_auth_provider_object_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_auth_provider_object_t **)&temp1;
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        arg2 = svn_swig_rb_auth_simple_prompt_func;
        arg3 = (void *)svn_swig_rb_make_baton(argv[0], _global_svn_swig_rb_pool);
    }
    arg4 = NUM2INT(argv[1]);
    if (argc > 2) {
        
    }
    {
        svn_client_get_simple_prompt_provider(arg1,arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_auth_provider_object_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_get_username_prompt_provider(int argc, VALUE *argv, VALUE self) {
    svn_auth_provider_object_t **arg1 = (svn_auth_provider_object_t **) 0 ;
    svn_auth_username_prompt_func_t arg2 = (svn_auth_username_prompt_func_t) 0 ;
    void *arg3 = (void *) 0 ;
    int arg4 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_auth_provider_object_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_auth_provider_object_t **)&temp1;
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        arg2 = svn_swig_rb_auth_username_prompt_func;
        arg3 = (void *)svn_swig_rb_make_baton(argv[0], _global_svn_swig_rb_pool);
    }
    arg4 = NUM2INT(argv[1]);
    if (argc > 2) {
        
    }
    {
        svn_client_get_username_prompt_provider(arg1,arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_auth_provider_object_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_get_simple_provider(int argc, VALUE *argv, VALUE self) {
    svn_auth_provider_object_t **arg1 = (svn_auth_provider_object_t **) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_auth_provider_object_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_auth_provider_object_t **)&temp1;
    }
    if ((argc < 0) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    if (argc > 0) {
        
    }
    {
        svn_client_get_simple_provider(arg1,arg2);
        
        
        
        
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_auth_provider_object_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_get_username_provider(int argc, VALUE *argv, VALUE self) {
    svn_auth_provider_object_t **arg1 = (svn_auth_provider_object_t **) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_auth_provider_object_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_auth_provider_object_t **)&temp1;
    }
    if ((argc < 0) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    if (argc > 0) {
        
    }
    {
        svn_client_get_username_provider(arg1,arg2);
        
        
        
        
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_auth_provider_object_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_get_ssl_server_trust_file_provider(int argc, VALUE *argv, VALUE self) {
    svn_auth_provider_object_t **arg1 = (svn_auth_provider_object_t **) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_auth_provider_object_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_auth_provider_object_t **)&temp1;
    }
    if ((argc < 0) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    if (argc > 0) {
        
    }
    {
        svn_client_get_ssl_server_trust_file_provider(arg1,arg2);
        
        
        
        
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_auth_provider_object_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_get_ssl_client_cert_file_provider(int argc, VALUE *argv, VALUE self) {
    svn_auth_provider_object_t **arg1 = (svn_auth_provider_object_t **) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_auth_provider_object_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_auth_provider_object_t **)&temp1;
    }
    if ((argc < 0) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    if (argc > 0) {
        
    }
    {
        svn_client_get_ssl_client_cert_file_provider(arg1,arg2);
        
        
        
        
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_auth_provider_object_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_get_ssl_client_cert_pw_file_provider(int argc, VALUE *argv, VALUE self) {
    svn_auth_provider_object_t **arg1 = (svn_auth_provider_object_t **) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_auth_provider_object_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_auth_provider_object_t **)&temp1;
    }
    if ((argc < 0) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    if (argc > 0) {
        
    }
    {
        svn_client_get_ssl_client_cert_pw_file_provider(arg1,arg2);
        
        
        
        
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_auth_provider_object_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_get_ssl_server_trust_prompt_provider(int argc, VALUE *argv, VALUE self) {
    svn_auth_provider_object_t **arg1 = (svn_auth_provider_object_t **) 0 ;
    svn_auth_ssl_server_trust_prompt_func_t arg2 = (svn_auth_ssl_server_trust_prompt_func_t) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_auth_provider_object_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_auth_provider_object_t **)&temp1;
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        arg2 = svn_swig_rb_auth_ssl_server_trust_prompt_func;
        arg3 = (void *)svn_swig_rb_make_baton(argv[0], _global_svn_swig_rb_pool);
    }
    if (argc > 1) {
        
    }
    {
        svn_client_get_ssl_server_trust_prompt_provider(arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_auth_provider_object_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_get_ssl_client_cert_prompt_provider(int argc, VALUE *argv, VALUE self) {
    svn_auth_provider_object_t **arg1 = (svn_auth_provider_object_t **) 0 ;
    svn_auth_ssl_client_cert_prompt_func_t arg2 = (svn_auth_ssl_client_cert_prompt_func_t) 0 ;
    void *arg3 = (void *) 0 ;
    int arg4 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_auth_provider_object_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_auth_provider_object_t **)&temp1;
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        arg2 = svn_swig_rb_auth_ssl_client_cert_prompt_func;
        arg3 = (void *)svn_swig_rb_make_baton(argv[0], _global_svn_swig_rb_pool);
    }
    arg4 = NUM2INT(argv[1]);
    if (argc > 2) {
        
    }
    {
        svn_client_get_ssl_client_cert_prompt_provider(arg1,arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_auth_provider_object_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_get_ssl_client_cert_pw_prompt_provider(int argc, VALUE *argv, VALUE self) {
    svn_auth_provider_object_t **arg1 = (svn_auth_provider_object_t **) 0 ;
    svn_auth_ssl_client_cert_pw_prompt_func_t arg2 = (svn_auth_ssl_client_cert_pw_prompt_func_t) 0 ;
    void *arg3 = (void *) 0 ;
    int arg4 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_auth_provider_object_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_auth_provider_object_t **)&temp1;
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        arg2 = svn_swig_rb_auth_ssl_client_cert_pw_prompt_func;
        arg3 = (void *)svn_swig_rb_make_baton(argv[0], _global_svn_swig_rb_pool);
    }
    arg4 = NUM2INT(argv[1]);
    if (argc > 2) {
        
    }
    {
        svn_client_get_ssl_client_cert_pw_prompt_provider(arg1,arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_auth_provider_object_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


swig_class cSvn_client_proplist_item_t;

static VALUE
_wrap_svn_client_proplist_item_t_node_name_set(int argc, VALUE *argv, VALUE self) {
    svn_client_proplist_item_t *arg1 = (svn_client_proplist_item_t *) 0 ;
    svn_stringbuf_t *arg2 = (svn_stringbuf_t *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_proplist_item_t, 1);
        
        
        
        arg1 = (svn_client_proplist_item_t *)temp1;
    }
    {
        if (NIL_P(argv[0])) {
            arg2 = NULL;
        } else {
            VALUE rb_pool;
            apr_pool_t *pool;
            
            svn_swig_rb_get_pool(argc, argv, self, &rb_pool, &pool);
            
            arg2 = svn_stringbuf_ncreate(StringValuePtr(argv[0]),
            RSTRING(argv[0])->len,
            pool);
        }
    }
    if (arg1) (arg1)->node_name = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_proplist_item_t_node_name_get(int argc, VALUE *argv, VALUE self) {
    svn_client_proplist_item_t *arg1 = (svn_client_proplist_item_t *) 0 ;
    svn_stringbuf_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_proplist_item_t, 1);
        
        
        
        arg1 = (svn_client_proplist_item_t *)temp1;
    }
    result = (svn_stringbuf_t *) ((arg1)->node_name);
    
    {
        vresult = rb_str_new(result->data, result->len);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_proplist_item_t_prop_hash_set(int argc, VALUE *argv, VALUE self) {
    svn_client_proplist_item_t *arg1 = (svn_client_proplist_item_t *) 0 ;
    apr_hash_t *arg2 = (apr_hash_t *) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_proplist_item_t, 1);
        
        
        
        arg1 = (svn_client_proplist_item_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_apr_hash_t, 1);
        
        
        
        arg2 = (apr_hash_t *)temp2;
    }
    if (arg1) (arg1)->prop_hash = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_proplist_item_t_prop_hash_get(int argc, VALUE *argv, VALUE self) {
    svn_client_proplist_item_t *arg1 = (svn_client_proplist_item_t *) 0 ;
    apr_hash_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_proplist_item_t, 1);
        
        
        
        arg1 = (svn_client_proplist_item_t *)temp1;
    }
    result = (apr_hash_t *) ((arg1)->prop_hash);
    
    {
        vresult = svn_swig_rb_prop_hash_to_hash(result);
    }
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_client_proplist_item_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_client_proplist_item_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_client_proplist_item_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_client_proplist_item_t(int argc, VALUE *argv, VALUE self) {
    svn_client_proplist_item_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_client_proplist_item_t *)(svn_client_proplist_item_t *) calloc(1, sizeof(svn_client_proplist_item_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_client_proplist_item_t(svn_client_proplist_item_t *arg1) {
    free((char *) arg1);
}
static VALUE
_wrap_svn_client_proplist_item_dup(int argc, VALUE *argv, VALUE self) {
    svn_client_proplist_item_t *arg1 = (svn_client_proplist_item_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_client_proplist_item_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_client_proplist_item_t, 1);
        
        
        
        arg1 = (svn_client_proplist_item_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (svn_client_proplist_item_t *)svn_client_proplist_item_dup((struct svn_client_proplist_item_t const *)arg1,arg2);
        
        
        
        
    }
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_client_proplist_item_t,0);
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


swig_class cSvn_client_commit_info_t;

static VALUE
_wrap_svn_client_commit_info_t_revision_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t *arg1 = (svn_client_commit_info_t *) 0 ;
    svn_revnum_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_info_t, 1);
        
        
        
        arg1 = (svn_client_commit_info_t *)temp1;
    }
    arg2 = NUM2LONG(argv[0]);
    if (arg1) (arg1)->revision = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_info_t_revision_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t *arg1 = (svn_client_commit_info_t *) 0 ;
    svn_revnum_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_info_t, 1);
        
        
        
        arg1 = (svn_client_commit_info_t *)temp1;
    }
    result = (svn_revnum_t) ((arg1)->revision);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_client_commit_info_t_date_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t *arg1 = (svn_client_commit_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_info_t, 1);
        
        
        
        arg1 = (svn_client_commit_info_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->date) free((char *)arg1->date);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->date = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_info_t_date_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t *arg1 = (svn_client_commit_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_info_t, 1);
        
        
        
        arg1 = (svn_client_commit_info_t *)temp1;
    }
    result = (char *) ((arg1)->date);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_client_commit_info_t_author_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t *arg1 = (svn_client_commit_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_info_t, 1);
        
        
        
        arg1 = (svn_client_commit_info_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->author) free((char *)arg1->author);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->author = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_info_t_author_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t *arg1 = (svn_client_commit_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_info_t, 1);
        
        
        
        arg1 = (svn_client_commit_info_t *)temp1;
    }
    result = (char *) ((arg1)->author);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_client_commit_info_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_client_commit_info_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_client_commit_info_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_client_commit_info_t(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_client_commit_info_t *)(svn_client_commit_info_t *) calloc(1, sizeof(svn_client_commit_info_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_client_commit_info_t(svn_client_commit_info_t *arg1) {
    free((char *) arg1);
}
swig_class cSvn_client_commit_item2_t;

static VALUE
_wrap_svn_client_commit_item2_t_path_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->path) free((char *)arg1->path);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->path = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item2_t_path_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    result = (char *) ((arg1)->path);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item2_t_kind_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    svn_node_kind_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    arg2 = (svn_node_kind_t) NUM2INT(argv[0]);
    if (arg1) (arg1)->kind = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item2_t_kind_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    svn_node_kind_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    result = (svn_node_kind_t) ((arg1)->kind);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item2_t_url_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->url) free((char *)arg1->url);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->url = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item2_t_url_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    result = (char *) ((arg1)->url);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item2_t_revision_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    svn_revnum_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    arg2 = NUM2LONG(argv[0]);
    if (arg1) (arg1)->revision = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item2_t_revision_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    svn_revnum_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    result = (svn_revnum_t) ((arg1)->revision);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item2_t_copyfrom_url_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    {
        if (NIL_P(argv[0])) {
            arg2 = NULL;
        } else {
            arg2 = StringValuePtr(argv[0]);
        }
    }
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->copyfrom_url) free((char *)arg1->copyfrom_url);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->copyfrom_url = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item2_t_copyfrom_url_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    result = (char *) ((arg1)->copyfrom_url);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item2_t_copyfrom_rev_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    svn_revnum_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    arg2 = NUM2LONG(argv[0]);
    if (arg1) (arg1)->copyfrom_rev = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item2_t_copyfrom_rev_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    svn_revnum_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    result = (svn_revnum_t) ((arg1)->copyfrom_rev);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item2_t_state_flags_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    apr_byte_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    arg2 = NUM2ULONG(argv[0]);
    if (arg1) (arg1)->state_flags = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item2_t_state_flags_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    apr_byte_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    result =  ((arg1)->state_flags);
    
    vresult = UINT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item2_t_wcprop_changes_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    {
        VALUE rb_pool;
        apr_pool_t *pool;
        
        svn_swig_rb_get_pool(argc, argv, self, &rb_pool, &pool);
        
        arg2 = svn_swig_rb_array_to_apr_array_prop(argv[0], pool);
    }
    if (arg1) (arg1)->wcprop_changes = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item2_t_wcprop_changes_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    apr_array_header_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    result = (apr_array_header_t *) ((arg1)->wcprop_changes);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_apr_array_header_t,0);
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_client_commit_item2_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_client_commit_item2_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_client_commit_item2_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_client_commit_item2_t(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_client_commit_item2_t *)(svn_client_commit_item2_t *) calloc(1, sizeof(svn_client_commit_item2_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_client_commit_item2_t(svn_client_commit_item2_t *arg1) {
    free((char *) arg1);
}
static VALUE
_wrap_svn_client_commit_item2_dup(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item2_t *arg1 = (svn_client_commit_item2_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_client_commit_item2_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_client_commit_item2_t, 1);
        
        
        
        arg1 = (svn_client_commit_item2_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (svn_client_commit_item2_t *)svn_client_commit_item2_dup((struct svn_client_commit_item2_t const *)arg1,arg2);
        
        
        
        
    }
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_client_commit_item2_t,0);
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


swig_class cSvn_client_commit_item_t;

static VALUE
_wrap_svn_client_commit_item_t_path_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->path) free((char *)arg1->path);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->path = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item_t_path_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    result = (char *) ((arg1)->path);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item_t_kind_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    svn_node_kind_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    arg2 = (svn_node_kind_t) NUM2INT(argv[0]);
    if (arg1) (arg1)->kind = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item_t_kind_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    svn_node_kind_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    result = (svn_node_kind_t) ((arg1)->kind);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item_t_url_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->url) free((char *)arg1->url);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->url = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item_t_url_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    result = (char *) ((arg1)->url);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item_t_revision_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    svn_revnum_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    arg2 = NUM2LONG(argv[0]);
    if (arg1) (arg1)->revision = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item_t_revision_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    svn_revnum_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    result = (svn_revnum_t) ((arg1)->revision);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item_t_copyfrom_url_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    {
        if (NIL_P(argv[0])) {
            arg2 = NULL;
        } else {
            arg2 = StringValuePtr(argv[0]);
        }
    }
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->copyfrom_url) free((char *)arg1->copyfrom_url);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->copyfrom_url = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item_t_copyfrom_url_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    result = (char *) ((arg1)->copyfrom_url);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item_t_state_flags_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    apr_byte_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    arg2 = NUM2ULONG(argv[0]);
    if (arg1) (arg1)->state_flags = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item_t_state_flags_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    apr_byte_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    result =  ((arg1)->state_flags);
    
    vresult = UINT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_client_commit_item_t_wcprop_changes_set(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    {
        VALUE rb_pool;
        apr_pool_t *pool;
        
        svn_swig_rb_get_pool(argc, argv, self, &rb_pool, &pool);
        
        arg2 = svn_swig_rb_array_to_apr_array_prop(argv[0], pool);
    }
    if (arg1) (arg1)->wcprop_changes = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_commit_item_t_wcprop_changes_get(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *arg1 = (svn_client_commit_item_t *) 0 ;
    apr_array_header_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_commit_item_t, 1);
        
        
        
        arg1 = (svn_client_commit_item_t *)temp1;
    }
    result = (apr_array_header_t *) ((arg1)->wcprop_changes);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_apr_array_header_t,0);
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_client_commit_item_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_client_commit_item_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_client_commit_item_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_client_commit_item_t(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_item_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_client_commit_item_t *)(svn_client_commit_item_t *) calloc(1, sizeof(svn_client_commit_item_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_client_commit_item_t(svn_client_commit_item_t *arg1) {
    free((char *) arg1);
}
swig_class cSvn_client_diff_summarize_t;

static VALUE
_wrap_svn_client_diff_summarize_t_path_set(int argc, VALUE *argv, VALUE self) {
    svn_client_diff_summarize_t *arg1 = (svn_client_diff_summarize_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_diff_summarize_t, 1);
        
        
        
        arg1 = (svn_client_diff_summarize_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->path) free((char *)arg1->path);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->path = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_client_diff_summarize_t_path_get(int argc, VALUE *argv, VALUE self) {
    svn_client_diff_summarize_t *arg1 = (svn_client_diff_summarize_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_diff_summarize_t, 1);
        
        
        
        arg1 = (svn_client_diff_summarize_t *)temp1;
    }
    result = (char *) ((arg1)->path);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_client_diff_summarize_t_summarize_kind_set(int argc, VALUE *argv, VALUE self) {
    svn_client_diff_summarize_t *arg1 = (svn_client_diff_summarize_t *) 0 ;
    svn_client_diff_summarize_kind_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_diff_summarize_t, 1);
        
        
        
        arg1 = (svn_client_diff_summarize_t *)temp1;
    }
    arg2 = (svn_client_diff_summarize_kind_t) NUM2INT(argv[0]);
    if (arg1) (arg1)->summarize_kind = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_diff_summarize_t_summarize_kind_get(int argc, VALUE *argv, VALUE self) {
    svn_client_diff_summarize_t *arg1 = (svn_client_diff_summarize_t *) 0 ;
    svn_client_diff_summarize_kind_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_diff_summarize_t, 1);
        
        
        
        arg1 = (svn_client_diff_summarize_t *)temp1;
    }
    result = (svn_client_diff_summarize_kind_t) ((arg1)->summarize_kind);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_client_diff_summarize_t_prop_changed_set(int argc, VALUE *argv, VALUE self) {
    svn_client_diff_summarize_t *arg1 = (svn_client_diff_summarize_t *) 0 ;
    svn_boolean_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_diff_summarize_t, 1);
        
        
        
        arg1 = (svn_client_diff_summarize_t *)temp1;
    }
    arg2 = RTEST(argv[0]);
    if (arg1) (arg1)->prop_changed = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_diff_summarize_t_prop_changed_get(int argc, VALUE *argv, VALUE self) {
    svn_client_diff_summarize_t *arg1 = (svn_client_diff_summarize_t *) 0 ;
    svn_boolean_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_diff_summarize_t, 1);
        
        
        
        arg1 = (svn_client_diff_summarize_t *)temp1;
    }
    result = (svn_boolean_t) ((arg1)->prop_changed);
    
    {
        vresult = output_helper(vresult, result ? Qtrue : Qfalse);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_diff_summarize_t_node_kind_set(int argc, VALUE *argv, VALUE self) {
    svn_client_diff_summarize_t *arg1 = (svn_client_diff_summarize_t *) 0 ;
    svn_node_kind_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_diff_summarize_t, 1);
        
        
        
        arg1 = (svn_client_diff_summarize_t *)temp1;
    }
    arg2 = (svn_node_kind_t) NUM2INT(argv[0]);
    if (arg1) (arg1)->node_kind = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_diff_summarize_t_node_kind_get(int argc, VALUE *argv, VALUE self) {
    svn_client_diff_summarize_t *arg1 = (svn_client_diff_summarize_t *) 0 ;
    svn_node_kind_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_diff_summarize_t, 1);
        
        
        
        arg1 = (svn_client_diff_summarize_t *)temp1;
    }
    result = (svn_node_kind_t) ((arg1)->node_kind);
    
    vresult = INT2NUM(result);
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_client_diff_summarize_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_client_diff_summarize_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_client_diff_summarize_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_client_diff_summarize_t(int argc, VALUE *argv, VALUE self) {
    svn_client_diff_summarize_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_client_diff_summarize_t *)(svn_client_diff_summarize_t *) calloc(1, sizeof(svn_client_diff_summarize_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_client_diff_summarize_t(svn_client_diff_summarize_t *arg1) {
    free((char *) arg1);
}
static VALUE
_wrap_svn_client_diff_summarize_dup(int argc, VALUE *argv, VALUE self) {
    svn_client_diff_summarize_t *arg1 = (svn_client_diff_summarize_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_client_diff_summarize_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_client_diff_summarize_t, 1);
        
        
        
        arg1 = (svn_client_diff_summarize_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (svn_client_diff_summarize_t *)svn_client_diff_summarize_dup((struct svn_client_diff_summarize_t const *)arg1,arg2);
        
        
        
        
    }
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_client_diff_summarize_t,0);
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


swig_class cSvn_client_ctx_t;

static VALUE
_wrap_svn_client_ctx_t_auth_baton_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_auth_baton_t *arg2 = (svn_auth_baton_t *) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_auth_baton_t, 1);
        
        
        
        arg2 = (svn_auth_baton_t *)temp2;
    }
    if (arg1) (arg1)->auth_baton = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_auth_baton_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_auth_baton_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (svn_auth_baton_t *) ((arg1)->auth_baton);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_auth_baton_t,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_notify_func_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_wc_notify_func_t arg2 = (svn_wc_notify_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_enum_svn_wc_notify_action_t_enum_svn_node_kind_t_p_q_const__char_enum_svn_wc_notify_state_t_enum_svn_wc_notify_state_t_long__void, 1);
        
        
        
        arg2 = (svn_wc_notify_func_t)temp2;
    }
    if (arg1) (arg1)->notify_func = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_notify_func_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_wc_notify_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (svn_wc_notify_func_t) ((arg1)->notify_func);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_enum_svn_wc_notify_action_t_enum_svn_node_kind_t_p_q_const__char_enum_svn_wc_notify_state_t_enum_svn_wc_notify_state_t_long__void,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_notify_baton_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *arg2 = (void *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    SWIG_ConvertPtr(argv[0], (void **) &arg2, 0, 1);
    if (arg1) (arg1)->notify_baton = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_notify_baton_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (void *) ((arg1)->notify_baton);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_void,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_log_msg_func_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_client_get_commit_log_t arg2 = (svn_client_get_commit_log_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_p_q_const__char_p_p_q_const__char_p_apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_client_get_commit_log_t)temp2;
    }
    if (arg1) (arg1)->log_msg_func = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_log_msg_func_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_client_get_commit_log_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (svn_client_get_commit_log_t) ((arg1)->log_msg_func);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_p_q_const__char_p_p_q_const__char_p_apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_log_msg_baton_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *arg2 = (void *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    SWIG_ConvertPtr(argv[0], (void **) &arg2, 0, 1);
    if (arg1) (arg1)->log_msg_baton = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_log_msg_baton_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (void *) ((arg1)->log_msg_baton);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_void,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_config_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    apr_hash_t *arg2 = (apr_hash_t *) 0 ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_hash_to_apr_hash_swig_type(argv[0], "svn_config_t *",
        _svn_client_config_pool());
    }
    if (arg1) (arg1)->config = arg2;
    
    {
        if (arg2)
        apr_pool_clear(_svn_client_config_pool());
    }
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_config_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    apr_hash_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (apr_hash_t *) ((arg1)->config);
    
    {
        vresult = svn_swig_rb_apr_hash_to_hash_swig_type(result, "svn_config_t *");
    }
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_cancel_func_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_cancel_func_t arg2 = (svn_cancel_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_cancel_func_t)temp2;
    }
    if (arg1) (arg1)->cancel_func = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_cancel_func_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_cancel_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (svn_cancel_func_t) ((arg1)->cancel_func);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_cancel_baton_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *arg2 = (void *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        arg2 = (void *)argv[0];
    }
    if (arg1) (arg1)->cancel_baton = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_cancel_baton_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (void *) ((arg1)->cancel_baton);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_void,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_notify_func2_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_wc_notify_func2_t arg2 = (svn_wc_notify_func2_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__struct_svn_wc_notify_t_p_apr_pool_t__void, 1);
        
        
        
        arg2 = (svn_wc_notify_func2_t)temp2;
    }
    if (arg1) (arg1)->notify_func2 = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_notify_func2_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_wc_notify_func2_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (svn_wc_notify_func2_t) ((arg1)->notify_func2);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__struct_svn_wc_notify_t_p_apr_pool_t__void,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_notify_baton2_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *arg2 = (void *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        arg2 = (void *)argv[0];
    }
    if (arg1) (arg1)->notify_baton2 = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_notify_baton2_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (void *) ((arg1)->notify_baton2);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_void,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_log_msg_func2_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_client_get_commit_log2_t arg2 = (svn_client_get_commit_log2_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_p_q_const__char_p_p_q_const__char_p_q_const__apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_client_get_commit_log2_t)temp2;
    }
    if (arg1) (arg1)->log_msg_func2 = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_log_msg_func2_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_client_get_commit_log2_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (svn_client_get_commit_log2_t) ((arg1)->log_msg_func2);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_p_q_const__char_p_p_q_const__char_p_q_const__apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_log_msg_baton2_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *arg2 = (void *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        arg2 = (void *)argv[0];
    }
    if (arg1) (arg1)->log_msg_baton2 = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_log_msg_baton2_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (void *) ((arg1)->log_msg_baton2);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_void,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_progress_func_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_ra_progress_notify_func_t arg2 = (svn_ra_progress_notify_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void, 1);
        
        
        
        arg2 = (svn_ra_progress_notify_func_t)temp2;
    }
    if (arg1) (arg1)->progress_func = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_progress_func_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_ra_progress_notify_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (svn_ra_progress_notify_func_t) ((arg1)->progress_func);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void,0);
    return vresult;
}


static VALUE
_wrap_svn_client_ctx_t_progress_baton_set(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *arg2 = (void *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    SWIG_ConvertPtr(argv[0], (void **) &arg2, 0, 1);
    if (arg1) (arg1)->progress_baton = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_client_ctx_t_progress_baton_get(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    void *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    result = (void *) ((arg1)->progress_baton);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_void,0);
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_client_ctx_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_client_ctx_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_client_ctx_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_client_ctx_t(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_client_ctx_t *)(svn_client_ctx_t *) calloc(1, sizeof(svn_client_ctx_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_client_ctx_t(svn_client_ctx_t *arg1) {
    free((char *) arg1);
}
static VALUE
_wrap_svn_client_create_context(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t **arg1 = (svn_client_ctx_t **) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_client_ctx_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_client_ctx_t **)&temp1;
    }
    if ((argc < 0) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    if (argc > 0) {
        
    }
    {
        result = (svn_error_t *)svn_client_create_context(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_client_ctx_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_checkout2(int argc, VALUE *argv, VALUE self) {
    svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg5 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_client_ctx_t *arg8 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg9 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_revnum_t temp1 ;
    svn_opt_revision_t rev4 ;
    svn_opt_revision_t rev5 ;
    void *temp8 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg9);
        _global_pool = arg9;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 6) || (argc > 8))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[2]);
    }
    {
        arg5 = &rev5;
        svn_swig_rb_set_revision(&rev5, argv[3]);
    }
    arg6 = RTEST(argv[4]);
    arg7 = RTEST(argv[5]);
    if (argc > 6) {
        {
            SWIG_ConvertPtr(argv[6], &temp8, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg8 = (svn_client_ctx_t *)temp8;
        }
    }
    if (argc > 7) {
        
    }
    {
        result = (svn_error_t *)svn_client_checkout2(arg1,(char const *)arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,(struct svn_opt_revision_t const *)arg5,arg6,arg7,arg8,arg9);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg1));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_checkout(int argc, VALUE *argv, VALUE self) {
    svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg5 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_revnum_t temp1 ;
    svn_opt_revision_t rev4 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[2]);
    }
    arg5 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_checkout(arg1,(char const *)arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg1));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_update2(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t **arg1 = (apr_array_header_t **) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg4 ;
    svn_boolean_t arg5 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_array_header_t *temp1 ;
    svn_opt_revision_t rev3 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        arg1 = &temp1;
    }
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    arg4 = RTEST(argv[2]);
    arg5 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_update2(arg1,(apr_array_header_t const *)arg2,(struct svn_opt_revision_t const *)arg3,arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, svn_swig_rb_apr_array_to_array_svn_rev(*arg1));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_update(int argc, VALUE *argv, VALUE self) {
    svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg4 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_revnum_t temp1 ;
    svn_opt_revision_t rev3 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    arg4 = RTEST(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_update(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg1));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_switch(int argc, VALUE *argv, VALUE self) {
    svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg5 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_revnum_t temp1 ;
    svn_opt_revision_t rev4 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[2]);
    }
    arg5 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_switch(arg1,(char const *)arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg1));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_add3(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_boolean_t arg2 ;
    svn_boolean_t arg3 ;
    svn_boolean_t arg4 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg1 = StringValuePtr(argv[0]);
    arg2 = RTEST(argv[1]);
    arg3 = RTEST(argv[2]);
    arg4 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_add3((char const *)arg1,arg2,arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_add2(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_boolean_t arg2 ;
    svn_boolean_t arg3 ;
    svn_client_ctx_t *arg4 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg1 = StringValuePtr(argv[0]);
    arg2 = RTEST(argv[1]);
    arg3 = RTEST(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp4, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg4 = (svn_client_ctx_t *)temp4;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_add2((char const *)arg1,arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_add(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_boolean_t arg2 ;
    svn_client_ctx_t *arg3 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    arg1 = StringValuePtr(argv[0]);
    arg2 = RTEST(argv[1]);
    if (argc > 2) {
        {
            SWIG_ConvertPtr(argv[2], &temp3, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg3 = (svn_client_ctx_t *)temp3;
        }
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_client_add((char const *)arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_mkdir2(int argc, VALUE *argv, VALUE self) {
    svn_commit_info_t **arg1 = (svn_commit_info_t **) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_client_ctx_t *arg3 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_commit_info_t *temp1 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_commit_info_t **)&temp1;
    }
    if ((argc < 1) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    if (argc > 1) {
        {
            SWIG_ConvertPtr(argv[1], &temp3, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg3 = (svn_client_ctx_t *)temp3;
        }
    }
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_client_mkdir2(arg1,(apr_array_header_t const *)arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_mkdir(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t **arg1 = (svn_client_commit_info_t **) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_client_ctx_t *arg3 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_client_commit_info_t *temp1 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_client_commit_info_t **)&temp1;
    }
    if ((argc < 1) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    if (argc > 1) {
        {
            SWIG_ConvertPtr(argv[1], &temp3, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg3 = (svn_client_ctx_t *)temp3;
        }
    }
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_client_mkdir(arg1,(apr_array_header_t const *)arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_client_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_delete2(int argc, VALUE *argv, VALUE self) {
    svn_commit_info_t **arg1 = (svn_commit_info_t **) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_boolean_t arg3 ;
    svn_client_ctx_t *arg4 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_commit_info_t *temp1 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_commit_info_t **)&temp1;
    }
    if ((argc < 2) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg3 = RTEST(argv[1]);
    if (argc > 2) {
        {
            SWIG_ConvertPtr(argv[2], &temp4, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg4 = (svn_client_ctx_t *)temp4;
        }
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_client_delete2(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_delete(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t **arg1 = (svn_client_commit_info_t **) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_boolean_t arg3 ;
    svn_client_ctx_t *arg4 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_client_commit_info_t *temp1 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_client_commit_info_t **)&temp1;
    }
    if ((argc < 2) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg3 = RTEST(argv[1]);
    if (argc > 2) {
        {
            SWIG_ConvertPtr(argv[2], &temp4, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg4 = (svn_client_ctx_t *)temp4;
        }
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_client_delete(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_client_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_import2(int argc, VALUE *argv, VALUE self) {
    svn_commit_info_t **arg1 = (svn_commit_info_t **) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_boolean_t arg4 ;
    svn_boolean_t arg5 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_commit_info_t *temp1 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_commit_info_t **)&temp1;
    }
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    arg4 = RTEST(argv[2]);
    arg5 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_import2(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_import(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t **arg1 = (svn_client_commit_info_t **) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_boolean_t arg4 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_client_commit_info_t *temp1 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_client_commit_info_t **)&temp1;
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    arg4 = RTEST(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_import(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_client_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_commit3(int argc, VALUE *argv, VALUE self) {
    svn_commit_info_t **arg1 = (svn_commit_info_t **) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_boolean_t arg3 ;
    svn_boolean_t arg4 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_commit_info_t *temp1 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_commit_info_t **)&temp1;
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg3 = RTEST(argv[1]);
    arg4 = RTEST(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_commit3(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_commit2(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t **arg1 = (svn_client_commit_info_t **) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_boolean_t arg3 ;
    svn_boolean_t arg4 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_client_commit_info_t *temp1 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_client_commit_info_t **)&temp1;
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg3 = RTEST(argv[1]);
    arg4 = RTEST(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_commit2(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_client_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_commit(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t **arg1 = (svn_client_commit_info_t **) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_boolean_t arg3 ;
    svn_client_ctx_t *arg4 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_client_commit_info_t *temp1 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_client_commit_info_t **)&temp1;
    }
    if ((argc < 2) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg3 = RTEST(argv[1]);
    if (argc > 2) {
        {
            SWIG_ConvertPtr(argv[2], &temp4, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg4 = (svn_client_ctx_t *)temp4;
        }
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_client_commit(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_client_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_status2(int argc, VALUE *argv, VALUE self) {
    svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_wc_status_func2_t arg4 = (svn_wc_status_func2_t) 0 ;
    void *arg5 = (void *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    svn_boolean_t arg9 ;
    svn_boolean_t arg10 ;
    svn_client_ctx_t *arg11 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg12 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_revnum_t temp1 ;
    svn_opt_revision_t rev3 ;
    void *temp11 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg12);
        _global_pool = arg12;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 8) || (argc > 10))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    {
        arg4 = svn_swig_rb_wc_status_func;
        arg5 = (void *)svn_swig_rb_make_baton(argv[2], _global_svn_swig_rb_pool);
    }
    arg6 = RTEST(argv[3]);
    arg7 = RTEST(argv[4]);
    arg8 = RTEST(argv[5]);
    arg9 = RTEST(argv[6]);
    arg10 = RTEST(argv[7]);
    if (argc > 8) {
        {
            SWIG_ConvertPtr(argv[8], &temp11, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg11 = (svn_client_ctx_t *)temp11;
        }
    }
    if (argc > 9) {
        
    }
    {
        result = (svn_error_t *)svn_client_status2(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10,arg11,arg12);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg1));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_status(int argc, VALUE *argv, VALUE self) {
    svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_wc_status_func_t arg4 = (svn_wc_status_func_t) 0 ;
    void *arg5 = (void *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    svn_boolean_t arg9 ;
    svn_client_ctx_t *arg10 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg11 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_revnum_t temp1 ;
    svn_opt_revision_t rev3 ;
    void *temp4 ;
    void *temp10 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg11);
        _global_pool = arg11;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 8) || (argc > 10))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    {
        SWIG_ConvertPtr(argv[2], &temp4, SWIGTYPE_p_f_p_void_p_q_const__char_p_struct_svn_wc_status_t__void, 1);
        
        
        
        arg4 = (svn_wc_status_func_t)temp4;
    }
    SWIG_ConvertPtr(argv[3], (void **) &arg5, 0, 1);
    arg6 = RTEST(argv[4]);
    arg7 = RTEST(argv[5]);
    arg8 = RTEST(argv[6]);
    arg9 = RTEST(argv[7]);
    if (argc > 8) {
        {
            SWIG_ConvertPtr(argv[8], &temp10, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg10 = (svn_client_ctx_t *)temp10;
        }
    }
    if (argc > 9) {
        
    }
    {
        result = (svn_error_t *)svn_client_status(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10,arg11);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg1));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_log3(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    int arg5 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_log_message_receiver_t arg8 = (svn_log_message_receiver_t) 0 ;
    void *arg9 = (void *) 0 ;
    svn_client_ctx_t *arg10 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg11 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    void *temp10 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg11);
        _global_pool = arg11;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 8) || (argc > 10))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    arg5 = NUM2INT(argv[4]);
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    {
        arg8 = svn_swig_rb_log_receiver;
        arg9 = (void *)svn_swig_rb_make_baton(argv[7], _global_svn_swig_rb_pool);
    }
    if (argc > 8) {
        {
            SWIG_ConvertPtr(argv[8], &temp10, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg10 = (svn_client_ctx_t *)temp10;
        }
    }
    if (argc > 9) {
        
    }
    {
        result = (svn_error_t *)svn_client_log3((apr_array_header_t const *)arg1,(struct svn_opt_revision_t const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6,arg7,arg8,arg9,arg10,arg11);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_log2(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    int arg4 ;
    svn_boolean_t arg5 ;
    svn_boolean_t arg6 ;
    svn_log_message_receiver_t arg7 = (svn_log_message_receiver_t) 0 ;
    void *arg8 = (void *) 0 ;
    svn_client_ctx_t *arg9 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev3 ;
    void *temp9 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 7) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    arg4 = NUM2INT(argv[3]);
    arg5 = RTEST(argv[4]);
    arg6 = RTEST(argv[5]);
    {
        arg7 = svn_swig_rb_log_receiver;
        arg8 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    if (argc > 7) {
        {
            SWIG_ConvertPtr(argv[7], &temp9, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg9 = (svn_client_ctx_t *)temp9;
        }
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_client_log2((apr_array_header_t const *)arg1,(struct svn_opt_revision_t const *)arg2,(struct svn_opt_revision_t const *)arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_log(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg4 ;
    svn_boolean_t arg5 ;
    svn_log_message_receiver_t arg6 = (svn_log_message_receiver_t) 0 ;
    void *arg7 = (void *) 0 ;
    svn_client_ctx_t *arg8 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg9 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev3 ;
    void *temp8 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg9);
        _global_pool = arg9;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 6) || (argc > 8))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    arg4 = RTEST(argv[3]);
    arg5 = RTEST(argv[4]);
    {
        arg6 = svn_swig_rb_log_receiver;
        arg7 = (void *)svn_swig_rb_make_baton(argv[5], _global_svn_swig_rb_pool);
    }
    if (argc > 6) {
        {
            SWIG_ConvertPtr(argv[6], &temp8, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg8 = (svn_client_ctx_t *)temp8;
        }
    }
    if (argc > 7) {
        
    }
    {
        result = (svn_error_t *)svn_client_log((apr_array_header_t const *)arg1,(struct svn_opt_revision_t const *)arg2,(struct svn_opt_revision_t const *)arg3,arg4,arg5,arg6,arg7,arg8,arg9);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_blame3(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_diff_file_options_t *arg5 = (svn_diff_file_options_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_client_blame_receiver_t arg7 = (svn_client_blame_receiver_t) 0 ;
    void *arg8 = (void *) 0 ;
    svn_client_ctx_t *arg9 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    void *temp5 ;
    void *temp9 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 7) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    {
        SWIG_ConvertPtr(argv[4], &temp5, SWIGTYPE_p_svn_diff_file_options_t, 1);
        
        
        
        arg5 = (svn_diff_file_options_t *)temp5;
    }
    arg6 = RTEST(argv[5]);
    {
        arg7 = svn_swig_rb_client_blame_receiver_func;
        arg8 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    if (argc > 7) {
        {
            SWIG_ConvertPtr(argv[7], &temp9, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg9 = (svn_client_ctx_t *)temp9;
        }
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_client_blame3((char const *)arg1,(struct svn_opt_revision_t const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,(struct svn_diff_file_options_t const *)arg5,arg6,arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_blame2(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_client_blame_receiver_t arg5 = (svn_client_blame_receiver_t) 0 ;
    void *arg6 = (void *) 0 ;
    svn_client_ctx_t *arg7 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    void *temp7 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 5) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    {
        arg5 = svn_swig_rb_client_blame_receiver_func;
        arg6 = (void *)svn_swig_rb_make_baton(argv[4], _global_svn_swig_rb_pool);
    }
    if (argc > 5) {
        {
            SWIG_ConvertPtr(argv[5], &temp7, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg7 = (svn_client_ctx_t *)temp7;
        }
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_client_blame2((char const *)arg1,(struct svn_opt_revision_t const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_blame(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_client_blame_receiver_t arg4 = (svn_client_blame_receiver_t) 0 ;
    void *arg5 = (void *) 0 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev3 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = svn_swig_rb_client_blame_receiver_func;
        arg5 = (void *)svn_swig_rb_make_baton(argv[3], _global_svn_swig_rb_pool);
    }
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_blame((char const *)arg1,(struct svn_opt_revision_t const *)arg2,(struct svn_opt_revision_t const *)arg3,arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_diff3(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_opt_revision_t *arg5 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    svn_boolean_t arg9 ;
    char *arg10 = (char *) 0 ;
    apr_file_t *arg11 = (apr_file_t *) 0 ;
    apr_file_t *arg12 = (apr_file_t *) 0 ;
    svn_client_ctx_t *arg13 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg14 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev5 ;
    void *temp13 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg14);
        _global_pool = arg14;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 12) || (argc > 14))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 12)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg2 = StringValuePtr(argv[1]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    arg4 = StringValuePtr(argv[3]);
    {
        arg5 = &rev5;
        svn_swig_rb_set_revision(&rev5, argv[4]);
    }
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    arg8 = RTEST(argv[7]);
    arg9 = RTEST(argv[8]);
    {
        arg10 = NULL;
        
        if (NIL_P(argv[9])) {
            
        } else if (TYPE(argv[9]) == T_FIXNUM) {
            arg10 = (char *)NUM2INT(argv[9]);
            if (!(arg10 == APR_LOCALE_CHARSET || arg10 == APR_DEFAULT_CHARSET)) {
                arg10 = NULL;
            }
        } else {
            arg10 = StringValuePtr(argv[9]);
        }
        
        if (!arg10) {
            arg10 = (char *)APR_LOCALE_CHARSET;
        }
    }
    {
        arg11 = svn_swig_rb_make_file(argv[10], _global_pool);
    }
    {
        arg12 = svn_swig_rb_make_file(argv[11], _global_pool);
    }
    if (argc > 12) {
        {
            SWIG_ConvertPtr(argv[12], &temp13, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg13 = (svn_client_ctx_t *)temp13;
        }
    }
    if (argc > 13) {
        
    }
    {
        result = (svn_error_t *)svn_client_diff3((apr_array_header_t const *)arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(char const *)arg4,(struct svn_opt_revision_t const *)arg5,arg6,arg7,arg8,arg9,(char const *)arg10,arg11,arg12,arg13,arg14);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_diff2(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_opt_revision_t *arg5 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    svn_boolean_t arg9 ;
    apr_file_t *arg10 = (apr_file_t *) 0 ;
    apr_file_t *arg11 = (apr_file_t *) 0 ;
    svn_client_ctx_t *arg12 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg13 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev5 ;
    void *temp12 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg13);
        _global_pool = arg13;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 11) || (argc > 13))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 11)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg2 = StringValuePtr(argv[1]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    arg4 = StringValuePtr(argv[3]);
    {
        arg5 = &rev5;
        svn_swig_rb_set_revision(&rev5, argv[4]);
    }
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    arg8 = RTEST(argv[7]);
    arg9 = RTEST(argv[8]);
    {
        arg10 = svn_swig_rb_make_file(argv[9], _global_pool);
    }
    {
        arg11 = svn_swig_rb_make_file(argv[10], _global_pool);
    }
    if (argc > 11) {
        {
            SWIG_ConvertPtr(argv[11], &temp12, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg12 = (svn_client_ctx_t *)temp12;
        }
    }
    if (argc > 12) {
        
    }
    {
        result = (svn_error_t *)svn_client_diff2((apr_array_header_t const *)arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(char const *)arg4,(struct svn_opt_revision_t const *)arg5,arg6,arg7,arg8,arg9,arg10,arg11,arg12,arg13);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_diff(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_opt_revision_t *arg5 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    apr_file_t *arg9 = (apr_file_t *) 0 ;
    apr_file_t *arg10 = (apr_file_t *) 0 ;
    svn_client_ctx_t *arg11 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg12 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev5 ;
    void *temp11 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg12);
        _global_pool = arg12;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 10) || (argc > 12))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 10)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg2 = StringValuePtr(argv[1]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    arg4 = StringValuePtr(argv[3]);
    {
        arg5 = &rev5;
        svn_swig_rb_set_revision(&rev5, argv[4]);
    }
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    arg8 = RTEST(argv[7]);
    {
        arg9 = svn_swig_rb_make_file(argv[8], _global_pool);
    }
    {
        arg10 = svn_swig_rb_make_file(argv[9], _global_pool);
    }
    if (argc > 10) {
        {
            SWIG_ConvertPtr(argv[10], &temp11, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg11 = (svn_client_ctx_t *)temp11;
        }
    }
    if (argc > 11) {
        
    }
    {
        result = (svn_error_t *)svn_client_diff((apr_array_header_t const *)arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(char const *)arg4,(struct svn_opt_revision_t const *)arg5,arg6,arg7,arg8,arg9,arg10,arg11,arg12);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_diff_peg3(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg5 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    svn_boolean_t arg9 ;
    char *arg10 = (char *) 0 ;
    apr_file_t *arg11 = (apr_file_t *) 0 ;
    apr_file_t *arg12 = (apr_file_t *) 0 ;
    svn_client_ctx_t *arg13 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg14 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    svn_opt_revision_t rev5 ;
    void *temp13 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg14);
        _global_pool = arg14;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 12) || (argc > 14))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 12)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg2 = StringValuePtr(argv[1]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    {
        arg5 = &rev5;
        svn_swig_rb_set_revision(&rev5, argv[4]);
    }
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    arg8 = RTEST(argv[7]);
    arg9 = RTEST(argv[8]);
    {
        arg10 = NULL;
        
        if (NIL_P(argv[9])) {
            
        } else if (TYPE(argv[9]) == T_FIXNUM) {
            arg10 = (char *)NUM2INT(argv[9]);
            if (!(arg10 == APR_LOCALE_CHARSET || arg10 == APR_DEFAULT_CHARSET)) {
                arg10 = NULL;
            }
        } else {
            arg10 = StringValuePtr(argv[9]);
        }
        
        if (!arg10) {
            arg10 = (char *)APR_LOCALE_CHARSET;
        }
    }
    {
        arg11 = svn_swig_rb_make_file(argv[10], _global_pool);
    }
    {
        arg12 = svn_swig_rb_make_file(argv[11], _global_pool);
    }
    if (argc > 12) {
        {
            SWIG_ConvertPtr(argv[12], &temp13, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg13 = (svn_client_ctx_t *)temp13;
        }
    }
    if (argc > 13) {
        
    }
    {
        result = (svn_error_t *)svn_client_diff_peg3((apr_array_header_t const *)arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,(struct svn_opt_revision_t const *)arg5,arg6,arg7,arg8,arg9,(char const *)arg10,arg11,arg12,arg13,arg14);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_diff_peg2(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg5 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    svn_boolean_t arg9 ;
    apr_file_t *arg10 = (apr_file_t *) 0 ;
    apr_file_t *arg11 = (apr_file_t *) 0 ;
    svn_client_ctx_t *arg12 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg13 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    svn_opt_revision_t rev5 ;
    void *temp12 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg13);
        _global_pool = arg13;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 11) || (argc > 13))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 11)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg2 = StringValuePtr(argv[1]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    {
        arg5 = &rev5;
        svn_swig_rb_set_revision(&rev5, argv[4]);
    }
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    arg8 = RTEST(argv[7]);
    arg9 = RTEST(argv[8]);
    {
        arg10 = svn_swig_rb_make_file(argv[9], _global_pool);
    }
    {
        arg11 = svn_swig_rb_make_file(argv[10], _global_pool);
    }
    if (argc > 11) {
        {
            SWIG_ConvertPtr(argv[11], &temp12, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg12 = (svn_client_ctx_t *)temp12;
        }
    }
    if (argc > 12) {
        
    }
    {
        result = (svn_error_t *)svn_client_diff_peg2((apr_array_header_t const *)arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,(struct svn_opt_revision_t const *)arg5,arg6,arg7,arg8,arg9,arg10,arg11,arg12,arg13);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_diff_peg(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg5 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    apr_file_t *arg9 = (apr_file_t *) 0 ;
    apr_file_t *arg10 = (apr_file_t *) 0 ;
    svn_client_ctx_t *arg11 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg12 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    svn_opt_revision_t rev5 ;
    void *temp11 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg12);
        _global_pool = arg12;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 10) || (argc > 12))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 10)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg2 = StringValuePtr(argv[1]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    {
        arg5 = &rev5;
        svn_swig_rb_set_revision(&rev5, argv[4]);
    }
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    arg8 = RTEST(argv[7]);
    {
        arg9 = svn_swig_rb_make_file(argv[8], _global_pool);
    }
    {
        arg10 = svn_swig_rb_make_file(argv[9], _global_pool);
    }
    if (argc > 10) {
        {
            SWIG_ConvertPtr(argv[10], &temp11, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg11 = (svn_client_ctx_t *)temp11;
        }
    }
    if (argc > 11) {
        
    }
    {
        result = (svn_error_t *)svn_client_diff_peg((apr_array_header_t const *)arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,(struct svn_opt_revision_t const *)arg5,arg6,arg7,arg8,arg9,arg10,arg11,arg12);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_diff_summarize(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg5 ;
    svn_boolean_t arg6 ;
    svn_client_diff_summarize_func_t arg7 = (svn_client_diff_summarize_func_t) 0 ;
    void *arg8 = (void *) 0 ;
    svn_client_ctx_t *arg9 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev4 ;
    void *temp9 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 7) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    arg3 = StringValuePtr(argv[2]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    arg5 = RTEST(argv[4]);
    arg6 = RTEST(argv[5]);
    {
        arg7 = svn_swig_rb_client_diff_summarize_func;
        arg8 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    if (argc > 7) {
        {
            SWIG_ConvertPtr(argv[7], &temp9, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg9 = (svn_client_ctx_t *)temp9;
        }
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_client_diff_summarize((char const *)arg1,(struct svn_opt_revision_t const *)arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6,arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_diff_summarize_peg(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg5 ;
    svn_boolean_t arg6 ;
    svn_client_diff_summarize_func_t arg7 = (svn_client_diff_summarize_func_t) 0 ;
    void *arg8 = (void *) 0 ;
    svn_client_ctx_t *arg9 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    void *temp9 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 7) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    arg5 = RTEST(argv[4]);
    arg6 = RTEST(argv[5]);
    {
        arg7 = svn_swig_rb_client_diff_summarize_func;
        arg8 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    if (argc > 7) {
        {
            SWIG_ConvertPtr(argv[7], &temp9, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg9 = (svn_client_ctx_t *)temp9;
        }
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_client_diff_summarize_peg((char const *)arg1,(struct svn_opt_revision_t const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6,arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_merge2(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    char *arg5 = (char *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    svn_boolean_t arg9 ;
    apr_array_header_t *arg10 = (apr_array_header_t *) 0 ;
    svn_client_ctx_t *arg11 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg12 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev4 ;
    void *temp11 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg12);
        _global_pool = arg12;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 10) || (argc > 12))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 10)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    arg3 = StringValuePtr(argv[2]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    arg5 = StringValuePtr(argv[4]);
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    arg8 = RTEST(argv[7]);
    arg9 = RTEST(argv[8]);
    {
        if (NIL_P(argv[9])) {
            arg10 = NULL;
        } else {
            VALUE rb_pool;
            apr_pool_t *pool;
            
            svn_swig_rb_get_pool(argc, argv, self, &rb_pool, &pool);
            arg10 = svn_swig_rb_array_to_apr_array_prop(argv[9], pool);
        }
    }
    if (argc > 10) {
        {
            SWIG_ConvertPtr(argv[10], &temp11, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg11 = (svn_client_ctx_t *)temp11;
        }
    }
    if (argc > 11) {
        
    }
    {
        result = (svn_error_t *)svn_client_merge2((char const *)arg1,(struct svn_opt_revision_t const *)arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,(char const *)arg5,arg6,arg7,arg8,arg9,(apr_array_header_t const *)arg10,arg11,arg12);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_merge(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    char *arg5 = (char *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    svn_boolean_t arg9 ;
    svn_client_ctx_t *arg10 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg11 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev4 ;
    void *temp10 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg11);
        _global_pool = arg11;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 9) || (argc > 11))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 9)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    arg3 = StringValuePtr(argv[2]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    arg5 = StringValuePtr(argv[4]);
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    arg8 = RTEST(argv[7]);
    arg9 = RTEST(argv[8]);
    if (argc > 9) {
        {
            SWIG_ConvertPtr(argv[9], &temp10, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg10 = (svn_client_ctx_t *)temp10;
        }
    }
    if (argc > 10) {
        
    }
    {
        result = (svn_error_t *)svn_client_merge((char const *)arg1,(struct svn_opt_revision_t const *)arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,(char const *)arg5,arg6,arg7,arg8,arg9,arg10,arg11);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_merge_peg2(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    char *arg5 = (char *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    svn_boolean_t arg9 ;
    apr_array_header_t *arg10 = (apr_array_header_t *) 0 ;
    svn_client_ctx_t *arg11 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg12 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    void *temp11 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg12);
        _global_pool = arg12;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 10) || (argc > 12))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 10)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    arg5 = StringValuePtr(argv[4]);
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    arg8 = RTEST(argv[7]);
    arg9 = RTEST(argv[8]);
    {
        if (NIL_P(argv[9])) {
            arg10 = NULL;
        } else {
            VALUE rb_pool;
            apr_pool_t *pool;
            
            svn_swig_rb_get_pool(argc, argv, self, &rb_pool, &pool);
            arg10 = svn_swig_rb_array_to_apr_array_prop(argv[9], pool);
        }
    }
    if (argc > 10) {
        {
            SWIG_ConvertPtr(argv[10], &temp11, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg11 = (svn_client_ctx_t *)temp11;
        }
    }
    if (argc > 11) {
        
    }
    {
        result = (svn_error_t *)svn_client_merge_peg2((char const *)arg1,(struct svn_opt_revision_t const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,(char const *)arg5,arg6,arg7,arg8,arg9,(apr_array_header_t const *)arg10,arg11,arg12);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_merge_peg(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    char *arg5 = (char *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    svn_boolean_t arg9 ;
    svn_client_ctx_t *arg10 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg11 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    void *temp10 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg11);
        _global_pool = arg11;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 9) || (argc > 11))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 9)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    arg5 = StringValuePtr(argv[4]);
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    arg8 = RTEST(argv[7]);
    arg9 = RTEST(argv[8]);
    if (argc > 9) {
        {
            SWIG_ConvertPtr(argv[9], &temp10, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg10 = (svn_client_ctx_t *)temp10;
        }
    }
    if (argc > 10) {
        
    }
    {
        result = (svn_error_t *)svn_client_merge_peg((char const *)arg1,(struct svn_opt_revision_t const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,(char const *)arg5,arg6,arg7,arg8,arg9,arg10,arg11);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_cleanup(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_client_ctx_t *arg2 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp2 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    arg1 = StringValuePtr(argv[0]);
    if (argc > 1) {
        {
            SWIG_ConvertPtr(argv[1], &temp2, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg2 = (svn_client_ctx_t *)temp2;
        }
    }
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_client_cleanup((char const *)arg1,arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_relocate(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_boolean_t arg4 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg1 = StringValuePtr(argv[0]);
    arg2 = StringValuePtr(argv[1]);
    arg3 = StringValuePtr(argv[2]);
    arg4 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_relocate((char const *)arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_revert(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    svn_boolean_t arg2 ;
    svn_client_ctx_t *arg3 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg2 = RTEST(argv[1]);
    if (argc > 2) {
        {
            SWIG_ConvertPtr(argv[2], &temp3, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg3 = (svn_client_ctx_t *)temp3;
        }
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_client_revert((apr_array_header_t const *)arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_resolved(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_boolean_t arg2 ;
    svn_client_ctx_t *arg3 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    arg1 = StringValuePtr(argv[0]);
    arg2 = RTEST(argv[1]);
    if (argc > 2) {
        {
            SWIG_ConvertPtr(argv[2], &temp3, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg3 = (svn_client_ctx_t *)temp3;
        }
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_client_resolved((char const *)arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_copy3(int argc, VALUE *argv, VALUE self) {
    svn_commit_info_t **arg1 = (svn_commit_info_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_commit_info_t *temp1 ;
    svn_opt_revision_t rev3 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_commit_info_t **)&temp1;
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    arg4 = StringValuePtr(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_copy3(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(char const *)arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_copy2(int argc, VALUE *argv, VALUE self) {
    svn_commit_info_t **arg1 = (svn_commit_info_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_commit_info_t *temp1 ;
    svn_opt_revision_t rev3 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_commit_info_t **)&temp1;
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    arg4 = StringValuePtr(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_copy2(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(char const *)arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_copy(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t **arg1 = (svn_client_commit_info_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_client_commit_info_t *temp1 ;
    svn_opt_revision_t rev3 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_client_commit_info_t **)&temp1;
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    arg4 = StringValuePtr(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_copy(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(char const *)arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_client_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_move4(int argc, VALUE *argv, VALUE self) {
    svn_commit_info_t **arg1 = (svn_commit_info_t **) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_boolean_t arg4 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_commit_info_t *temp1 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_commit_info_t **)&temp1;
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    arg4 = RTEST(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_move4(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_move3(int argc, VALUE *argv, VALUE self) {
    svn_commit_info_t **arg1 = (svn_commit_info_t **) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_boolean_t arg4 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_commit_info_t *temp1 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_commit_info_t **)&temp1;
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    arg4 = RTEST(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_move3(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_move2(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t **arg1 = (svn_client_commit_info_t **) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_boolean_t arg4 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_client_commit_info_t *temp1 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_client_commit_info_t **)&temp1;
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    arg4 = RTEST(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_move2(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_client_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_move(int argc, VALUE *argv, VALUE self) {
    svn_client_commit_info_t **arg1 = (svn_client_commit_info_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_boolean_t arg5 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_client_commit_info_t *temp1 ;
    svn_opt_revision_t rev3 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_client_commit_info_t **)&temp1;
    }
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    arg4 = StringValuePtr(argv[2]);
    arg5 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_move(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(char const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_client_commit_info_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_propset2(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_string_t *arg2 = (svn_string_t *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_boolean_t arg4 ;
    svn_boolean_t arg5 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_string_t value2 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 5) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        if (NIL_P(argv[1])) {
            arg2 = NULL;
        } else {
            value2.data = StringValuePtr(argv[1]);
            value2.len = RSTRING(argv[1])->len;
            arg2 = &value2;
        }
    }
    arg3 = StringValuePtr(argv[2]);
    arg4 = RTEST(argv[3]);
    arg5 = RTEST(argv[4]);
    if (argc > 5) {
        {
            SWIG_ConvertPtr(argv[5], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_client_propset2((char const *)arg1,(struct svn_string_t const *)arg2,(char const *)arg3,arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_propset(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_string_t *arg2 = (svn_string_t *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_boolean_t arg4 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_string_t value2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        if (NIL_P(argv[1])) {
            arg2 = NULL;
        } else {
            value2.data = StringValuePtr(argv[1]);
            value2.len = RSTRING(argv[1])->len;
            arg2 = &value2;
        }
    }
    arg3 = StringValuePtr(argv[2]);
    arg4 = RTEST(argv[3]);
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_propset((char const *)arg1,(struct svn_string_t const *)arg2,(char const *)arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_revprop_set(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_string_t *arg2 = (svn_string_t *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_revnum_t *arg5 = (svn_revnum_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_client_ctx_t *arg7 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_string_t value2 ;
    svn_opt_revision_t rev4 ;
    svn_revnum_t temp5 ;
    void *temp7 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg5 = &temp5;
    if ((argc < 5) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        if (NIL_P(argv[1])) {
            arg2 = NULL;
        } else {
            value2.data = StringValuePtr(argv[1]);
            value2.len = RSTRING(argv[1])->len;
            arg2 = &value2;
        }
    }
    arg3 = StringValuePtr(argv[2]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    arg6 = RTEST(argv[4]);
    if (argc > 5) {
        {
            SWIG_ConvertPtr(argv[5], &temp7, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg7 = (svn_client_ctx_t *)temp7;
        }
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_client_revprop_set((char const *)arg1,(struct svn_string_t const *)arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg5));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_propget2(int argc, VALUE *argv, VALUE self) {
    apr_hash_t **arg1 = (apr_hash_t **) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg5 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_client_ctx_t *arg7 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_hash_t *temp1 ;
    svn_opt_revision_t rev4 ;
    svn_opt_revision_t rev5 ;
    void *temp7 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 5) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[2]);
    }
    {
        arg5 = &rev5;
        svn_swig_rb_set_revision(&rev5, argv[3]);
    }
    arg6 = RTEST(argv[4]);
    if (argc > 5) {
        {
            SWIG_ConvertPtr(argv[5], &temp7, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg7 = (svn_client_ctx_t *)temp7;
        }
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_client_propget2(arg1,(char const *)arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,(struct svn_opt_revision_t const *)arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_svn_string(*arg1));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_propget(int argc, VALUE *argv, VALUE self) {
    apr_hash_t **arg1 = (apr_hash_t **) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg5 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_hash_t *temp1 ;
    svn_opt_revision_t rev4 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[2]);
    }
    arg5 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_propget(arg1,(char const *)arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_svn_string(*arg1));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_revprop_get(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_string_t **arg2 = (svn_string_t **) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_revnum_t *arg5 = (svn_revnum_t *) 0 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_string_t *temp2 ;
    svn_opt_revision_t rev4 ;
    svn_revnum_t temp5 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        arg2 = &temp2;
    }
    arg5 = &temp5;
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg1 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[2]);
    }
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_revprop_get((char const *)arg1,arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg2) {
            vresult = output_helper(vresult, rb_str_new((*arg2)->data, (*arg2)->len));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        VALUE o = INT2NUM((long) (*arg5));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_proplist2(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t **arg1 = (apr_array_header_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg5 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_array_header_t *temp1 ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        arg1 = &temp1;
    }
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[2]);
    }
    arg5 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_proplist2(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = svn_swig_rb_apr_array_to_array_proplist_item(*arg1);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_proplist(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t **arg1 = (apr_array_header_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg4 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_array_header_t *temp1 ;
    svn_opt_revision_t rev3 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        arg1 = &temp1;
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    arg4 = RTEST(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_proplist(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = svn_swig_rb_apr_array_to_array_proplist_item(*arg1);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_revprop_list(int argc, VALUE *argv, VALUE self) {
    apr_hash_t **arg1 = (apr_hash_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_revnum_t *arg4 = (svn_revnum_t *) 0 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_hash_t *temp1 ;
    svn_opt_revision_t rev3 ;
    svn_revnum_t temp4 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    arg4 = &temp4;
    if ((argc < 2) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    if (argc > 2) {
        {
            SWIG_ConvertPtr(argv[2], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_client_revprop_list(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_svn_string(*arg1));
    }
    {
        VALUE o = INT2NUM((long) (*arg4));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_export3(int argc, VALUE *argv, VALUE self) {
    svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg5 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    char *arg9 = (char *) 0 ;
    svn_client_ctx_t *arg10 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg11 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_revnum_t temp1 ;
    svn_opt_revision_t rev4 ;
    svn_opt_revision_t rev5 ;
    void *temp10 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg11);
        _global_pool = arg11;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 8) || (argc > 10))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[2]);
    }
    {
        arg5 = &rev5;
        svn_swig_rb_set_revision(&rev5, argv[3]);
    }
    arg6 = RTEST(argv[4]);
    arg7 = RTEST(argv[5]);
    arg8 = RTEST(argv[6]);
    {
        if (NIL_P(argv[7])) {
            arg9 = NULL;
        } else {
            arg9 = StringValuePtr(argv[7]);
        }
    }
    if (argc > 8) {
        {
            SWIG_ConvertPtr(argv[8], &temp10, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg10 = (svn_client_ctx_t *)temp10;
        }
    }
    if (argc > 9) {
        
    }
    {
        result = (svn_error_t *)svn_client_export3(arg1,(char const *)arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,(struct svn_opt_revision_t const *)arg5,arg6,arg7,arg8,(char const *)arg9,arg10,arg11);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg1));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_export2(int argc, VALUE *argv, VALUE self) {
    svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg5 ;
    char *arg6 = (char *) 0 ;
    svn_client_ctx_t *arg7 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_revnum_t temp1 ;
    svn_opt_revision_t rev4 ;
    void *temp7 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 5) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[2]);
    }
    arg5 = RTEST(argv[3]);
    {
        if (NIL_P(argv[4])) {
            arg6 = NULL;
        } else {
            arg6 = StringValuePtr(argv[4]);
        }
    }
    if (argc > 5) {
        {
            SWIG_ConvertPtr(argv[5], &temp7, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg7 = (svn_client_ctx_t *)temp7;
        }
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_client_export2(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,(char const *)arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg1));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_export(int argc, VALUE *argv, VALUE self) {
    svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg5 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_revnum_t temp1 ;
    svn_opt_revision_t rev4 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[2]);
    }
    arg5 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_export(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg1));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_list(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg4 ;
    apr_uint32_t arg5 ;
    svn_boolean_t arg6 ;
    svn_client_list_func_t arg7 = (svn_client_list_func_t) 0 ;
    void *arg8 = (void *) 0 ;
    svn_client_ctx_t *arg9 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev3 ;
    void *temp9 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 7) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    arg4 = RTEST(argv[3]);
    arg5 = NUM2ULONG(argv[4]);
    arg6 = RTEST(argv[5]);
    {
        arg7 = svn_swig_rb_client_list_func;
        arg8 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    if (argc > 7) {
        {
            SWIG_ConvertPtr(argv[7], &temp9, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg9 = (svn_client_ctx_t *)temp9;
        }
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_client_list((char const *)arg1,(struct svn_opt_revision_t const *)arg2,(struct svn_opt_revision_t const *)arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_ls3(int argc, VALUE *argv, VALUE self) {
    apr_hash_t **arg1 = (apr_hash_t **) 0 ;
    apr_hash_t **arg2 = (apr_hash_t **) 0 ;
    char *arg3 = (char *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg5 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg6 ;
    svn_client_ctx_t *arg7 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_hash_t *temp1 ;
    apr_hash_t *temp2 ;
    svn_opt_revision_t rev4 ;
    svn_opt_revision_t rev5 ;
    void *temp7 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    arg2 = &temp2;
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg3 = StringValuePtr(argv[0]);
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[1]);
    }
    {
        arg5 = &rev5;
        svn_swig_rb_set_revision(&rev5, argv[2]);
    }
    arg6 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp7, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg7 = (svn_client_ctx_t *)temp7;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_ls3(arg1,arg2,(char const *)arg3,(struct svn_opt_revision_t const *)arg4,(struct svn_opt_revision_t const *)arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_swig_type
        (*arg1, "svn_dirent_t *"));
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_swig_type
        (*arg2, "svn_lock_t *"));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_ls2(int argc, VALUE *argv, VALUE self) {
    apr_hash_t **arg1 = (apr_hash_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg5 ;
    svn_client_ctx_t *arg6 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_hash_t *temp1 ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    void *temp6 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[2]);
    }
    arg5 = RTEST(argv[3]);
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp6, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg6 = (svn_client_ctx_t *)temp6;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_ls2(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_swig_type
        (*arg1, "svn_dirent_t *"));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_ls(int argc, VALUE *argv, VALUE self) {
    apr_hash_t **arg1 = (apr_hash_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_boolean_t arg4 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_hash_t *temp1 ;
    svn_opt_revision_t rev3 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[1]);
    }
    arg4 = RTEST(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_ls(arg1,(char const *)arg2,arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_swig_type
        (*arg1, "svn_dirent_t *"));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_cat2(int argc, VALUE *argv, VALUE self) {
    svn_stream_t *arg1 = (svn_stream_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg4 = (svn_opt_revision_t *) 0 ;
    svn_client_ctx_t *arg5 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev3 ;
    svn_opt_revision_t rev4 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        arg1 = svn_swig_rb_make_stream(argv[0]);
    }
    arg2 = StringValuePtr(argv[1]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = &rev4;
        svn_swig_rb_set_revision(&rev4, argv[3]);
    }
    if (argc > 4) {
        {
            SWIG_ConvertPtr(argv[4], &temp5, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg5 = (svn_client_ctx_t *)temp5;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_client_cat2(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,(struct svn_opt_revision_t const *)arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_cat(int argc, VALUE *argv, VALUE self) {
    svn_stream_t *arg1 = (svn_stream_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_client_ctx_t *arg4 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev3 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        arg1 = svn_swig_rb_make_stream(argv[0]);
    }
    arg2 = StringValuePtr(argv[1]);
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp4, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg4 = (svn_client_ctx_t *)temp4;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_cat(arg1,(char const *)arg2,(struct svn_opt_revision_t const *)arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_lock(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_boolean_t arg3 ;
    svn_client_ctx_t *arg4 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    {
        if (NIL_P(argv[1])) {
            arg2 = NULL;
        } else {
            arg2 = StringValuePtr(argv[1]);
        }
    }
    arg3 = RTEST(argv[2]);
    if (argc > 3) {
        {
            SWIG_ConvertPtr(argv[3], &temp4, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg4 = (svn_client_ctx_t *)temp4;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_client_lock((apr_array_header_t const *)arg1,(char const *)arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_unlock(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t *arg1 = (apr_array_header_t *) 0 ;
    svn_boolean_t arg2 ;
    svn_client_ctx_t *arg3 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        arg1 = svn_swig_rb_strings_to_apr_array(argv[0], _global_pool);
    }
    arg2 = RTEST(argv[1]);
    if (argc > 2) {
        {
            SWIG_ConvertPtr(argv[2], &temp3, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg3 = (svn_client_ctx_t *)temp3;
        }
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_client_unlock((apr_array_header_t const *)arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


swig_class cSvn_info_t;

static VALUE
_wrap_svn_info_t_URL_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->URL) free((char *)arg1->URL);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->URL = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_info_t_URL_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (char *) ((arg1)->URL);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_info_t_rev_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_revnum_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = NUM2LONG(argv[0]);
    if (arg1) (arg1)->rev = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_info_t_rev_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_revnum_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (svn_revnum_t) ((arg1)->rev);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_info_t_kind_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_node_kind_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = (svn_node_kind_t) NUM2INT(argv[0]);
    if (arg1) (arg1)->kind = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_info_t_kind_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_node_kind_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (svn_node_kind_t) ((arg1)->kind);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_info_t_repos_root_URL_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->repos_root_URL) free((char *)arg1->repos_root_URL);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->repos_root_URL = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_info_t_repos_root_URL_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (char *) ((arg1)->repos_root_URL);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_info_t_repos_UUID_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->repos_UUID) free((char *)arg1->repos_UUID);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->repos_UUID = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_info_t_repos_UUID_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (char *) ((arg1)->repos_UUID);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_info_t_last_changed_rev_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_revnum_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = NUM2LONG(argv[0]);
    if (arg1) (arg1)->last_changed_rev = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_info_t_last_changed_rev_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_revnum_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (svn_revnum_t) ((arg1)->last_changed_rev);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_info_t_last_changed_date_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    apr_time_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = (apr_time_t) NUM2LL(argv[0]);
    if (arg1) (arg1)->last_changed_date = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_info_t_last_changed_date_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    apr_time_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result =  ((arg1)->last_changed_date);
    
    vresult = LL2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_info_t_last_changed_author_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->last_changed_author) free((char *)arg1->last_changed_author);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->last_changed_author = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_info_t_last_changed_author_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (char *) ((arg1)->last_changed_author);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_info_t_lock_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_lock_t *arg2 = (svn_lock_t *) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_lock_t, 1);
        
        
        
        arg2 = (svn_lock_t *)temp2;
    }
    if (arg1) (arg1)->lock = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_info_t_lock_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_lock_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (svn_lock_t *) ((arg1)->lock);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_lock_t,0);
    return vresult;
}


static VALUE
_wrap_svn_info_t_has_wc_info_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_boolean_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = RTEST(argv[0]);
    if (arg1) (arg1)->has_wc_info = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_info_t_has_wc_info_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_boolean_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (svn_boolean_t) ((arg1)->has_wc_info);
    
    {
        vresult = output_helper(vresult, result ? Qtrue : Qfalse);
    }
    return vresult;
}


static VALUE
_wrap_svn_info_t_schedule_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_wc_schedule_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = (svn_wc_schedule_t) NUM2INT(argv[0]);
    if (arg1) (arg1)->schedule = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_info_t_schedule_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_wc_schedule_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (svn_wc_schedule_t) ((arg1)->schedule);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_info_t_copyfrom_url_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    {
        if (NIL_P(argv[0])) {
            arg2 = NULL;
        } else {
            arg2 = StringValuePtr(argv[0]);
        }
    }
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->copyfrom_url) free((char *)arg1->copyfrom_url);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->copyfrom_url = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_info_t_copyfrom_url_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (char *) ((arg1)->copyfrom_url);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_info_t_copyfrom_rev_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_revnum_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = NUM2LONG(argv[0]);
    if (arg1) (arg1)->copyfrom_rev = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_info_t_copyfrom_rev_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    svn_revnum_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (svn_revnum_t) ((arg1)->copyfrom_rev);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_info_t_text_time_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    apr_time_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = (apr_time_t) NUM2LL(argv[0]);
    if (arg1) (arg1)->text_time = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_info_t_text_time_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    apr_time_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result =  ((arg1)->text_time);
    
    vresult = LL2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_info_t_prop_time_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    apr_time_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = (apr_time_t) NUM2LL(argv[0]);
    if (arg1) (arg1)->prop_time = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_info_t_prop_time_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    apr_time_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result =  ((arg1)->prop_time);
    
    vresult = LL2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_info_t_checksum_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->checksum) free((char *)arg1->checksum);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->checksum = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_info_t_checksum_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (char *) ((arg1)->checksum);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_info_t_conflict_old_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->conflict_old) free((char *)arg1->conflict_old);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->conflict_old = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_info_t_conflict_old_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (char *) ((arg1)->conflict_old);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_info_t_conflict_new_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->conflict_new) free((char *)arg1->conflict_new);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->conflict_new = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_info_t_conflict_new_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (char *) ((arg1)->conflict_new);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_info_t_conflict_wrk_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->conflict_wrk) free((char *)arg1->conflict_wrk);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->conflict_wrk = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_info_t_conflict_wrk_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (char *) ((arg1)->conflict_wrk);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_info_t_prejfile_set(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->prejfile) free((char *)arg1->prejfile);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->prejfile = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_info_t_prejfile_get(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    result = (char *) ((arg1)->prejfile);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_info_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_info_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_info_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_info_t(int argc, VALUE *argv, VALUE self) {
    svn_info_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_info_t *)(svn_info_t *) calloc(1, sizeof(svn_info_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_info_t(svn_info_t *arg1) {
    free((char *) arg1);
}
static VALUE
_wrap_svn_info_dup(int argc, VALUE *argv, VALUE self) {
    svn_info_t *arg1 = (svn_info_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_info_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_info_t, 1);
        
        
        
        arg1 = (svn_info_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (svn_info_t *)svn_info_dup((struct svn_info_t const *)arg1,arg2);
        
        
        
        
    }
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_info_t,0);
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_info(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_opt_revision_t *arg2 = (svn_opt_revision_t *) 0 ;
    svn_opt_revision_t *arg3 = (svn_opt_revision_t *) 0 ;
    svn_info_receiver_t arg4 = (svn_info_receiver_t) 0 ;
    void *arg5 = (void *) 0 ;
    svn_boolean_t arg6 ;
    svn_client_ctx_t *arg7 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_opt_revision_t rev2 ;
    svn_opt_revision_t rev3 ;
    void *temp7 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 5) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    arg1 = StringValuePtr(argv[0]);
    {
        arg2 = &rev2;
        svn_swig_rb_set_revision(&rev2, argv[1]);
    }
    {
        arg3 = &rev3;
        svn_swig_rb_set_revision(&rev3, argv[2]);
    }
    {
        arg4 = svn_swig_rb_info_receiver;
        arg5 = (void *)svn_swig_rb_make_baton(argv[3], _global_svn_swig_rb_pool);
    }
    arg6 = RTEST(argv[4]);
    if (argc > 5) {
        {
            SWIG_ConvertPtr(argv[5], &temp7, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg7 = (svn_client_ctx_t *)temp7;
        }
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_client_info((char const *)arg1,(struct svn_opt_revision_t const *)arg2,(struct svn_opt_revision_t const *)arg3,arg4,arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_url_from_path(int argc, VALUE *argv, VALUE self) {
    char **arg1 = (char **) 0 ;
    char *arg2 = (char *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    char const *temp1 = NULL ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = (char **)&temp1;
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    arg2 = StringValuePtr(argv[0]);
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_client_url_from_path((char const **)arg1,(char const *)arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg1) {
            vresult = output_helper(vresult, rb_str_new2(*arg1));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_uuid_from_url(int argc, VALUE *argv, VALUE self) {
    char **arg1 = (char **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_client_ctx_t *arg3 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    char const *temp1 = NULL ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = (char **)&temp1;
    if ((argc < 1) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    arg2 = StringValuePtr(argv[0]);
    if (argc > 1) {
        {
            SWIG_ConvertPtr(argv[1], &temp3, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg3 = (svn_client_ctx_t *)temp3;
        }
    }
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_client_uuid_from_url((char const **)arg1,(char const *)arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg1) {
            vresult = output_helper(vresult, rb_str_new2(*arg1));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_uuid_from_path(int argc, VALUE *argv, VALUE self) {
    char **arg1 = (char **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_wc_adm_access_t *arg3 = (svn_wc_adm_access_t *) 0 ;
    svn_client_ctx_t *arg4 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    char const *temp1 = NULL ;
    void *temp3 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = (char **)&temp1;
    if ((argc < 2) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        SWIG_ConvertPtr(argv[1], &temp3, SWIGTYPE_p_svn_wc_adm_access_t, 1);
        
        
        
        arg3 = (svn_wc_adm_access_t *)temp3;
    }
    if (argc > 2) {
        {
            SWIG_ConvertPtr(argv[2], &temp4, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg4 = (svn_client_ctx_t *)temp4;
        }
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_client_uuid_from_path((char const **)arg1,(char const *)arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg1) {
            vresult = output_helper(vresult, rb_str_new2(*arg1));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_open_ra_session(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t **arg1 = (svn_ra_session_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_client_ctx_t *arg3 = (svn_client_ctx_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_ra_session_t *temp1 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        int adjusted_argc = argc;
        VALUE *adjusted_argv = argv;
        
        svn_swig_rb_adjust_arg_for_client_ctx_and_pool(&adjusted_argc,
        &adjusted_argv);
        svn_swig_rb_get_pool(adjusted_argc, adjusted_argv, self,
        &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_ra_session_t **)&temp1;
    }
    if ((argc < 1) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    arg2 = StringValuePtr(argv[0]);
    if (argc > 1) {
        {
            SWIG_ConvertPtr(argv[1], &temp3, SWIGTYPE_p_svn_client_ctx_t, 1);
            
            
            
            arg3 = (svn_client_ctx_t *)temp3;
        }
    }
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_client_open_ra_session(arg1,(char const *)arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_ra_session_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_set_log_msg_func2(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_client_get_commit_log2_t arg2 = (svn_client_get_commit_log2_t) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    VALUE result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_get_commit_log_func2;
        arg3 = (void *)svn_swig_rb_make_baton(argv[1], _global_svn_swig_rb_pool);
    }
    if (argc > 2) {
        
    }
    {
        result = (VALUE)svn_client_set_log_msg_func2(arg1,arg2,arg3,arg4);
        
        
        
        
    }
    vresult = result;
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_set_notify_func2(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_wc_notify_func2_t arg2 = (svn_wc_notify_func2_t) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    VALUE result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_notify_func2;
        arg3 = (void *)svn_swig_rb_make_baton(argv[1], _global_svn_swig_rb_pool);
    }
    if (argc > 2) {
        
    }
    {
        result = (VALUE)svn_client_set_notify_func2(arg1,arg2,arg3,arg4);
        
        
        
        
    }
    vresult = result;
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_client_set_cancel_func(int argc, VALUE *argv, VALUE self) {
    svn_client_ctx_t *arg1 = (svn_client_ctx_t *) 0 ;
    svn_cancel_func_t arg2 = (svn_cancel_func_t) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    VALUE result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_client_ctx_t, 1);
        
        
        
        arg1 = (svn_client_ctx_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_cancel_func;
        arg3 = (void *)svn_swig_rb_make_baton(argv[1], _global_svn_swig_rb_pool);
    }
    if (argc > 2) {
        
    }
    {
        result = (VALUE)svn_client_set_cancel_func(arg1,arg2,arg3,arg4);
        
        
        
        
    }
    vresult = result;
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg3);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}



/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (BEGIN) -------- */

static swig_type_info _swigt__p_apr_array_header_t = {"_p_apr_array_header_t", "apr_array_header_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_file_t = {"_p_apr_file_t", "apr_file_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_hash_t = {"_p_apr_hash_t", "apr_hash_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int32_t = {"_p_apr_int32_t", "apr_int32_t *|time_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int64_t = {"_p_apr_int64_t", "apr_int64_t *|svn_filesize_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_pool_t = {"_p_apr_pool_t", "apr_pool_t *", 0, 0, 0};
static swig_type_info _swigt__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void = {"_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void", "void (*)(apr_off_t,apr_off_t,void *,apr_pool_t *)|svn_ra_progress_notify_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(apr_getopt_t *,void *,apr_pool_t *)|svn_opt_subcommand_t *", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_q_const__char_p_p_q_const__char_p_apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_q_const__char_p_p_q_const__char_p_apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(char const **,char const **,apr_array_header_t *,void *,apr_pool_t *)|svn_client_get_commit_log_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_q_const__char_p_p_q_const__char_p_q_const__apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_q_const__char_p_p_q_const__char_p_q_const__apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(char const **,char const **,apr_array_header_t const *,void *,apr_pool_t *)|svn_client_get_commit_log2_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_svn_auth_cred_simple_t_p_void_p_q_const__char_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_svn_auth_cred_simple_t_p_void_p_q_const__char_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_auth_cred_simple_t **,void *,char const *,char const *,svn_boolean_t,apr_pool_t *)|svn_auth_simple_prompt_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_svn_auth_cred_ssl_client_cert_pw_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_svn_auth_cred_ssl_client_cert_pw_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_auth_cred_ssl_client_cert_pw_t **,void *,char const *,svn_boolean_t,apr_pool_t *)|svn_auth_ssl_client_cert_pw_prompt_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_svn_auth_cred_ssl_client_cert_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_svn_auth_cred_ssl_client_cert_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_auth_cred_ssl_client_cert_t **,void *,char const *,svn_boolean_t,apr_pool_t *)|svn_auth_ssl_client_cert_prompt_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_svn_auth_cred_ssl_server_trust_t_p_void_p_q_const__char_apr_uint32_t_p_q_const__svn_auth_ssl_server_cert_info_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_svn_auth_cred_ssl_server_trust_t_p_void_p_q_const__char_apr_uint32_t_p_q_const__svn_auth_ssl_server_cert_info_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_auth_cred_ssl_server_trust_t **,void *,char const *,apr_uint32_t,svn_auth_ssl_server_cert_info_t const *,svn_boolean_t,apr_pool_t *)|svn_auth_ssl_server_trust_prompt_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_svn_auth_cred_username_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_svn_auth_cred_username_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_auth_cred_username_t **,void *,char const *,svn_boolean_t,apr_pool_t *)|svn_auth_username_prompt_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_q_const__svn_client_diff_summarize_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_q_const__svn_client_diff_summarize_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_client_diff_summarize_t const *,void *,apr_pool_t *)|svn_client_diff_summarize_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void__p_svn_error_t = {"_p_f_p_void__p_svn_error_t", "struct svn_error_t *(*)(void *)|svn_cancel_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_apr_int64_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_apr_int64_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_int64_t,svn_revnum_t,char const *,char const *,char const *,apr_pool_t *)|svn_client_blame_receiver_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_hash_t *,svn_revnum_t,char const *,char const *,char const *,apr_pool_t *)|svn_log_message_receiver_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_enum_svn_wc_notify_action_t_enum_svn_node_kind_t_p_q_const__char_enum_svn_wc_notify_state_t_enum_svn_wc_notify_state_t_long__void = {"_p_f_p_void_p_q_const__char_enum_svn_wc_notify_action_t_enum_svn_node_kind_t_p_q_const__char_enum_svn_wc_notify_state_t_enum_svn_wc_notify_state_t_long__void", "void (*)(void *,char const *,enum svn_wc_notify_action_t,enum svn_node_kind_t,char const *,enum svn_wc_notify_state_t,enum svn_wc_notify_state_t,long)|svn_wc_notify_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__svn_dirent_t_p_q_const__svn_lock_t_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__svn_dirent_t_p_q_const__svn_lock_t_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_dirent_t const *,svn_lock_t const *,char const *,apr_pool_t *)|svn_client_list_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__svn_info_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__svn_info_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_info_t const *,apr_pool_t *)|svn_info_receiver_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_struct_svn_wc_status2_t__void = {"_p_f_p_void_p_q_const__char_p_struct_svn_wc_status2_t__void", "void (*)(void *,char const *,struct svn_wc_status2_t *)|svn_wc_status_func2_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_struct_svn_wc_status_t__void = {"_p_f_p_void_p_q_const__char_p_struct_svn_wc_status_t__void", "void (*)(void *,char const *,struct svn_wc_status_t *)|svn_wc_status_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__struct_svn_wc_notify_t_p_apr_pool_t__void = {"_p_f_p_void_p_q_const__struct_svn_wc_notify_t_p_apr_pool_t__void", "void (*)(void *,struct svn_wc_notify_t const *,apr_pool_t *)|svn_wc_notify_func2_t", 0, 0, 0};
static swig_type_info _swigt__p_int = {"_p_int", "int *|svn_boolean_t *", 0, 0, 0};
static swig_type_info _swigt__p_long = {"_p_long", "long *|svn_revnum_t *", 0, 0, 0};
static swig_type_info _swigt__p_p_apr_array_header_t = {"_p_p_apr_array_header_t", "apr_array_header_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_apr_hash_t = {"_p_p_apr_hash_t", "apr_hash_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_char = {"_p_p_char", "char **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_auth_provider_object_t = {"_p_p_svn_auth_provider_object_t", "struct svn_auth_provider_object_t **|svn_auth_provider_object_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_client_commit_info_t = {"_p_p_svn_client_commit_info_t", "struct svn_client_commit_info_t **|svn_client_commit_info_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_client_ctx_t = {"_p_p_svn_client_ctx_t", "struct svn_client_ctx_t **|svn_client_ctx_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_commit_info_t = {"_p_p_svn_commit_info_t", "struct svn_commit_info_t **|svn_commit_info_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_ra_session_t = {"_p_p_svn_ra_session_t", "struct svn_ra_session_t **|svn_ra_session_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_string_t = {"_p_p_svn_string_t", "struct svn_string_t **|svn_string_t **", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_baton_t = {"_p_svn_auth_baton_t", "struct svn_auth_baton_t *|svn_auth_baton_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_simple_t = {"_p_svn_auth_cred_simple_t", "struct svn_auth_cred_simple_t *|svn_auth_cred_simple_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_pw_t = {"_p_svn_auth_cred_ssl_client_cert_pw_t", "struct svn_auth_cred_ssl_client_cert_pw_t *|svn_auth_cred_ssl_client_cert_pw_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_t = {"_p_svn_auth_cred_ssl_client_cert_t", "struct svn_auth_cred_ssl_client_cert_t *|svn_auth_cred_ssl_client_cert_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_server_trust_t = {"_p_svn_auth_cred_ssl_server_trust_t", "struct svn_auth_cred_ssl_server_trust_t *|svn_auth_cred_ssl_server_trust_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_username_t = {"_p_svn_auth_cred_username_t", "struct svn_auth_cred_username_t *|svn_auth_cred_username_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_iterstate_t = {"_p_svn_auth_iterstate_t", "struct svn_auth_iterstate_t *|svn_auth_iterstate_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_object_t = {"_p_svn_auth_provider_object_t", "struct svn_auth_provider_object_t *|svn_auth_provider_object_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_t = {"_p_svn_auth_provider_t", "struct svn_auth_provider_t *|svn_auth_provider_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_ssl_server_cert_info_t = {"_p_svn_auth_ssl_server_cert_info_t", "struct svn_auth_ssl_server_cert_info_t *|svn_auth_ssl_server_cert_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_client_commit_info_t = {"_p_svn_client_commit_info_t", "struct svn_client_commit_info_t *|svn_client_commit_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_client_commit_item2_t = {"_p_svn_client_commit_item2_t", "struct svn_client_commit_item2_t *|svn_client_commit_item2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_client_commit_item_t = {"_p_svn_client_commit_item_t", "struct svn_client_commit_item_t *|svn_client_commit_item_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_client_ctx_t = {"_p_svn_client_ctx_t", "struct svn_client_ctx_t *|svn_client_ctx_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_client_diff_summarize_kind_t = {"_p_svn_client_diff_summarize_kind_t", "enum svn_client_diff_summarize_kind_t *|svn_client_diff_summarize_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_client_diff_summarize_t = {"_p_svn_client_diff_summarize_t", "struct svn_client_diff_summarize_t *|svn_client_diff_summarize_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_client_proplist_item_t = {"_p_svn_client_proplist_item_t", "struct svn_client_proplist_item_t *|svn_client_proplist_item_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_commit_info_t = {"_p_svn_commit_info_t", "struct svn_commit_info_t *|svn_commit_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_config_t = {"_p_svn_config_t", "struct svn_config_t *|svn_config_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_delta_editor_t = {"_p_svn_delta_editor_t", "struct svn_delta_editor_t *|svn_delta_editor_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_datasource_e = {"_p_svn_diff_datasource_e", "enum svn_diff_datasource_e *|svn_diff_datasource_e *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_file_ignore_space_t = {"_p_svn_diff_file_ignore_space_t", "enum svn_diff_file_ignore_space_t *|svn_diff_file_ignore_space_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_file_options_t = {"_p_svn_diff_file_options_t", "struct svn_diff_file_options_t *|svn_diff_file_options_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_fns_t = {"_p_svn_diff_fns_t", "struct svn_diff_fns_t *|svn_diff_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_output_fns_t = {"_p_svn_diff_output_fns_t", "struct svn_diff_output_fns_t *|svn_diff_output_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_t = {"_p_svn_diff_t", "struct svn_diff_t *|svn_diff_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_dirent_t = {"_p_svn_dirent_t", "struct svn_dirent_t *|svn_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_errno_t = {"_p_svn_errno_t", "enum svn_errno_t *|svn_errno_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_error_t = {"_p_svn_error_t", "struct svn_error_t *|svn_error_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_info_t = {"_p_svn_info_t", "struct svn_info_t *|svn_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_dirent_t = {"_p_svn_io_dirent_t", "struct svn_io_dirent_t *|svn_io_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_file_del_t = {"_p_svn_io_file_del_t", "enum svn_io_file_del_t *|svn_io_file_del_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_lock_t = {"_p_svn_lock_t", "struct svn_lock_t *|svn_lock_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_log_changed_path_t = {"_p_svn_log_changed_path_t", "struct svn_log_changed_path_t *|svn_log_changed_path_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_node_kind_t = {"_p_svn_node_kind_t", "enum svn_node_kind_t *|svn_node_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_t = {"_p_svn_opt_revision_t", "struct svn_opt_revision_t *|svn_opt_revision_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_value_t = {"_p_svn_opt_revision_value_t", "union svn_opt_revision_value_t *|svn_opt_revision_value_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc2_t = {"_p_svn_opt_subcommand_desc2_t", "struct svn_opt_subcommand_desc2_t *|svn_opt_subcommand_desc2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc_t = {"_p_svn_opt_subcommand_desc_t", "struct svn_opt_subcommand_desc_t *|svn_opt_subcommand_desc_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_prop_kind = {"_p_svn_prop_kind", "enum svn_prop_kind *|svn_prop_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_prop_t = {"_p_svn_prop_t", "struct svn_prop_t *|svn_prop_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_callbacks2_t = {"_p_svn_ra_callbacks2_t", "struct svn_ra_callbacks2_t *|svn_ra_callbacks2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_callbacks_t = {"_p_svn_ra_callbacks_t", "struct svn_ra_callbacks_t *|svn_ra_callbacks_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_plugin_t = {"_p_svn_ra_plugin_t", "struct svn_ra_plugin_t *|svn_ra_plugin_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_reporter2_t = {"_p_svn_ra_reporter2_t", "struct svn_ra_reporter2_t *|svn_ra_reporter2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_reporter_t = {"_p_svn_ra_reporter_t", "struct svn_ra_reporter_t *|svn_ra_reporter_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_session_t = {"_p_svn_ra_session_t", "struct svn_ra_session_t *|svn_ra_session_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stream_t = {"_p_svn_stream_t", "struct svn_stream_t *|svn_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_string_t = {"_p_svn_string_t", "struct svn_string_t *|svn_string_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stringbuf_t = {"_p_svn_stringbuf_t", "struct svn_stringbuf_t *|svn_stringbuf_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_op_t = {"_p_svn_txdelta_op_t", "struct svn_txdelta_op_t *|svn_txdelta_op_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_stream_t = {"_p_svn_txdelta_stream_t", "struct svn_txdelta_stream_t *|svn_txdelta_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_window_t = {"_p_svn_txdelta_window_t", "struct svn_txdelta_window_t *|svn_txdelta_window_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_checklist_t = {"_p_svn_version_checklist_t", "struct svn_version_checklist_t *|svn_version_checklist_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_t = {"_p_svn_version_t", "struct svn_version_t *|svn_version_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_adm_access_t = {"_p_svn_wc_adm_access_t", "struct svn_wc_adm_access_t *|svn_wc_adm_access_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_diff_callbacks2_t = {"_p_svn_wc_diff_callbacks2_t", "struct svn_wc_diff_callbacks2_t *|svn_wc_diff_callbacks2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_diff_callbacks_t = {"_p_svn_wc_diff_callbacks_t", "struct svn_wc_diff_callbacks_t *|svn_wc_diff_callbacks_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_entry_callbacks_t = {"_p_svn_wc_entry_callbacks_t", "struct svn_wc_entry_callbacks_t *|svn_wc_entry_callbacks_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_entry_t = {"_p_svn_wc_entry_t", "struct svn_wc_entry_t *|svn_wc_entry_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_external_item_t = {"_p_svn_wc_external_item_t", "struct svn_wc_external_item_t *|svn_wc_external_item_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_merge_outcome_t = {"_p_svn_wc_merge_outcome_t", "enum svn_wc_merge_outcome_t *|svn_wc_merge_outcome_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_notify_action_t = {"_p_svn_wc_notify_action_t", "enum svn_wc_notify_action_t *|svn_wc_notify_action_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_notify_lock_state_t = {"_p_svn_wc_notify_lock_state_t", "enum svn_wc_notify_lock_state_t *|svn_wc_notify_lock_state_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_notify_state_t = {"_p_svn_wc_notify_state_t", "enum svn_wc_notify_state_t *|svn_wc_notify_state_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_notify_t = {"_p_svn_wc_notify_t", "struct svn_wc_notify_t *|svn_wc_notify_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_revision_status_t = {"_p_svn_wc_revision_status_t", "struct svn_wc_revision_status_t *|svn_wc_revision_status_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_schedule_t = {"_p_svn_wc_schedule_t", "enum svn_wc_schedule_t *|svn_wc_schedule_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_status2_t = {"_p_svn_wc_status2_t", "struct svn_wc_status2_t *|svn_wc_status2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_status_t = {"_p_svn_wc_status_t", "struct svn_wc_status_t *|svn_wc_status_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_wc_traversal_info_t = {"_p_svn_wc_traversal_info_t", "struct svn_wc_traversal_info_t *|svn_wc_traversal_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_unsigned_long = {"_p_unsigned_long", "unsigned long *|VALUE *", 0, 0, 0};
static swig_type_info _swigt__p_void = {"_p_void", "void *", 0, 0, 0};

static swig_type_info *swig_type_initial[] = {
  &_swigt__p_apr_array_header_t,
  &_swigt__p_apr_file_t,
  &_swigt__p_apr_hash_t,
  &_swigt__p_apr_int32_t,
  &_swigt__p_apr_int64_t,
  &_swigt__p_apr_pool_t,
  &_swigt__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void,
  &_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_q_const__char_p_p_q_const__char_p_apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_q_const__char_p_p_q_const__char_p_q_const__apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_svn_auth_cred_simple_t_p_void_p_q_const__char_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_svn_auth_cred_ssl_client_cert_pw_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_svn_auth_cred_ssl_client_cert_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_svn_auth_cred_ssl_server_trust_t_p_void_p_q_const__char_apr_uint32_t_p_q_const__svn_auth_ssl_server_cert_info_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_svn_auth_cred_username_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_q_const__svn_client_diff_summarize_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void__p_svn_error_t,
  &_swigt__p_f_p_void_apr_int64_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_enum_svn_wc_notify_action_t_enum_svn_node_kind_t_p_q_const__char_enum_svn_wc_notify_state_t_enum_svn_wc_notify_state_t_long__void,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__svn_dirent_t_p_q_const__svn_lock_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__svn_info_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_struct_svn_wc_status2_t__void,
  &_swigt__p_f_p_void_p_q_const__char_p_struct_svn_wc_status_t__void,
  &_swigt__p_f_p_void_p_q_const__struct_svn_wc_notify_t_p_apr_pool_t__void,
  &_swigt__p_int,
  &_swigt__p_long,
  &_swigt__p_p_apr_array_header_t,
  &_swigt__p_p_apr_hash_t,
  &_swigt__p_p_char,
  &_swigt__p_p_svn_auth_provider_object_t,
  &_swigt__p_p_svn_client_commit_info_t,
  &_swigt__p_p_svn_client_ctx_t,
  &_swigt__p_p_svn_commit_info_t,
  &_swigt__p_p_svn_ra_session_t,
  &_swigt__p_p_svn_string_t,
  &_swigt__p_svn_auth_baton_t,
  &_swigt__p_svn_auth_cred_simple_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_pw_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_t,
  &_swigt__p_svn_auth_cred_ssl_server_trust_t,
  &_swigt__p_svn_auth_cred_username_t,
  &_swigt__p_svn_auth_iterstate_t,
  &_swigt__p_svn_auth_provider_object_t,
  &_swigt__p_svn_auth_provider_t,
  &_swigt__p_svn_auth_ssl_server_cert_info_t,
  &_swigt__p_svn_client_commit_info_t,
  &_swigt__p_svn_client_commit_item2_t,
  &_swigt__p_svn_client_commit_item_t,
  &_swigt__p_svn_client_ctx_t,
  &_swigt__p_svn_client_diff_summarize_kind_t,
  &_swigt__p_svn_client_diff_summarize_t,
  &_swigt__p_svn_client_proplist_item_t,
  &_swigt__p_svn_commit_info_t,
  &_swigt__p_svn_config_t,
  &_swigt__p_svn_delta_editor_t,
  &_swigt__p_svn_diff_datasource_e,
  &_swigt__p_svn_diff_file_ignore_space_t,
  &_swigt__p_svn_diff_file_options_t,
  &_swigt__p_svn_diff_fns_t,
  &_swigt__p_svn_diff_output_fns_t,
  &_swigt__p_svn_diff_t,
  &_swigt__p_svn_dirent_t,
  &_swigt__p_svn_errno_t,
  &_swigt__p_svn_error_t,
  &_swigt__p_svn_info_t,
  &_swigt__p_svn_io_dirent_t,
  &_swigt__p_svn_io_file_del_t,
  &_swigt__p_svn_lock_t,
  &_swigt__p_svn_log_changed_path_t,
  &_swigt__p_svn_node_kind_t,
  &_swigt__p_svn_opt_revision_t,
  &_swigt__p_svn_opt_revision_value_t,
  &_swigt__p_svn_opt_subcommand_desc2_t,
  &_swigt__p_svn_opt_subcommand_desc_t,
  &_swigt__p_svn_prop_kind,
  &_swigt__p_svn_prop_t,
  &_swigt__p_svn_ra_callbacks2_t,
  &_swigt__p_svn_ra_callbacks_t,
  &_swigt__p_svn_ra_plugin_t,
  &_swigt__p_svn_ra_reporter2_t,
  &_swigt__p_svn_ra_reporter_t,
  &_swigt__p_svn_ra_session_t,
  &_swigt__p_svn_stream_t,
  &_swigt__p_svn_string_t,
  &_swigt__p_svn_stringbuf_t,
  &_swigt__p_svn_txdelta_op_t,
  &_swigt__p_svn_txdelta_stream_t,
  &_swigt__p_svn_txdelta_window_t,
  &_swigt__p_svn_version_checklist_t,
  &_swigt__p_svn_version_t,
  &_swigt__p_svn_wc_adm_access_t,
  &_swigt__p_svn_wc_diff_callbacks2_t,
  &_swigt__p_svn_wc_diff_callbacks_t,
  &_swigt__p_svn_wc_entry_callbacks_t,
  &_swigt__p_svn_wc_entry_t,
  &_swigt__p_svn_wc_external_item_t,
  &_swigt__p_svn_wc_merge_outcome_t,
  &_swigt__p_svn_wc_notify_action_t,
  &_swigt__p_svn_wc_notify_lock_state_t,
  &_swigt__p_svn_wc_notify_state_t,
  &_swigt__p_svn_wc_notify_t,
  &_swigt__p_svn_wc_revision_status_t,
  &_swigt__p_svn_wc_schedule_t,
  &_swigt__p_svn_wc_status2_t,
  &_swigt__p_svn_wc_status_t,
  &_swigt__p_svn_wc_traversal_info_t,
  &_swigt__p_unsigned_long,
  &_swigt__p_void,
};

static swig_cast_info _swigc__p_apr_array_header_t[] = {  {&_swigt__p_apr_array_header_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_file_t[] = {  {&_swigt__p_apr_file_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_hash_t[] = {  {&_swigt__p_apr_hash_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int32_t[] = {  {&_swigt__p_apr_int32_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int64_t[] = {  {&_swigt__p_apr_int64_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_pool_t[] = {  {&_swigt__p_apr_pool_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void[] = {  {&_swigt__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_q_const__char_p_p_q_const__char_p_apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_q_const__char_p_p_q_const__char_p_apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_q_const__char_p_p_q_const__char_p_q_const__apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_q_const__char_p_p_q_const__char_p_q_const__apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_svn_auth_cred_simple_t_p_void_p_q_const__char_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_svn_auth_cred_simple_t_p_void_p_q_const__char_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_svn_auth_cred_ssl_client_cert_pw_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_svn_auth_cred_ssl_client_cert_pw_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_svn_auth_cred_ssl_client_cert_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_svn_auth_cred_ssl_client_cert_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_svn_auth_cred_ssl_server_trust_t_p_void_p_q_const__char_apr_uint32_t_p_q_const__svn_auth_ssl_server_cert_info_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_svn_auth_cred_ssl_server_trust_t_p_void_p_q_const__char_apr_uint32_t_p_q_const__svn_auth_ssl_server_cert_info_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_svn_auth_cred_username_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_svn_auth_cred_username_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_q_const__svn_client_diff_summarize_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_q_const__svn_client_diff_summarize_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_apr_int64_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_apr_int64_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_enum_svn_wc_notify_action_t_enum_svn_node_kind_t_p_q_const__char_enum_svn_wc_notify_state_t_enum_svn_wc_notify_state_t_long__void[] = {  {&_swigt__p_f_p_void_p_q_const__char_enum_svn_wc_notify_action_t_enum_svn_node_kind_t_p_q_const__char_enum_svn_wc_notify_state_t_enum_svn_wc_notify_state_t_long__void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__svn_dirent_t_p_q_const__svn_lock_t_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__svn_dirent_t_p_q_const__svn_lock_t_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__svn_info_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__svn_info_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_struct_svn_wc_status2_t__void[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_struct_svn_wc_status2_t__void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_struct_svn_wc_status_t__void[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_struct_svn_wc_status_t__void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__struct_svn_wc_notify_t_p_apr_pool_t__void[] = {  {&_swigt__p_f_p_void_p_q_const__struct_svn_wc_notify_t_p_apr_pool_t__void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_int[] = {  {&_swigt__p_int, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_long[] = {  {&_swigt__p_long, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_apr_array_header_t[] = {  {&_swigt__p_p_apr_array_header_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_apr_hash_t[] = {  {&_swigt__p_p_apr_hash_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_char[] = {  {&_swigt__p_p_char, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_auth_provider_object_t[] = {  {&_swigt__p_p_svn_auth_provider_object_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_client_commit_info_t[] = {  {&_swigt__p_p_svn_client_commit_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_client_ctx_t[] = {  {&_swigt__p_p_svn_client_ctx_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_commit_info_t[] = {  {&_swigt__p_p_svn_commit_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_ra_session_t[] = {  {&_swigt__p_p_svn_ra_session_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_string_t[] = {  {&_swigt__p_p_svn_string_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_baton_t[] = {  {&_swigt__p_svn_auth_baton_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_simple_t[] = {  {&_swigt__p_svn_auth_cred_simple_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_pw_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_pw_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_server_trust_t[] = {  {&_swigt__p_svn_auth_cred_ssl_server_trust_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_username_t[] = {  {&_swigt__p_svn_auth_cred_username_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_iterstate_t[] = {  {&_swigt__p_svn_auth_iterstate_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_object_t[] = {  {&_swigt__p_svn_auth_provider_object_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_t[] = {  {&_swigt__p_svn_auth_provider_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_ssl_server_cert_info_t[] = {  {&_swigt__p_svn_auth_ssl_server_cert_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_client_commit_info_t[] = {  {&_swigt__p_svn_client_commit_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_client_commit_item2_t[] = {  {&_swigt__p_svn_client_commit_item2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_client_commit_item_t[] = {  {&_swigt__p_svn_client_commit_item_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_client_ctx_t[] = {  {&_swigt__p_svn_client_ctx_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_client_diff_summarize_kind_t[] = {  {&_swigt__p_svn_client_diff_summarize_kind_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_client_diff_summarize_t[] = {  {&_swigt__p_svn_client_diff_summarize_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_client_proplist_item_t[] = {  {&_swigt__p_svn_client_proplist_item_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_commit_info_t[] = {  {&_swigt__p_svn_commit_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_config_t[] = {  {&_swigt__p_svn_config_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_delta_editor_t[] = {  {&_swigt__p_svn_delta_editor_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_datasource_e[] = {  {&_swigt__p_svn_diff_datasource_e, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_file_ignore_space_t[] = {  {&_swigt__p_svn_diff_file_ignore_space_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_file_options_t[] = {  {&_swigt__p_svn_diff_file_options_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_fns_t[] = {  {&_swigt__p_svn_diff_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_output_fns_t[] = {  {&_swigt__p_svn_diff_output_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_t[] = {  {&_swigt__p_svn_diff_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_dirent_t[] = {  {&_swigt__p_svn_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_errno_t[] = {  {&_swigt__p_svn_errno_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_error_t[] = {  {&_swigt__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_info_t[] = {  {&_swigt__p_svn_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_dirent_t[] = {  {&_swigt__p_svn_io_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_file_del_t[] = {  {&_swigt__p_svn_io_file_del_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_lock_t[] = {  {&_swigt__p_svn_lock_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_log_changed_path_t[] = {  {&_swigt__p_svn_log_changed_path_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_node_kind_t[] = {  {&_swigt__p_svn_node_kind_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_t[] = {  {&_swigt__p_svn_opt_revision_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_value_t[] = {  {&_swigt__p_svn_opt_revision_value_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc2_t[] = {  {&_swigt__p_svn_opt_subcommand_desc2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc_t[] = {  {&_swigt__p_svn_opt_subcommand_desc_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_prop_kind[] = {  {&_swigt__p_svn_prop_kind, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_prop_t[] = {  {&_swigt__p_svn_prop_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_callbacks2_t[] = {  {&_swigt__p_svn_ra_callbacks2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_callbacks_t[] = {  {&_swigt__p_svn_ra_callbacks_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_plugin_t[] = {  {&_swigt__p_svn_ra_plugin_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_reporter2_t[] = {  {&_swigt__p_svn_ra_reporter2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_reporter_t[] = {  {&_swigt__p_svn_ra_reporter_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_session_t[] = {  {&_swigt__p_svn_ra_session_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stream_t[] = {  {&_swigt__p_svn_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_string_t[] = {  {&_swigt__p_svn_string_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stringbuf_t[] = {  {&_swigt__p_svn_stringbuf_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_op_t[] = {  {&_swigt__p_svn_txdelta_op_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_stream_t[] = {  {&_swigt__p_svn_txdelta_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_window_t[] = {  {&_swigt__p_svn_txdelta_window_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_checklist_t[] = {  {&_swigt__p_svn_version_checklist_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_t[] = {  {&_swigt__p_svn_version_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_adm_access_t[] = {  {&_swigt__p_svn_wc_adm_access_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_diff_callbacks2_t[] = {  {&_swigt__p_svn_wc_diff_callbacks2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_diff_callbacks_t[] = {  {&_swigt__p_svn_wc_diff_callbacks_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_entry_callbacks_t[] = {  {&_swigt__p_svn_wc_entry_callbacks_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_entry_t[] = {  {&_swigt__p_svn_wc_entry_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_external_item_t[] = {  {&_swigt__p_svn_wc_external_item_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_merge_outcome_t[] = {  {&_swigt__p_svn_wc_merge_outcome_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_notify_action_t[] = {  {&_swigt__p_svn_wc_notify_action_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_notify_lock_state_t[] = {  {&_swigt__p_svn_wc_notify_lock_state_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_notify_state_t[] = {  {&_swigt__p_svn_wc_notify_state_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_notify_t[] = {  {&_swigt__p_svn_wc_notify_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_revision_status_t[] = {  {&_swigt__p_svn_wc_revision_status_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_schedule_t[] = {  {&_swigt__p_svn_wc_schedule_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_status2_t[] = {  {&_swigt__p_svn_wc_status2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_status_t[] = {  {&_swigt__p_svn_wc_status_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_wc_traversal_info_t[] = {  {&_swigt__p_svn_wc_traversal_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_unsigned_long[] = {  {&_swigt__p_unsigned_long, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_void[] = {  {&_swigt__p_void, 0, 0, 0},{0, 0, 0, 0}};

static swig_cast_info *swig_cast_initial[] = {
  _swigc__p_apr_array_header_t,
  _swigc__p_apr_file_t,
  _swigc__p_apr_hash_t,
  _swigc__p_apr_int32_t,
  _swigc__p_apr_int64_t,
  _swigc__p_apr_pool_t,
  _swigc__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void,
  _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_q_const__char_p_p_q_const__char_p_apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_q_const__char_p_p_q_const__char_p_q_const__apr_array_header_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_svn_auth_cred_simple_t_p_void_p_q_const__char_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_svn_auth_cred_ssl_client_cert_pw_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_svn_auth_cred_ssl_client_cert_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_svn_auth_cred_ssl_server_trust_t_p_void_p_q_const__char_apr_uint32_t_p_q_const__svn_auth_ssl_server_cert_info_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_svn_auth_cred_username_t_p_void_p_q_const__char_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_q_const__svn_client_diff_summarize_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void__p_svn_error_t,
  _swigc__p_f_p_void_apr_int64_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_enum_svn_wc_notify_action_t_enum_svn_node_kind_t_p_q_const__char_enum_svn_wc_notify_state_t_enum_svn_wc_notify_state_t_long__void,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__svn_dirent_t_p_q_const__svn_lock_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__svn_info_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_struct_svn_wc_status2_t__void,
  _swigc__p_f_p_void_p_q_const__char_p_struct_svn_wc_status_t__void,
  _swigc__p_f_p_void_p_q_const__struct_svn_wc_notify_t_p_apr_pool_t__void,
  _swigc__p_int,
  _swigc__p_long,
  _swigc__p_p_apr_array_header_t,
  _swigc__p_p_apr_hash_t,
  _swigc__p_p_char,
  _swigc__p_p_svn_auth_provider_object_t,
  _swigc__p_p_svn_client_commit_info_t,
  _swigc__p_p_svn_client_ctx_t,
  _swigc__p_p_svn_commit_info_t,
  _swigc__p_p_svn_ra_session_t,
  _swigc__p_p_svn_string_t,
  _swigc__p_svn_auth_baton_t,
  _swigc__p_svn_auth_cred_simple_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_pw_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_t,
  _swigc__p_svn_auth_cred_ssl_server_trust_t,
  _swigc__p_svn_auth_cred_username_t,
  _swigc__p_svn_auth_iterstate_t,
  _swigc__p_svn_auth_provider_object_t,
  _swigc__p_svn_auth_provider_t,
  _swigc__p_svn_auth_ssl_server_cert_info_t,
  _swigc__p_svn_client_commit_info_t,
  _swigc__p_svn_client_commit_item2_t,
  _swigc__p_svn_client_commit_item_t,
  _swigc__p_svn_client_ctx_t,
  _swigc__p_svn_client_diff_summarize_kind_t,
  _swigc__p_svn_client_diff_summarize_t,
  _swigc__p_svn_client_proplist_item_t,
  _swigc__p_svn_commit_info_t,
  _swigc__p_svn_config_t,
  _swigc__p_svn_delta_editor_t,
  _swigc__p_svn_diff_datasource_e,
  _swigc__p_svn_diff_file_ignore_space_t,
  _swigc__p_svn_diff_file_options_t,
  _swigc__p_svn_diff_fns_t,
  _swigc__p_svn_diff_output_fns_t,
  _swigc__p_svn_diff_t,
  _swigc__p_svn_dirent_t,
  _swigc__p_svn_errno_t,
  _swigc__p_svn_error_t,
  _swigc__p_svn_info_t,
  _swigc__p_svn_io_dirent_t,
  _swigc__p_svn_io_file_del_t,
  _swigc__p_svn_lock_t,
  _swigc__p_svn_log_changed_path_t,
  _swigc__p_svn_node_kind_t,
  _swigc__p_svn_opt_revision_t,
  _swigc__p_svn_opt_revision_value_t,
  _swigc__p_svn_opt_subcommand_desc2_t,
  _swigc__p_svn_opt_subcommand_desc_t,
  _swigc__p_svn_prop_kind,
  _swigc__p_svn_prop_t,
  _swigc__p_svn_ra_callbacks2_t,
  _swigc__p_svn_ra_callbacks_t,
  _swigc__p_svn_ra_plugin_t,
  _swigc__p_svn_ra_reporter2_t,
  _swigc__p_svn_ra_reporter_t,
  _swigc__p_svn_ra_session_t,
  _swigc__p_svn_stream_t,
  _swigc__p_svn_string_t,
  _swigc__p_svn_stringbuf_t,
  _swigc__p_svn_txdelta_op_t,
  _swigc__p_svn_txdelta_stream_t,
  _swigc__p_svn_txdelta_window_t,
  _swigc__p_svn_version_checklist_t,
  _swigc__p_svn_version_t,
  _swigc__p_svn_wc_adm_access_t,
  _swigc__p_svn_wc_diff_callbacks2_t,
  _swigc__p_svn_wc_diff_callbacks_t,
  _swigc__p_svn_wc_entry_callbacks_t,
  _swigc__p_svn_wc_entry_t,
  _swigc__p_svn_wc_external_item_t,
  _swigc__p_svn_wc_merge_outcome_t,
  _swigc__p_svn_wc_notify_action_t,
  _swigc__p_svn_wc_notify_lock_state_t,
  _swigc__p_svn_wc_notify_state_t,
  _swigc__p_svn_wc_notify_t,
  _swigc__p_svn_wc_revision_status_t,
  _swigc__p_svn_wc_schedule_t,
  _swigc__p_svn_wc_status2_t,
  _swigc__p_svn_wc_status_t,
  _swigc__p_svn_wc_traversal_info_t,
  _swigc__p_unsigned_long,
  _swigc__p_void,
};


/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (END) -------- */

/*************************************************************************
 * Type initialization:
 * This problem is tough by the requirement that no dynamic 
 * memory is used. Also, since swig_type_info structures store pointers to 
 * swig_cast_info structures and swig_cast_info structures store pointers back
 * to swig_type_info structures, we need some lookup code at initialization. 
 * The idea is that swig generates all the structures that are needed. 
 * The runtime then collects these partially filled structures. 
 * The SWIG_InitializeModule function takes these initial arrays out of 
 * swig_module, and does all the lookup, filling in the swig_module.types
 * array with the correct data and linking the correct swig_cast_info
 * structures together.

 * The generated swig_type_info structures are assigned staticly to an initial 
 * array. We just loop though that array, and handle each type individually.
 * First we lookup if this type has been already loaded, and if so, use the
 * loaded structure instead of the generated one. Then we have to fill in the
 * cast linked list. The cast data is initially stored in something like a
 * two-dimensional array. Each row corresponds to a type (there are the same
 * number of rows as there are in the swig_type_initial array). Each entry in
 * a column is one of the swig_cast_info structures for that type.
 * The cast_initial array is actually an array of arrays, because each row has
 * a variable number of columns. So to actually build the cast linked list,
 * we find the array of casts associated with the type, and loop through it 
 * adding the casts to the list. The one last trick we need to do is making
 * sure the type pointer in the swig_cast_info struct is correct.

 * First off, we lookup the cast->type name to see if it is already loaded. 
 * There are three cases to handle:
 *  1) If the cast->type has already been loaded AND the type we are adding
 *     casting info to has not been loaded (it is in this module), THEN we
 *     replace the cast->type pointer with the type pointer that has already
 *     been loaded.
 *  2) If BOTH types (the one we are adding casting info to, and the 
 *     cast->type) are loaded, THEN the cast info has already been loaded by
 *     the previous module so we just ignore it.
 *  3) Finally, if cast->type has not already been loaded, then we add that
 *     swig_cast_info to the linked list (because the cast->type) pointer will
 *     be correct.
**/

#ifdef __cplusplus
extern "C" {
#endif

SWIGRUNTIME void
SWIG_InitializeModule(void *clientdata) {
  swig_type_info *type, *ret;
  swig_cast_info *cast;
  size_t i;
  swig_module_info *module_head;
  static int init_run = 0;

  clientdata = clientdata;

  if (init_run) return;
  init_run = 1;

  /* Initialize the swig_module */
  swig_module.type_initial = swig_type_initial;
  swig_module.cast_initial = swig_cast_initial;

  /* Try and load any already created modules */
  module_head = SWIG_GetModule(clientdata);
  if (module_head) {
    swig_module.next = module_head->next;
    module_head->next = &swig_module;
  } else {
    /* This is the first module loaded */
    swig_module.next = &swig_module;
    SWIG_SetModule(clientdata, &swig_module);
  }
		 
  /* Now work on filling in swig_module.types */
  for (i = 0; i < swig_module.size; ++i) {
    type = 0;

    /* if there is another module already loaded */
    if (swig_module.next != &swig_module) {
      type = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, swig_module.type_initial[i]->name);
    }
    if (type) {
      /* Overwrite clientdata field */
      if (swig_module.type_initial[i]->clientdata) type->clientdata = swig_module.type_initial[i]->clientdata;
    } else {
      type = swig_module.type_initial[i];
    }

    /* Insert casting types */
    cast = swig_module.cast_initial[i];
    while (cast->type) {
    
      /* Don't need to add information already in the list */
      ret = 0;
      if (swig_module.next != &swig_module) {
        ret = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, cast->type->name);
      }
      if (ret && type == swig_module.type_initial[i]) {
        cast->type = ret;
        ret = 0;
      }
      
      if (!ret) {
        if (type->cast) {
          type->cast->prev = cast;
          cast->next = type->cast;
        }
        type->cast = cast;
      }

      cast++;
    }

    /* Set entry in modules->types array equal to the type */
    swig_module.types[i] = type;
  }
}

/* This function will propagate the clientdata field of type to
* any new swig_type_info structures that have been added into the list
* of equivalent types.  It is like calling
* SWIG_TypeClientData(type, clientdata) a second time.
*/
SWIGRUNTIME void
SWIG_PropagateClientData(void) {
  size_t i;
  swig_cast_info *equiv;
  static int init_run = 0;

  if (init_run) return;
  init_run = 1;

  for (i = 0; i < swig_module.size; i++) {
    if (swig_module.types[i]->clientdata) {
      equiv = swig_module.types[i]->cast;
      while (equiv) {
        if (!equiv->converter) {
          if (equiv->type && !equiv->type->clientdata)
            SWIG_TypeClientData(equiv->type, swig_module.types[i]->clientdata);
        }
        equiv = equiv->next;
      }
    }
  }
}

#ifdef __cplusplus
}
#endif


#ifdef __cplusplus
extern "C"
#endif
SWIGEXPORT void Init_client(void) {
    int i;
    
    SWIG_InitRuntime();
    mClient = rb_define_module("Svn");
    mClient = rb_define_module_under(mClient, "Ext");
    mClient = rb_define_module_under(mClient, "Client");
    
    SWIG_InitializeModule(0);
    for (i = 0; i < swig_module.size; i++) {
        SWIG_define_class(swig_module.types[i]);
    }
    
    rb_require("svn/ext/core");
    rb_require("svn/ext/delta");
    rb_require("svn/ext/wc");
    rb_require("svn/ext/ra");
    rb_define_module_function(mClient, "svn_client_version", _wrap_svn_client_version, -1);
    rb_define_module_function(mClient, "svn_client_get_simple_prompt_provider", _wrap_svn_client_get_simple_prompt_provider, -1);
    rb_define_module_function(mClient, "svn_client_get_username_prompt_provider", _wrap_svn_client_get_username_prompt_provider, -1);
    rb_define_module_function(mClient, "svn_client_get_simple_provider", _wrap_svn_client_get_simple_provider, -1);
    rb_define_module_function(mClient, "svn_client_get_username_provider", _wrap_svn_client_get_username_provider, -1);
    rb_define_module_function(mClient, "svn_client_get_ssl_server_trust_file_provider", _wrap_svn_client_get_ssl_server_trust_file_provider, -1);
    rb_define_module_function(mClient, "svn_client_get_ssl_client_cert_file_provider", _wrap_svn_client_get_ssl_client_cert_file_provider, -1);
    rb_define_module_function(mClient, "svn_client_get_ssl_client_cert_pw_file_provider", _wrap_svn_client_get_ssl_client_cert_pw_file_provider, -1);
    rb_define_module_function(mClient, "svn_client_get_ssl_server_trust_prompt_provider", _wrap_svn_client_get_ssl_server_trust_prompt_provider, -1);
    rb_define_module_function(mClient, "svn_client_get_ssl_client_cert_prompt_provider", _wrap_svn_client_get_ssl_client_cert_prompt_provider, -1);
    rb_define_module_function(mClient, "svn_client_get_ssl_client_cert_pw_prompt_provider", _wrap_svn_client_get_ssl_client_cert_pw_prompt_provider, -1);
    
    cSvn_client_proplist_item_t.klass = rb_define_class_under(mClient, "Svn_client_proplist_item_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_client_proplist_item_t, (void *) &cSvn_client_proplist_item_t);
    rb_define_alloc_func(cSvn_client_proplist_item_t.klass, _wrap_svn_client_proplist_item_t_allocate);
    rb_define_method(cSvn_client_proplist_item_t.klass, "initialize", _wrap_new_svn_client_proplist_item_t, -1);
    rb_define_method(cSvn_client_proplist_item_t.klass, "node_name=", _wrap_svn_client_proplist_item_t_node_name_set, -1);
    rb_define_method(cSvn_client_proplist_item_t.klass, "node_name", _wrap_svn_client_proplist_item_t_node_name_get, -1);
    rb_define_method(cSvn_client_proplist_item_t.klass, "prop_hash=", _wrap_svn_client_proplist_item_t_prop_hash_set, -1);
    rb_define_method(cSvn_client_proplist_item_t.klass, "prop_hash", _wrap_svn_client_proplist_item_t_prop_hash_get, -1);
    cSvn_client_proplist_item_t.mark = 0;
    cSvn_client_proplist_item_t.destroy = (void (*)(void *)) free_svn_client_proplist_item_t;
    rb_define_module_function(mClient, "svn_client_proplist_item_dup", _wrap_svn_client_proplist_item_dup, -1);
    
    cSvn_client_commit_info_t.klass = rb_define_class_under(mClient, "Svn_client_commit_info_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_client_commit_info_t, (void *) &cSvn_client_commit_info_t);
    rb_define_alloc_func(cSvn_client_commit_info_t.klass, _wrap_svn_client_commit_info_t_allocate);
    rb_define_method(cSvn_client_commit_info_t.klass, "initialize", _wrap_new_svn_client_commit_info_t, -1);
    rb_define_method(cSvn_client_commit_info_t.klass, "revision=", _wrap_svn_client_commit_info_t_revision_set, -1);
    rb_define_method(cSvn_client_commit_info_t.klass, "revision", _wrap_svn_client_commit_info_t_revision_get, -1);
    rb_define_method(cSvn_client_commit_info_t.klass, "date=", _wrap_svn_client_commit_info_t_date_set, -1);
    rb_define_method(cSvn_client_commit_info_t.klass, "date", _wrap_svn_client_commit_info_t_date_get, -1);
    rb_define_method(cSvn_client_commit_info_t.klass, "author=", _wrap_svn_client_commit_info_t_author_set, -1);
    rb_define_method(cSvn_client_commit_info_t.klass, "author", _wrap_svn_client_commit_info_t_author_get, -1);
    cSvn_client_commit_info_t.mark = 0;
    cSvn_client_commit_info_t.destroy = (void (*)(void *)) free_svn_client_commit_info_t;
    rb_define_const(mClient,"SVN_CLIENT_COMMIT_ITEM_ADD", INT2NUM(0x01));
    rb_define_const(mClient,"SVN_CLIENT_COMMIT_ITEM_DELETE", INT2NUM(0x02));
    rb_define_const(mClient,"SVN_CLIENT_COMMIT_ITEM_TEXT_MODS", INT2NUM(0x04));
    rb_define_const(mClient,"SVN_CLIENT_COMMIT_ITEM_PROP_MODS", INT2NUM(0x08));
    rb_define_const(mClient,"SVN_CLIENT_COMMIT_ITEM_IS_COPY", INT2NUM(0x10));
    rb_define_const(mClient,"SVN_CLIENT_COMMIT_ITEM_LOCK_TOKEN", INT2NUM(0x20));
    
    cSvn_client_commit_item2_t.klass = rb_define_class_under(mClient, "Svn_client_commit_item2_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_client_commit_item2_t, (void *) &cSvn_client_commit_item2_t);
    rb_define_alloc_func(cSvn_client_commit_item2_t.klass, _wrap_svn_client_commit_item2_t_allocate);
    rb_define_method(cSvn_client_commit_item2_t.klass, "initialize", _wrap_new_svn_client_commit_item2_t, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "path=", _wrap_svn_client_commit_item2_t_path_set, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "path", _wrap_svn_client_commit_item2_t_path_get, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "kind=", _wrap_svn_client_commit_item2_t_kind_set, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "kind", _wrap_svn_client_commit_item2_t_kind_get, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "url=", _wrap_svn_client_commit_item2_t_url_set, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "url", _wrap_svn_client_commit_item2_t_url_get, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "revision=", _wrap_svn_client_commit_item2_t_revision_set, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "revision", _wrap_svn_client_commit_item2_t_revision_get, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "copyfrom_url=", _wrap_svn_client_commit_item2_t_copyfrom_url_set, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "copyfrom_url", _wrap_svn_client_commit_item2_t_copyfrom_url_get, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "copyfrom_rev=", _wrap_svn_client_commit_item2_t_copyfrom_rev_set, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "copyfrom_rev", _wrap_svn_client_commit_item2_t_copyfrom_rev_get, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "state_flags=", _wrap_svn_client_commit_item2_t_state_flags_set, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "state_flags", _wrap_svn_client_commit_item2_t_state_flags_get, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "wcprop_changes=", _wrap_svn_client_commit_item2_t_wcprop_changes_set, -1);
    rb_define_method(cSvn_client_commit_item2_t.klass, "wcprop_changes", _wrap_svn_client_commit_item2_t_wcprop_changes_get, -1);
    cSvn_client_commit_item2_t.mark = 0;
    cSvn_client_commit_item2_t.destroy = (void (*)(void *)) free_svn_client_commit_item2_t;
    rb_define_module_function(mClient, "svn_client_commit_item2_dup", _wrap_svn_client_commit_item2_dup, -1);
    
    cSvn_client_commit_item_t.klass = rb_define_class_under(mClient, "Svn_client_commit_item_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_client_commit_item_t, (void *) &cSvn_client_commit_item_t);
    rb_define_alloc_func(cSvn_client_commit_item_t.klass, _wrap_svn_client_commit_item_t_allocate);
    rb_define_method(cSvn_client_commit_item_t.klass, "initialize", _wrap_new_svn_client_commit_item_t, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "path=", _wrap_svn_client_commit_item_t_path_set, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "path", _wrap_svn_client_commit_item_t_path_get, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "kind=", _wrap_svn_client_commit_item_t_kind_set, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "kind", _wrap_svn_client_commit_item_t_kind_get, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "url=", _wrap_svn_client_commit_item_t_url_set, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "url", _wrap_svn_client_commit_item_t_url_get, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "revision=", _wrap_svn_client_commit_item_t_revision_set, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "revision", _wrap_svn_client_commit_item_t_revision_get, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "copyfrom_url=", _wrap_svn_client_commit_item_t_copyfrom_url_set, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "copyfrom_url", _wrap_svn_client_commit_item_t_copyfrom_url_get, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "state_flags=", _wrap_svn_client_commit_item_t_state_flags_set, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "state_flags", _wrap_svn_client_commit_item_t_state_flags_get, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "wcprop_changes=", _wrap_svn_client_commit_item_t_wcprop_changes_set, -1);
    rb_define_method(cSvn_client_commit_item_t.klass, "wcprop_changes", _wrap_svn_client_commit_item_t_wcprop_changes_get, -1);
    cSvn_client_commit_item_t.mark = 0;
    cSvn_client_commit_item_t.destroy = (void (*)(void *)) free_svn_client_commit_item_t;
    rb_define_const(mClient,"Svn_client_diff_summarize_kind_normal", INT2NUM(svn_client_diff_summarize_kind_normal));
    rb_define_const(mClient,"Svn_client_diff_summarize_kind_added", INT2NUM(svn_client_diff_summarize_kind_added));
    rb_define_const(mClient,"Svn_client_diff_summarize_kind_modified", INT2NUM(svn_client_diff_summarize_kind_modified));
    rb_define_const(mClient,"Svn_client_diff_summarize_kind_deleted", INT2NUM(svn_client_diff_summarize_kind_deleted));
    
    cSvn_client_diff_summarize_t.klass = rb_define_class_under(mClient, "Svn_client_diff_summarize_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_client_diff_summarize_t, (void *) &cSvn_client_diff_summarize_t);
    rb_define_alloc_func(cSvn_client_diff_summarize_t.klass, _wrap_svn_client_diff_summarize_t_allocate);
    rb_define_method(cSvn_client_diff_summarize_t.klass, "initialize", _wrap_new_svn_client_diff_summarize_t, -1);
    rb_define_method(cSvn_client_diff_summarize_t.klass, "path=", _wrap_svn_client_diff_summarize_t_path_set, -1);
    rb_define_method(cSvn_client_diff_summarize_t.klass, "path", _wrap_svn_client_diff_summarize_t_path_get, -1);
    rb_define_method(cSvn_client_diff_summarize_t.klass, "summarize_kind=", _wrap_svn_client_diff_summarize_t_summarize_kind_set, -1);
    rb_define_method(cSvn_client_diff_summarize_t.klass, "summarize_kind", _wrap_svn_client_diff_summarize_t_summarize_kind_get, -1);
    rb_define_method(cSvn_client_diff_summarize_t.klass, "prop_changed=", _wrap_svn_client_diff_summarize_t_prop_changed_set, -1);
    rb_define_method(cSvn_client_diff_summarize_t.klass, "prop_changed", _wrap_svn_client_diff_summarize_t_prop_changed_get, -1);
    rb_define_method(cSvn_client_diff_summarize_t.klass, "node_kind=", _wrap_svn_client_diff_summarize_t_node_kind_set, -1);
    rb_define_method(cSvn_client_diff_summarize_t.klass, "node_kind", _wrap_svn_client_diff_summarize_t_node_kind_get, -1);
    cSvn_client_diff_summarize_t.mark = 0;
    cSvn_client_diff_summarize_t.destroy = (void (*)(void *)) free_svn_client_diff_summarize_t;
    rb_define_module_function(mClient, "svn_client_diff_summarize_dup", _wrap_svn_client_diff_summarize_dup, -1);
    
    cSvn_client_ctx_t.klass = rb_define_class_under(mClient, "Svn_client_ctx_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_client_ctx_t, (void *) &cSvn_client_ctx_t);
    rb_define_alloc_func(cSvn_client_ctx_t.klass, _wrap_svn_client_ctx_t_allocate);
    rb_define_method(cSvn_client_ctx_t.klass, "initialize", _wrap_new_svn_client_ctx_t, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "auth_baton=", _wrap_svn_client_ctx_t_auth_baton_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "auth_baton", _wrap_svn_client_ctx_t_auth_baton_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "notify_func=", _wrap_svn_client_ctx_t_notify_func_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "notify_func", _wrap_svn_client_ctx_t_notify_func_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "notify_baton=", _wrap_svn_client_ctx_t_notify_baton_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "notify_baton", _wrap_svn_client_ctx_t_notify_baton_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "log_msg_func=", _wrap_svn_client_ctx_t_log_msg_func_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "log_msg_func", _wrap_svn_client_ctx_t_log_msg_func_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "log_msg_baton=", _wrap_svn_client_ctx_t_log_msg_baton_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "log_msg_baton", _wrap_svn_client_ctx_t_log_msg_baton_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "config=", _wrap_svn_client_ctx_t_config_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "config", _wrap_svn_client_ctx_t_config_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "cancel_func=", _wrap_svn_client_ctx_t_cancel_func_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "cancel_func", _wrap_svn_client_ctx_t_cancel_func_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "cancel_baton=", _wrap_svn_client_ctx_t_cancel_baton_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "cancel_baton", _wrap_svn_client_ctx_t_cancel_baton_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "notify_func2=", _wrap_svn_client_ctx_t_notify_func2_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "notify_func2", _wrap_svn_client_ctx_t_notify_func2_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "notify_baton2=", _wrap_svn_client_ctx_t_notify_baton2_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "notify_baton2", _wrap_svn_client_ctx_t_notify_baton2_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "log_msg_func2=", _wrap_svn_client_ctx_t_log_msg_func2_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "log_msg_func2", _wrap_svn_client_ctx_t_log_msg_func2_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "log_msg_baton2=", _wrap_svn_client_ctx_t_log_msg_baton2_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "log_msg_baton2", _wrap_svn_client_ctx_t_log_msg_baton2_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "progress_func=", _wrap_svn_client_ctx_t_progress_func_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "progress_func", _wrap_svn_client_ctx_t_progress_func_get, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "progress_baton=", _wrap_svn_client_ctx_t_progress_baton_set, -1);
    rb_define_method(cSvn_client_ctx_t.klass, "progress_baton", _wrap_svn_client_ctx_t_progress_baton_get, -1);
    cSvn_client_ctx_t.mark = 0;
    cSvn_client_ctx_t.destroy = (void (*)(void *)) free_svn_client_ctx_t;
    rb_define_const(mClient,"SVN_CLIENT_AUTH_USERNAME", rb_str_new2("username"));
    rb_define_const(mClient,"SVN_CLIENT_AUTH_PASSWORD", rb_str_new2("password"));
    rb_define_module_function(mClient, "svn_client_create_context", _wrap_svn_client_create_context, -1);
    rb_define_module_function(mClient, "svn_client_checkout2", _wrap_svn_client_checkout2, -1);
    rb_define_module_function(mClient, "svn_client_checkout", _wrap_svn_client_checkout, -1);
    rb_define_module_function(mClient, "svn_client_update2", _wrap_svn_client_update2, -1);
    rb_define_module_function(mClient, "svn_client_update", _wrap_svn_client_update, -1);
    rb_define_module_function(mClient, "svn_client_switch", _wrap_svn_client_switch, -1);
    rb_define_module_function(mClient, "svn_client_add3", _wrap_svn_client_add3, -1);
    rb_define_module_function(mClient, "svn_client_add2", _wrap_svn_client_add2, -1);
    rb_define_module_function(mClient, "svn_client_add", _wrap_svn_client_add, -1);
    rb_define_module_function(mClient, "svn_client_mkdir2", _wrap_svn_client_mkdir2, -1);
    rb_define_module_function(mClient, "svn_client_mkdir", _wrap_svn_client_mkdir, -1);
    rb_define_module_function(mClient, "svn_client_delete2", _wrap_svn_client_delete2, -1);
    rb_define_module_function(mClient, "svn_client_delete", _wrap_svn_client_delete, -1);
    rb_define_module_function(mClient, "svn_client_import2", _wrap_svn_client_import2, -1);
    rb_define_module_function(mClient, "svn_client_import", _wrap_svn_client_import, -1);
    rb_define_module_function(mClient, "svn_client_commit3", _wrap_svn_client_commit3, -1);
    rb_define_module_function(mClient, "svn_client_commit2", _wrap_svn_client_commit2, -1);
    rb_define_module_function(mClient, "svn_client_commit", _wrap_svn_client_commit, -1);
    rb_define_module_function(mClient, "svn_client_status2", _wrap_svn_client_status2, -1);
    rb_define_module_function(mClient, "svn_client_status", _wrap_svn_client_status, -1);
    rb_define_module_function(mClient, "svn_client_log3", _wrap_svn_client_log3, -1);
    rb_define_module_function(mClient, "svn_client_log2", _wrap_svn_client_log2, -1);
    rb_define_module_function(mClient, "svn_client_log", _wrap_svn_client_log, -1);
    rb_define_module_function(mClient, "svn_client_blame3", _wrap_svn_client_blame3, -1);
    rb_define_module_function(mClient, "svn_client_blame2", _wrap_svn_client_blame2, -1);
    rb_define_module_function(mClient, "svn_client_blame", _wrap_svn_client_blame, -1);
    rb_define_module_function(mClient, "svn_client_diff3", _wrap_svn_client_diff3, -1);
    rb_define_module_function(mClient, "svn_client_diff2", _wrap_svn_client_diff2, -1);
    rb_define_module_function(mClient, "svn_client_diff", _wrap_svn_client_diff, -1);
    rb_define_module_function(mClient, "svn_client_diff_peg3", _wrap_svn_client_diff_peg3, -1);
    rb_define_module_function(mClient, "svn_client_diff_peg2", _wrap_svn_client_diff_peg2, -1);
    rb_define_module_function(mClient, "svn_client_diff_peg", _wrap_svn_client_diff_peg, -1);
    rb_define_module_function(mClient, "svn_client_diff_summarize", _wrap_svn_client_diff_summarize, -1);
    rb_define_module_function(mClient, "svn_client_diff_summarize_peg", _wrap_svn_client_diff_summarize_peg, -1);
    rb_define_module_function(mClient, "svn_client_merge2", _wrap_svn_client_merge2, -1);
    rb_define_module_function(mClient, "svn_client_merge", _wrap_svn_client_merge, -1);
    rb_define_module_function(mClient, "svn_client_merge_peg2", _wrap_svn_client_merge_peg2, -1);
    rb_define_module_function(mClient, "svn_client_merge_peg", _wrap_svn_client_merge_peg, -1);
    rb_define_module_function(mClient, "svn_client_cleanup", _wrap_svn_client_cleanup, -1);
    rb_define_module_function(mClient, "svn_client_relocate", _wrap_svn_client_relocate, -1);
    rb_define_module_function(mClient, "svn_client_revert", _wrap_svn_client_revert, -1);
    rb_define_module_function(mClient, "svn_client_resolved", _wrap_svn_client_resolved, -1);
    rb_define_module_function(mClient, "svn_client_copy3", _wrap_svn_client_copy3, -1);
    rb_define_module_function(mClient, "svn_client_copy2", _wrap_svn_client_copy2, -1);
    rb_define_module_function(mClient, "svn_client_copy", _wrap_svn_client_copy, -1);
    rb_define_module_function(mClient, "svn_client_move4", _wrap_svn_client_move4, -1);
    rb_define_module_function(mClient, "svn_client_move3", _wrap_svn_client_move3, -1);
    rb_define_module_function(mClient, "svn_client_move2", _wrap_svn_client_move2, -1);
    rb_define_module_function(mClient, "svn_client_move", _wrap_svn_client_move, -1);
    rb_define_module_function(mClient, "svn_client_propset2", _wrap_svn_client_propset2, -1);
    rb_define_module_function(mClient, "svn_client_propset", _wrap_svn_client_propset, -1);
    rb_define_module_function(mClient, "svn_client_revprop_set", _wrap_svn_client_revprop_set, -1);
    rb_define_module_function(mClient, "svn_client_propget2", _wrap_svn_client_propget2, -1);
    rb_define_module_function(mClient, "svn_client_propget", _wrap_svn_client_propget, -1);
    rb_define_module_function(mClient, "svn_client_revprop_get", _wrap_svn_client_revprop_get, -1);
    rb_define_module_function(mClient, "svn_client_proplist2", _wrap_svn_client_proplist2, -1);
    rb_define_module_function(mClient, "svn_client_proplist", _wrap_svn_client_proplist, -1);
    rb_define_module_function(mClient, "svn_client_revprop_list", _wrap_svn_client_revprop_list, -1);
    rb_define_module_function(mClient, "svn_client_export3", _wrap_svn_client_export3, -1);
    rb_define_module_function(mClient, "svn_client_export2", _wrap_svn_client_export2, -1);
    rb_define_module_function(mClient, "svn_client_export", _wrap_svn_client_export, -1);
    rb_define_module_function(mClient, "svn_client_list", _wrap_svn_client_list, -1);
    rb_define_module_function(mClient, "svn_client_ls3", _wrap_svn_client_ls3, -1);
    rb_define_module_function(mClient, "svn_client_ls2", _wrap_svn_client_ls2, -1);
    rb_define_module_function(mClient, "svn_client_ls", _wrap_svn_client_ls, -1);
    rb_define_module_function(mClient, "svn_client_cat2", _wrap_svn_client_cat2, -1);
    rb_define_module_function(mClient, "svn_client_cat", _wrap_svn_client_cat, -1);
    rb_define_module_function(mClient, "svn_client_lock", _wrap_svn_client_lock, -1);
    rb_define_module_function(mClient, "svn_client_unlock", _wrap_svn_client_unlock, -1);
    
    cSvn_info_t.klass = rb_define_class_under(mClient, "Svn_info_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_info_t, (void *) &cSvn_info_t);
    rb_define_alloc_func(cSvn_info_t.klass, _wrap_svn_info_t_allocate);
    rb_define_method(cSvn_info_t.klass, "initialize", _wrap_new_svn_info_t, -1);
    rb_define_method(cSvn_info_t.klass, "URL=", _wrap_svn_info_t_URL_set, -1);
    rb_define_method(cSvn_info_t.klass, "URL", _wrap_svn_info_t_URL_get, -1);
    rb_define_method(cSvn_info_t.klass, "rev=", _wrap_svn_info_t_rev_set, -1);
    rb_define_method(cSvn_info_t.klass, "rev", _wrap_svn_info_t_rev_get, -1);
    rb_define_method(cSvn_info_t.klass, "kind=", _wrap_svn_info_t_kind_set, -1);
    rb_define_method(cSvn_info_t.klass, "kind", _wrap_svn_info_t_kind_get, -1);
    rb_define_method(cSvn_info_t.klass, "repos_root_URL=", _wrap_svn_info_t_repos_root_URL_set, -1);
    rb_define_method(cSvn_info_t.klass, "repos_root_URL", _wrap_svn_info_t_repos_root_URL_get, -1);
    rb_define_method(cSvn_info_t.klass, "repos_UUID=", _wrap_svn_info_t_repos_UUID_set, -1);
    rb_define_method(cSvn_info_t.klass, "repos_UUID", _wrap_svn_info_t_repos_UUID_get, -1);
    rb_define_method(cSvn_info_t.klass, "last_changed_rev=", _wrap_svn_info_t_last_changed_rev_set, -1);
    rb_define_method(cSvn_info_t.klass, "last_changed_rev", _wrap_svn_info_t_last_changed_rev_get, -1);
    rb_define_method(cSvn_info_t.klass, "last_changed_date=", _wrap_svn_info_t_last_changed_date_set, -1);
    rb_define_method(cSvn_info_t.klass, "last_changed_date", _wrap_svn_info_t_last_changed_date_get, -1);
    rb_define_method(cSvn_info_t.klass, "last_changed_author=", _wrap_svn_info_t_last_changed_author_set, -1);
    rb_define_method(cSvn_info_t.klass, "last_changed_author", _wrap_svn_info_t_last_changed_author_get, -1);
    rb_define_method(cSvn_info_t.klass, "lock=", _wrap_svn_info_t_lock_set, -1);
    rb_define_method(cSvn_info_t.klass, "lock", _wrap_svn_info_t_lock_get, -1);
    rb_define_method(cSvn_info_t.klass, "has_wc_info=", _wrap_svn_info_t_has_wc_info_set, -1);
    rb_define_method(cSvn_info_t.klass, "has_wc_info", _wrap_svn_info_t_has_wc_info_get, -1);
    rb_define_method(cSvn_info_t.klass, "schedule=", _wrap_svn_info_t_schedule_set, -1);
    rb_define_method(cSvn_info_t.klass, "schedule", _wrap_svn_info_t_schedule_get, -1);
    rb_define_method(cSvn_info_t.klass, "copyfrom_url=", _wrap_svn_info_t_copyfrom_url_set, -1);
    rb_define_method(cSvn_info_t.klass, "copyfrom_url", _wrap_svn_info_t_copyfrom_url_get, -1);
    rb_define_method(cSvn_info_t.klass, "copyfrom_rev=", _wrap_svn_info_t_copyfrom_rev_set, -1);
    rb_define_method(cSvn_info_t.klass, "copyfrom_rev", _wrap_svn_info_t_copyfrom_rev_get, -1);
    rb_define_method(cSvn_info_t.klass, "text_time=", _wrap_svn_info_t_text_time_set, -1);
    rb_define_method(cSvn_info_t.klass, "text_time", _wrap_svn_info_t_text_time_get, -1);
    rb_define_method(cSvn_info_t.klass, "prop_time=", _wrap_svn_info_t_prop_time_set, -1);
    rb_define_method(cSvn_info_t.klass, "prop_time", _wrap_svn_info_t_prop_time_get, -1);
    rb_define_method(cSvn_info_t.klass, "checksum=", _wrap_svn_info_t_checksum_set, -1);
    rb_define_method(cSvn_info_t.klass, "checksum", _wrap_svn_info_t_checksum_get, -1);
    rb_define_method(cSvn_info_t.klass, "conflict_old=", _wrap_svn_info_t_conflict_old_set, -1);
    rb_define_method(cSvn_info_t.klass, "conflict_old", _wrap_svn_info_t_conflict_old_get, -1);
    rb_define_method(cSvn_info_t.klass, "conflict_new=", _wrap_svn_info_t_conflict_new_set, -1);
    rb_define_method(cSvn_info_t.klass, "conflict_new", _wrap_svn_info_t_conflict_new_get, -1);
    rb_define_method(cSvn_info_t.klass, "conflict_wrk=", _wrap_svn_info_t_conflict_wrk_set, -1);
    rb_define_method(cSvn_info_t.klass, "conflict_wrk", _wrap_svn_info_t_conflict_wrk_get, -1);
    rb_define_method(cSvn_info_t.klass, "prejfile=", _wrap_svn_info_t_prejfile_set, -1);
    rb_define_method(cSvn_info_t.klass, "prejfile", _wrap_svn_info_t_prejfile_get, -1);
    cSvn_info_t.mark = 0;
    cSvn_info_t.destroy = (void (*)(void *)) free_svn_info_t;
    rb_define_module_function(mClient, "svn_info_dup", _wrap_svn_info_dup, -1);
    rb_define_module_function(mClient, "svn_client_info", _wrap_svn_client_info, -1);
    rb_define_module_function(mClient, "svn_client_url_from_path", _wrap_svn_client_url_from_path, -1);
    rb_define_module_function(mClient, "svn_client_uuid_from_url", _wrap_svn_client_uuid_from_url, -1);
    rb_define_module_function(mClient, "svn_client_uuid_from_path", _wrap_svn_client_uuid_from_path, -1);
    rb_define_module_function(mClient, "svn_client_open_ra_session", _wrap_svn_client_open_ra_session, -1);
    rb_define_module_function(mClient, "svn_client_set_log_msg_func2", _wrap_svn_client_set_log_msg_func2, -1);
    rb_define_module_function(mClient, "svn_client_set_notify_func2", _wrap_svn_client_set_notify_func2, -1);
    rb_define_module_function(mClient, "svn_client_set_cancel_func", _wrap_svn_client_set_cancel_func, -1);
}

