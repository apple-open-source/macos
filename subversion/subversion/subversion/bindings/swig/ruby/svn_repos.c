/* ----------------------------------------------------------------------------
 * This file was automatically generated by SWIG (http://www.swig.org).
 * Version 1.3.25
 * 
 * This file is not intended to be easily readable and contains a number of 
 * coding conventions designed to improve portability and efficiency. Do not make
 * changes to this file unless you know what you are doing--modify the SWIG 
 * interface file instead. 
 * ----------------------------------------------------------------------------- */

/***********************************************************************
 *
 *  This section contains generic SWIG labels for method/variable
 *  declarations/attributes, and other compiler dependent labels.
 *
 ************************************************************************/

/* template workaround for compilers that cannot correctly implement the C++ standard */
#ifndef SWIGTEMPLATEDISAMBIGUATOR
#  if defined(__SUNPRO_CC) && (__SUNPRO_CC <= 0x560)
#    define SWIGTEMPLATEDISAMBIGUATOR template
#  else
#    define SWIGTEMPLATEDISAMBIGUATOR 
#  endif
#endif

/* inline attribute */
#ifndef SWIGINLINE
# if defined(__cplusplus) || (defined(__GNUC__) && !defined(__STRICT_ANSI__))
#   define SWIGINLINE inline
# else
#   define SWIGINLINE
# endif
#endif

/* attribute recognised by some compilers to avoid 'unused' warnings */
#ifndef SWIGUNUSED
# if defined(__GNUC__) || defined(__ICC)
#   define SWIGUNUSED __attribute__ ((unused)) 
# else
#   define SWIGUNUSED 
# endif
#endif

/* internal SWIG method */
#ifndef SWIGINTERN
# define SWIGINTERN static SWIGUNUSED
#endif

/* internal inline SWIG method */
#ifndef SWIGINTERNINLINE
# define SWIGINTERNINLINE SWIGINTERN SWIGINLINE
#endif

/* exporting methods for Windows DLLs */
#ifndef SWIGEXPORT
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   if defined(STATIC_LINKED)
#     define SWIGEXPORT
#   else
#     define SWIGEXPORT __declspec(dllexport)
#   endif
# else
#   define SWIGEXPORT
# endif
#endif

/* calling conventions for Windows */
#ifndef SWIGSTDCALL
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   define SWIGSTDCALL __stdcall
# else
#   define SWIGSTDCALL
# endif 
#endif


/* ruby.swg */
/* Implementation : RUBY */
#define SWIGRUBY 1

#include "ruby.h"

/* Flags for pointer conversion */
#define SWIG_POINTER_EXCEPTION     0x1
#define SWIG_POINTER_DISOWN        0x2

#define NUM2USHRT(n) (\
    (0 <= NUM2UINT(n) && NUM2UINT(n) <= USHRT_MAX)\
    ? (unsigned short) NUM2UINT(n) \
    : (rb_raise(rb_eArgError, "integer %d out of range of `unsigned short'",\
               NUM2UINT(n)), (short)0)\
)

#define NUM2SHRT(n) (\
    (SHRT_MIN <= NUM2INT(n) && NUM2INT(n) <= SHRT_MAX)\
    ? (short)NUM2INT(n)\
    : (rb_raise(rb_eArgError, "integer %d out of range of `short'",\
               NUM2INT(n)), (short)0)\
)

/* Ruby 1.7 defines NUM2LL(), LL2NUM() and ULL2NUM() macros */
#ifndef NUM2LL
#define NUM2LL(x) NUM2LONG((x))
#endif
#ifndef LL2NUM
#define LL2NUM(x) INT2NUM((long) (x))
#endif
#ifndef ULL2NUM
#define ULL2NUM(x) UINT2NUM((unsigned long) (x))
#endif

/* Ruby 1.7 doesn't (yet) define NUM2ULL() */
#ifndef NUM2ULL
#ifdef HAVE_LONG_LONG
#define NUM2ULL(x) rb_num2ull((x))
#else
#define NUM2ULL(x) NUM2ULONG(x)
#endif
#endif

/*
 * Need to be very careful about how these macros are defined, especially
 * when compiling C++ code or C code with an ANSI C compiler.
 *
 * VALUEFUNC(f) is a macro used to typecast a C function that implements
 * a Ruby method so that it can be passed as an argument to API functions
 * like rb_define_method() and rb_define_singleton_method().
 *
 * VOIDFUNC(f) is a macro used to typecast a C function that implements
 * either the "mark" or "free" stuff for a Ruby Data object, so that it
 * can be passed as an argument to API functions like Data_Wrap_Struct()
 * and Data_Make_Struct().
 */
 
#ifdef __cplusplus
#  ifndef RUBY_METHOD_FUNC /* These definitions should work for Ruby 1.4.6 */
#    define PROTECTFUNC(f) ((VALUE (*)()) f)
#    define VALUEFUNC(f) ((VALUE (*)()) f)
#    define VOIDFUNC(f)  ((void (*)()) f)
#  else
#    ifndef ANYARGS /* These definitions should work for Ruby 1.6 */
#      define PROTECTFUNC(f) ((VALUE (*)()) f)
#      define VALUEFUNC(f) ((VALUE (*)()) f)
#      define VOIDFUNC(f)  ((RUBY_DATA_FUNC) f)
#    else /* These definitions should work for Ruby 1.7+ */
#      define PROTECTFUNC(f) ((VALUE (*)(VALUE)) f)
#      define VALUEFUNC(f) ((VALUE (*)(ANYARGS)) f)
#      define VOIDFUNC(f)  ((RUBY_DATA_FUNC) f)
#    endif
#  endif
#else
#  define VALUEFUNC(f) (f)
#  define VOIDFUNC(f) (f)
#endif

typedef struct {
  VALUE klass;
  VALUE mImpl;
  void  (*mark)(void *);
  void  (*destroy)(void *);
} swig_class;

/* Don't use for expressions have side effect */
#ifndef RB_STRING_VALUE
#define RB_STRING_VALUE(s) (TYPE(s) == T_STRING ? (s) : (*(volatile VALUE *)&(s) = rb_str_to_str(s)))
#endif
#ifndef StringValue
#define StringValue(s) RB_STRING_VALUE(s)
#endif
#ifndef StringValuePtr
#define StringValuePtr(s) RSTRING(RB_STRING_VALUE(s))->ptr
#endif
#ifndef StringValueLen
#define StringValueLen(s) RSTRING(RB_STRING_VALUE(s))->len
#endif
#ifndef SafeStringValue
#define SafeStringValue(v) do {\
    StringValue(v);\
    rb_check_safe_str(v);\
} while (0)
#endif

#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
#define rb_define_alloc_func(klass, func) rb_define_singleton_method((klass), "new", VALUEFUNC((func)), -1)
#define rb_undef_alloc_func(klass) rb_undef_method(CLASS_OF((klass)), "new")
#endif

/* Contract support */

#define SWIG_contract_assert(expr, msg) if (!(expr)) { rb_raise(rb_eRuntimeError, (char *) msg ); } else



/***********************************************************************
 * swigrun.swg
 *
 *     This file contains generic CAPI SWIG runtime support for pointer
 *     type checking.
 *
 ************************************************************************/

/* This should only be incremented when either the layout of swig_type_info changes,
   or for whatever reason, the runtime changes incompatibly */
#define SWIG_RUNTIME_VERSION "2"

/* define SWIG_TYPE_TABLE_NAME as "SWIG_TYPE_TABLE" */
#ifdef SWIG_TYPE_TABLE
# define SWIG_QUOTE_STRING(x) #x
# define SWIG_EXPAND_AND_QUOTE_STRING(x) SWIG_QUOTE_STRING(x)
# define SWIG_TYPE_TABLE_NAME SWIG_EXPAND_AND_QUOTE_STRING(SWIG_TYPE_TABLE)
#else
# define SWIG_TYPE_TABLE_NAME
#endif

/*
  You can use the SWIGRUNTIME and SWIGRUNTIMEINLINE macros for
  creating a static or dynamic library from the swig runtime code.
  In 99.9% of the cases, swig just needs to declare them as 'static'.
  
  But only do this if is strictly necessary, ie, if you have problems
  with your compiler or so.
*/

#ifndef SWIGRUNTIME
# define SWIGRUNTIME SWIGINTERN
#endif

#ifndef SWIGRUNTIMEINLINE
# define SWIGRUNTIMEINLINE SWIGRUNTIME SWIGINLINE
#endif

#include <string.h>

#ifdef __cplusplus
extern "C" {
#endif

typedef void *(*swig_converter_func)(void *);
typedef struct swig_type_info *(*swig_dycast_func)(void **);

/* Structure to store inforomation on one type */
typedef struct swig_type_info {
  const char             *name;			/* mangled name of this type */
  const char             *str;			/* human readable name of this type */
  swig_dycast_func        dcast;		/* dynamic cast function down a hierarchy */
  struct swig_cast_info  *cast;			/* linked list of types that can cast into this type */
  void                   *clientdata;		/* language specific type data */
} swig_type_info;

/* Structure to store a type and conversion function used for casting */
typedef struct swig_cast_info {
  swig_type_info         *type;			/* pointer to type that is equivalent to this type */
  swig_converter_func     converter;		/* function to cast the void pointers */
  struct swig_cast_info  *next;			/* pointer to next cast in linked list */
  struct swig_cast_info  *prev;			/* pointer to the previous cast */
} swig_cast_info;

/* Structure used to store module information
 * Each module generates one structure like this, and the runtime collects
 * all of these structures and stores them in a circularly linked list.*/
typedef struct swig_module_info {
  swig_type_info         **types;		/* Array of pointers to swig_type_info structures that are in this module */
  size_t                 size;		        /* Number of types in this module */
  struct swig_module_info *next;		/* Pointer to next element in circularly linked list */
  swig_type_info         **type_initial;	/* Array of initially generated type structures */
  swig_cast_info         **cast_initial;	/* Array of initially generated casting structures */
  void                    *clientdata;		/* Language specific module data */
} swig_module_info;


/* 
  Compare two type names skipping the space characters, therefore
  "char*" == "char *" and "Class<int>" == "Class<int >", etc.

  Return 0 when the two name types are equivalent, as in
  strncmp, but skipping ' '.
*/
SWIGRUNTIME int
SWIG_TypeNameComp(const char *f1, const char *l1,
		  const char *f2, const char *l2) {
  for (;(f1 != l1) && (f2 != l2); ++f1, ++f2) {
    while ((*f1 == ' ') && (f1 != l1)) ++f1;
    while ((*f2 == ' ') && (f2 != l2)) ++f2;
    if (*f1 != *f2) return (int)(*f1 - *f2);
  }
  return (l1 - f1) - (l2 - f2);
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if not equal, 1 if equal
*/
SWIGRUNTIME int
SWIG_TypeEquiv(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if equal, -1 if nb < tb, 1 if nb > tb
*/
SWIGRUNTIME int
SWIG_TypeCompare(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}


/* think of this as a c++ template<> or a scheme macro */
#define SWIG_TypeCheck_Template(comparison, ty)         \
  if (ty) {                                             \
    swig_cast_info *iter = ty->cast;                    \
    while (iter) {                                      \
      if (comparison) {                                 \
        if (iter == ty->cast) return iter;              \
        /* Move iter to the top of the linked list */   \
        iter->prev->next = iter->next;                  \
        if (iter->next)                                 \
          iter->next->prev = iter->prev;                \
        iter->next = ty->cast;                          \
        iter->prev = 0;                                 \
        if (ty->cast) ty->cast->prev = iter;            \
        ty->cast = iter;                                \
        return iter;                                    \
      }                                                 \
      iter = iter->next;                                \
    }                                                   \
  }                                                     \
  return 0

/*
  Check the typename
*/
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheck(const char *c, swig_type_info *ty) {
  SWIG_TypeCheck_Template(strcmp(iter->type->name, c) == 0, ty);
}

/* Same as previous function, except strcmp is replaced with a pointer comparison */
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheckStruct(swig_type_info *from, swig_type_info *into) {
  SWIG_TypeCheck_Template(iter->type == from, into);
}

/*
  Cast a pointer up an inheritance hierarchy
*/
SWIGRUNTIMEINLINE void *
SWIG_TypeCast(swig_cast_info *ty, void *ptr) {
  return ((!ty) || (!ty->converter)) ? ptr : (*ty->converter)(ptr);
}

/* 
   Dynamic pointer casting. Down an inheritance hierarchy
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeDynamicCast(swig_type_info *ty, void **ptr) {
  swig_type_info *lastty = ty;
  if (!ty || !ty->dcast) return ty;
  while (ty && (ty->dcast)) {
    ty = (*ty->dcast)(ptr);
    if (ty) lastty = ty;
  }
  return lastty;
}

/*
  Return the name associated with this type
*/
SWIGRUNTIMEINLINE const char *
SWIG_TypeName(const swig_type_info *ty) {
  return ty->name;
}

/*
  Return the pretty name associated with this type,
  that is an unmangled type name in a form presentable to the user.
*/
SWIGRUNTIME const char *
SWIG_TypePrettyName(const swig_type_info *type) {
  /* The "str" field contains the equivalent pretty names of the
     type, separated by vertical-bar characters.  We choose
     to print the last name, as it is often (?) the most
     specific. */
  if (type->str != NULL) {
    const char *last_name = type->str;
    const char *s;
    for (s = type->str; *s; s++)
      if (*s == '|') last_name = s+1;
    return last_name;
  }
  else
    return type->name;
}

/* 
   Set the clientdata field for a type
*/
SWIGRUNTIME void
SWIG_TypeClientData(swig_type_info *ti, void *clientdata) {
  if (!ti->clientdata) {
    swig_cast_info *cast = ti->cast;
    /* if (ti->clientdata == clientdata) return; */
    ti->clientdata = clientdata;
    
    while (cast) {
      if (!cast->converter)
	SWIG_TypeClientData(cast->type, clientdata);
      cast = cast->next;
    }
  }
}

/*
  Search for a swig_type_info structure only by mangled name
  Search is a O(log #types)
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_MangledTypeQueryModule(swig_module_info *start, 
                            swig_module_info *end, 
		            const char *name) {
  swig_module_info *iter = start;
  do {
    if (iter->size) {
      register size_t l = 0;
      register size_t r = iter->size - 1;
      do {
	/* since l+r >= 0, we can (>> 1) instead (/ 2) */
	register size_t i = (l + r) >> 1; 
	const char *iname = iter->types[i]->name;
	if (iname) {
	  register int compare = strcmp(name, iname);
	  if (compare == 0) {	    
	    return iter->types[i];
	  } else if (compare < 0) {
	    if (i) {
	      r = i - 1;
	    } else {
	      break;
	    }
	  } else if (compare > 0) {
	    l = i + 1;
	  }
	} else {
	  break; /* should never happen */
	}
      } while (l <= r);
    }
    iter = iter->next;
  } while (iter != end);
  return 0;
}

/*
  Search for a swig_type_info structure for either a mangled name or a human readable name.
  It first searches the mangled names of the types, which is a O(log #types)
  If a type is not found it then searches the human readable names, which is O(#types).
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeQueryModule(swig_module_info *start, 
                     swig_module_info *end, 
		     const char *name) {
  /* STEP 1: Search the name field using binary search */
  swig_type_info *ret = SWIG_MangledTypeQueryModule(start, end, name);
  if (ret) {
    return ret;
  } else {
    /* STEP 2: If the type hasn't been found, do a complete search
       of the str field (the human readable name) */
    swig_module_info *iter = start;
    do {
      register size_t i = 0;
      for (; i < iter->size; ++i) {
	if (iter->types[i]->str && (SWIG_TypeEquiv(iter->types[i]->str, name)))
	  return iter->types[i];
      }
      iter = iter->next;
    } while (iter != end);
  }
  
  /* neither found a match */
  return 0;
}


/* 
   Pack binary data into a string
*/
SWIGRUNTIME char *
SWIG_PackData(char *c, void *ptr, size_t sz) {
  static const char hex[17] = "0123456789abcdef";
  register const unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu =  u + sz;
  for (; u != eu; ++u) {
    register unsigned char uu = *u;
    *(c++) = hex[(uu & 0xf0) >> 4];
    *(c++) = hex[uu & 0xf];
  }
  return c;
}

/* 
   Unpack binary data from a string
*/
SWIGRUNTIME const char *
SWIG_UnpackData(const char *c, void *ptr, size_t sz) {
  register unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu = u + sz;
  for (; u != eu; ++u) {
    register char d = *(c++);
    register unsigned char uu = 0;
    if ((d >= '0') && (d <= '9'))
      uu = ((d - '0') << 4);
    else if ((d >= 'a') && (d <= 'f'))
      uu = ((d - ('a'-10)) << 4);
    else 
      return (char *) 0;
    d = *(c++);
    if ((d >= '0') && (d <= '9'))
      uu |= (d - '0');
    else if ((d >= 'a') && (d <= 'f'))
      uu |= (d - ('a'-10));
    else 
      return (char *) 0;
    *u = uu;
  }
  return c;
}

/* 
   Pack 'void *' into a string buffer.
*/
SWIGRUNTIME char *
SWIG_PackVoidPtr(char *buff, void *ptr, const char *name, size_t bsz) {
  char *r = buff;
  if ((2*sizeof(void *) + 2) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,&ptr,sizeof(void *));
  if (strlen(name) + 1 > (bsz - (r - buff))) return 0;
  strcpy(r,name);
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackVoidPtr(const char *c, void **ptr, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      *ptr = (void *) 0;
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sizeof(void *));
}

SWIGRUNTIME char *
SWIG_PackDataName(char *buff, void *ptr, size_t sz, const char *name, size_t bsz) {
  char *r = buff;
  size_t lname = (name ? strlen(name) : 0);
  if ((2*sz + 2 + lname) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,ptr,sz);
  if (lname) {
    strncpy(r,name,lname+1);
  } else {
    *r = 0;
  }
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackDataName(const char *c, void *ptr, size_t sz, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      memset(ptr,0,sz);
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sz);
}

#ifdef __cplusplus
}
#endif


/* Common SWIG API */
#define SWIG_ConvertPtr(obj, pp, type, flags) \
  SWIG_Ruby_ConvertPtr(obj, pp, type, flags)
#define SWIG_NewPointerObj(p, type, flags) \
  SWIG_Ruby_NewPointerObj(p, type, flags)
#define SWIG_MustGetPtr(p, type, argnum, flags) \
  SWIG_Ruby_MustGetPtr(p, type, argnum, flags)
#define SWIG_GetModule(clientdata) \
  SWIG_Ruby_GetModule()
#define SWIG_SetModule(clientdata, pointer) \
  SWIG_Ruby_SetModule(pointer)

/* Ruby-specific SWIG API */

#define SWIG_InitRuntime() \
  SWIG_Ruby_InitRuntime()
#define SWIG_define_class(ty) \
  SWIG_Ruby_define_class(ty)
#define SWIG_NewClassInstance(value, ty) \
  SWIG_Ruby_NewClassInstance(value, ty)
#define SWIG_MangleStr(value) \
  SWIG_Ruby_MangleStr(value)
#define SWIG_CheckConvert(value, ty) \
  SWIG_Ruby_CheckConvert(value, ty)
#define SWIG_NewPackedObj(ptr, sz, ty) \
  SWIG_Ruby_NewPackedObj(ptr, sz, ty)
#define SWIG_ConvertPacked(obj, ptr, sz, ty, flags) \
  SWIG_Ruby_ConvertPacked(obj, ptr, sz, ty, flags)

/* rubydef.swg */
#ifdef __cplusplus
extern "C" {
#endif

static VALUE _mSWIG = Qnil;
static VALUE _cSWIG_Pointer = Qnil;
static VALUE swig_runtime_data_type_pointer = Qnil;

/* Initialize Ruby runtime support */
static void
SWIG_Ruby_InitRuntime(void)
{
    if (_mSWIG == Qnil) {
        _mSWIG = rb_define_module("SWIG");
    }
}

/* Define Ruby class for C type */
static void
SWIG_Ruby_define_class(swig_type_info *type)
{
    VALUE klass;
    char *klass_name = (char *) malloc(4 + strlen(type->name) + 1);
    sprintf(klass_name, "TYPE%s", type->name);
    if (NIL_P(_cSWIG_Pointer)) {
	_cSWIG_Pointer = rb_define_class_under(_mSWIG, "Pointer", rb_cObject);
	rb_undef_method(CLASS_OF(_cSWIG_Pointer), "new");
    }
    klass = rb_define_class_under(_mSWIG, klass_name, _cSWIG_Pointer);
    free((void *) klass_name);
}

/* Create a new pointer object */
static VALUE
SWIG_Ruby_NewPointerObj(void *ptr, swig_type_info *type, int own)
{
    char *klass_name;
    swig_class *sklass;
    VALUE klass;
    VALUE obj;
    
    if (!ptr)
	return Qnil;
    
    if (type->clientdata) {
      sklass = (swig_class *) type->clientdata;
      obj = Data_Wrap_Struct(sklass->klass, VOIDFUNC(sklass->mark), (own ? VOIDFUNC(sklass->destroy) : 0), ptr);
    } else {
      klass_name = (char *) malloc(4 + strlen(type->name) + 1);
      sprintf(klass_name, "TYPE%s", type->name);
      klass = rb_const_get(_mSWIG, rb_intern(klass_name));
      free((void *) klass_name);
      obj = Data_Wrap_Struct(klass, 0, 0, ptr);
    }
    rb_iv_set(obj, "__swigtype__", rb_str_new2(type->name));
    return obj;
}

/* Create a new class instance (always owned) */
static VALUE
SWIG_Ruby_NewClassInstance(VALUE klass, swig_type_info *type)
{
    VALUE obj;
    swig_class *sklass = (swig_class *) type->clientdata;
    obj = Data_Wrap_Struct(klass, VOIDFUNC(sklass->mark), VOIDFUNC(sklass->destroy), 0);
    rb_iv_set(obj, "__swigtype__", rb_str_new2(type->name));
    return obj;
}

/* Get type mangle from class name */
static SWIGINLINE char *
SWIG_Ruby_MangleStr(VALUE obj)
{
  VALUE stype = rb_iv_get(obj, "__swigtype__");
  return StringValuePtr(stype);
}

/* Convert a pointer value */
static int
SWIG_Ruby_ConvertPtr(VALUE obj, void **ptr, swig_type_info *ty, int flags)
{
  char *c;
  swig_cast_info *tc;

  /* Grab the pointer */
  if (NIL_P(obj)) {
    *ptr = 0;
    return 0;
  } else {
    Data_Get_Struct(obj, void, *ptr);
  }
  
  /* Do type-checking if type info was provided */
  if (ty) {
    if (ty->clientdata) {
        if (rb_obj_is_kind_of(obj, ((swig_class *) (ty->clientdata))->klass)) {
          if (*ptr == 0)
            rb_raise(rb_eRuntimeError, "This %s already released", ty->str);
          return 0;
        }
    }
    if ((c = SWIG_MangleStr(obj)) == NULL) {
      if (flags & SWIG_POINTER_EXCEPTION)
        rb_raise(rb_eTypeError, "Expected %s", ty->str);
      else
        return -1;
    }
    tc = SWIG_TypeCheck(c, ty);
    if (!tc) {
      if (flags & SWIG_POINTER_EXCEPTION)
        rb_raise(rb_eTypeError, "Expected %s", ty->str);
      else
        return -1;
    }
    *ptr = SWIG_TypeCast(tc, *ptr);
  }
  return 0;
}

/* Convert a pointer value, signal an exception on a type mismatch */
static SWIGINLINE void *
SWIG_Ruby_MustGetPtr(VALUE obj, swig_type_info *ty, int argnum, int flags)
{
  void *result;
  SWIG_ConvertPtr(obj, &result, ty, flags | SWIG_POINTER_EXCEPTION);
  return result;
}

/* Check convert */
static SWIGINLINE int
SWIG_Ruby_CheckConvert(VALUE obj, swig_type_info *ty)
{
  char *c = SWIG_MangleStr(obj);
  if (!c)
    return 0;
  return SWIG_TypeCheck(c,ty) != 0;
}

static VALUE
SWIG_Ruby_NewPackedObj(void *ptr, int sz, swig_type_info *type) {
  char result[1024];
  char *r = result;
  if ((2*sz + 1 + strlen(type->name)) > 1000) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r, ptr, sz);
  strcpy(r, type->name);
  return rb_str_new2(result);
}

/* Convert a packed value value */
static void
SWIG_Ruby_ConvertPacked(VALUE obj, void *ptr, int sz, swig_type_info *ty, int flags) {
  swig_cast_info *tc;
  const char  *c;

  if (TYPE(obj) != T_STRING) goto type_error;
  c = StringValuePtr(obj);
  /* Pointer values must start with leading underscore */
  if (*c != '_') goto type_error;
  c++;
  c = SWIG_UnpackData(c, ptr, sz);
  if (ty) {
    tc = SWIG_TypeCheck(c, ty);
    if (!tc) goto type_error;
  }
  return;

type_error:

  if (flags) {
    if (ty) {
      rb_raise(rb_eTypeError, "Type error. Expected %s", ty->name);
    } else {
      rb_raise(rb_eTypeError, "Expected a pointer");
    }
  }
}

static swig_module_info *SWIG_Ruby_GetModule() {
    VALUE pointer;
    swig_module_info *ret = 0;

   /* first check if pointer already created */
    pointer = rb_gv_get("$swig_runtime_data_type_pointer" SWIG_RUNTIME_VERSION SWIG_TYPE_TABLE_NAME);
    if (pointer != Qnil) {
      Data_Get_Struct(pointer, swig_module_info, ret);
    }
    return ret;
}

static void SWIG_Ruby_SetModule(swig_module_info *pointer) {
      /* register a new class */
      VALUE cl = rb_define_class("swig_runtime_data", rb_cObject);
      /* create and store the structure pointer to a global variable */
      swig_runtime_data_type_pointer = Data_Wrap_Struct(cl, 0, 0, pointer);
      rb_define_readonly_variable("$swig_runtime_data_type_pointer" SWIG_RUNTIME_VERSION SWIG_TYPE_TABLE_NAME, &swig_runtime_data_type_pointer);
}

#ifdef __cplusplus
}
#endif




/* -------- TYPES TABLE (BEGIN) -------- */

#define SWIGTYPE_p_apr_array_header_t swig_types[0]
#define SWIGTYPE_p_apr_hash_t swig_types[1]
#define SWIGTYPE_p_apr_int32_t swig_types[2]
#define SWIGTYPE_p_apr_int64_t swig_types[3]
#define SWIGTYPE_p_apr_pool_t swig_types[4]
#define SWIGTYPE_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[5]
#define SWIGTYPE_p_f_p_p_svn_stream_t_p_void__p_svn_error_t swig_types[6]
#define SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[7]
#define SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t swig_types[8]
#define SWIGTYPE_p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[9]
#define SWIGTYPE_p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t swig_types[10]
#define SWIGTYPE_p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t swig_types[11]
#define SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t swig_types[12]
#define SWIGTYPE_p_f_p_void__p_svn_error_t swig_types[13]
#define SWIGTYPE_p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[14]
#define SWIGTYPE_p_f_p_void_p_q_const__char__p_svn_error_t swig_types[15]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t swig_types[16]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t swig_types[17]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t swig_types[18]
#define SWIGTYPE_p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t swig_types[19]
#define SWIGTYPE_p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t swig_types[20]
#define SWIGTYPE_p_int swig_types[21]
#define SWIGTYPE_p_long swig_types[22]
#define SWIGTYPE_p_p_apr_array_header_t swig_types[23]
#define SWIGTYPE_p_p_apr_hash_t swig_types[24]
#define SWIGTYPE_p_p_char swig_types[25]
#define SWIGTYPE_p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t swig_types[26]
#define SWIGTYPE_p_p_svn_authz_t swig_types[27]
#define SWIGTYPE_p_p_svn_delta_editor_t swig_types[28]
#define SWIGTYPE_p_p_svn_dirent_t swig_types[29]
#define SWIGTYPE_p_p_svn_fs_txn_t swig_types[30]
#define SWIGTYPE_p_p_svn_lock_t swig_types[31]
#define SWIGTYPE_p_p_svn_repos_parse_fns2_t swig_types[32]
#define SWIGTYPE_p_p_svn_repos_parse_fns_t swig_types[33]
#define SWIGTYPE_p_p_svn_repos_t swig_types[34]
#define SWIGTYPE_p_p_svn_stream_t swig_types[35]
#define SWIGTYPE_p_p_svn_string_t swig_types[36]
#define SWIGTYPE_p_p_void swig_types[37]
#define SWIGTYPE_p_svn_auth_baton_t swig_types[38]
#define SWIGTYPE_p_svn_auth_cred_simple_t swig_types[39]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_pw_t swig_types[40]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_t swig_types[41]
#define SWIGTYPE_p_svn_auth_cred_ssl_server_trust_t swig_types[42]
#define SWIGTYPE_p_svn_auth_cred_username_t swig_types[43]
#define SWIGTYPE_p_svn_auth_iterstate_t swig_types[44]
#define SWIGTYPE_p_svn_auth_provider_object_t swig_types[45]
#define SWIGTYPE_p_svn_auth_provider_t swig_types[46]
#define SWIGTYPE_p_svn_auth_ssl_server_cert_info_t swig_types[47]
#define SWIGTYPE_p_svn_authz_t swig_types[48]
#define SWIGTYPE_p_svn_commit_info_t swig_types[49]
#define SWIGTYPE_p_svn_config_t swig_types[50]
#define SWIGTYPE_p_svn_delta_editor_t swig_types[51]
#define SWIGTYPE_p_svn_diff_datasource_e swig_types[52]
#define SWIGTYPE_p_svn_diff_file_ignore_space_t swig_types[53]
#define SWIGTYPE_p_svn_diff_file_options_t swig_types[54]
#define SWIGTYPE_p_svn_diff_fns_t swig_types[55]
#define SWIGTYPE_p_svn_diff_output_fns_t swig_types[56]
#define SWIGTYPE_p_svn_diff_t swig_types[57]
#define SWIGTYPE_p_svn_dirent_t swig_types[58]
#define SWIGTYPE_p_svn_errno_t swig_types[59]
#define SWIGTYPE_p_svn_error_t swig_types[60]
#define SWIGTYPE_p_svn_fs_access_t swig_types[61]
#define SWIGTYPE_p_svn_fs_dirent_t swig_types[62]
#define SWIGTYPE_p_svn_fs_history_t swig_types[63]
#define SWIGTYPE_p_svn_fs_id_t swig_types[64]
#define SWIGTYPE_p_svn_fs_path_change_kind_t swig_types[65]
#define SWIGTYPE_p_svn_fs_path_change_t swig_types[66]
#define SWIGTYPE_p_svn_fs_root_t swig_types[67]
#define SWIGTYPE_p_svn_fs_t swig_types[68]
#define SWIGTYPE_p_svn_fs_txn_t swig_types[69]
#define SWIGTYPE_p_svn_io_dirent_t swig_types[70]
#define SWIGTYPE_p_svn_io_file_del_t swig_types[71]
#define SWIGTYPE_p_svn_lock_t swig_types[72]
#define SWIGTYPE_p_svn_log_changed_path_t swig_types[73]
#define SWIGTYPE_p_svn_node_kind_t swig_types[74]
#define SWIGTYPE_p_svn_opt_revision_t swig_types[75]
#define SWIGTYPE_p_svn_opt_revision_value_t swig_types[76]
#define SWIGTYPE_p_svn_opt_subcommand_desc2_t swig_types[77]
#define SWIGTYPE_p_svn_opt_subcommand_desc_t swig_types[78]
#define SWIGTYPE_p_svn_prop_kind swig_types[79]
#define SWIGTYPE_p_svn_prop_t swig_types[80]
#define SWIGTYPE_p_svn_repos_authz_access_t swig_types[81]
#define SWIGTYPE_p_svn_repos_node_t swig_types[82]
#define SWIGTYPE_p_svn_repos_parse_fns2_t swig_types[83]
#define SWIGTYPE_p_svn_repos_parse_fns_t swig_types[84]
#define SWIGTYPE_p_svn_repos_t swig_types[85]
#define SWIGTYPE_p_svn_stream_t swig_types[86]
#define SWIGTYPE_p_svn_string_t swig_types[87]
#define SWIGTYPE_p_svn_stringbuf_t swig_types[88]
#define SWIGTYPE_p_svn_txdelta_op_t swig_types[89]
#define SWIGTYPE_p_svn_txdelta_stream_t swig_types[90]
#define SWIGTYPE_p_svn_txdelta_window_t swig_types[91]
#define SWIGTYPE_p_svn_version_checklist_t swig_types[92]
#define SWIGTYPE_p_svn_version_t swig_types[93]
#define SWIGTYPE_p_unsigned_long swig_types[94]
#define SWIGTYPE_p_void swig_types[95]
static swig_type_info *swig_types[96];
static swig_module_info swig_module = {swig_types, 96, 0, 0, 0, 0};
#define SWIG_TypeQuery(name) SWIG_TypeQueryModule(&swig_module, &swig_module, name)
#define SWIG_MangledTypeQuery(name) SWIG_MangledTypeQueryModule(&swig_module, &swig_module, name)

/* -------- TYPES TABLE (END) -------- */

#define SWIG_init    Init_repos
#define SWIG_name    "Svn::Ext::Repos"

static VALUE mRepos;

static void SWIG_AsVal(VALUE obj, int *val)
{
    *val = (int) NUM2INT(obj);
}


#ifdef __cplusplus
extern "C" {
#endif
#ifdef HAVE_SYS_TIME_H
# include <sys/time.h>
struct timeval rb_time_timeval(VALUE);
#endif
#ifdef __cplusplus
}
#endif


#ifdef __cplusplus
extern "C" {
#endif
#include "rubyio.h"
#ifdef __cplusplus
}
#endif


static VALUE _global_svn_swig_rb_pool = Qnil;


#include "svn_time.h"
#include "svn_pools.h"


#ifdef SWIGPYTHON
#include "swigutil_py.h"
#endif

#ifdef SWIGPERL
#include "swigutil_pl.h"
#endif

#ifdef SWIGRUBY
#include "swigutil_rb.h"
#endif


#include "svn_repos.h"


static VALUE output_helper(VALUE target, VALUE o) {
    if (NIL_P(target)) {
	target = o;
    } else {
	if (TYPE(target) != T_ARRAY) {
	    VALUE o2 = target;
	    target = rb_ary_new();
	    rb_ary_push(target, o2);
	}
	rb_ary_push(target, o);
    }
    return target;
}


static svn_error_t *svn_repos_parse_fns2_invoke_new_revision_record(
  svn_repos_parse_fns2_t *_obj, void **revision_baton, apr_hash_t *headers, void *parse_baton, apr_pool_t *pool) {
  return _obj->new_revision_record(revision_baton, headers, parse_baton, pool);
}

static svn_error_t *svn_repos_parse_fns2_invoke_uuid_record(
  svn_repos_parse_fns2_t *_obj, const char *uuid, void *parse_baton, apr_pool_t *pool) {
  return _obj->uuid_record(uuid, parse_baton, pool);
}

static svn_error_t *svn_repos_parse_fns2_invoke_new_node_record(
  svn_repos_parse_fns2_t *_obj, void **node_baton, apr_hash_t *headers, void *revision_baton, apr_pool_t *pool) {
  return _obj->new_node_record(node_baton, headers, revision_baton, pool);
}

static svn_error_t *svn_repos_parse_fns2_invoke_set_revision_property(
  svn_repos_parse_fns2_t *_obj, void *revision_baton, const char *name, const svn_string_t *value) {
  return _obj->set_revision_property(revision_baton, name, value);
}

static svn_error_t *svn_repos_parse_fns2_invoke_set_node_property(
  svn_repos_parse_fns2_t *_obj, void *node_baton, const char *name, const svn_string_t *value) {
  return _obj->set_node_property(node_baton, name, value);
}

static svn_error_t *svn_repos_parse_fns2_invoke_delete_node_property(
  svn_repos_parse_fns2_t *_obj, void *node_baton, const char *name) {
  return _obj->delete_node_property(node_baton, name);
}

static svn_error_t *svn_repos_parse_fns2_invoke_remove_node_props(
  svn_repos_parse_fns2_t *_obj, void *node_baton) {
  return _obj->remove_node_props(node_baton);
}

static svn_error_t *svn_repos_parse_fns2_invoke_set_fulltext(
  svn_repos_parse_fns2_t *_obj, svn_stream_t **stream, void *node_baton) {
  return _obj->set_fulltext(stream, node_baton);
}

static svn_error_t *svn_repos_parse_fns2_invoke_apply_textdelta(
  svn_repos_parse_fns2_t *_obj, svn_txdelta_window_handler_t *handler, void **handler_baton, void *node_baton) {
  return _obj->apply_textdelta(handler, handler_baton, node_baton);
}

static svn_error_t *svn_repos_parse_fns2_invoke_close_node(
  svn_repos_parse_fns2_t *_obj, void *node_baton) {
  return _obj->close_node(node_baton);
}

static svn_error_t *svn_repos_parse_fns2_invoke_close_revision(
  svn_repos_parse_fns2_t *_obj, void *revision_baton) {
  return _obj->close_revision(revision_baton);
}



static svn_fs_t *
svn_repos_fs_wrapper(svn_repos_t *fs, apr_pool_t *pool)
{
  return svn_repos_fs(fs);
}

static VALUE
_wrap_svn_repos_version(int argc, VALUE *argv, VALUE self) {
    svn_version_t *result;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_version_t *)svn_repos_version();
        
        
        
        
    }
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_version_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_find_root_path(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    arg1 = StringValuePtr(argv[0]);
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_find_root_path((char const *)arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_open(int argc, VALUE *argv, VALUE self) {
    svn_repos_t **arg1 = (svn_repos_t **) 0 ;
    char *arg2 = (char *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_repos_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_repos_t **)&temp1;
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    arg2 = StringValuePtr(argv[0]);
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_repos_open(arg1,(char const *)arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_repos_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_create(int argc, VALUE *argv, VALUE self) {
    svn_repos_t **arg1 = (svn_repos_t **) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    char *arg4 = (char *) 0 ;
    apr_hash_t *arg5 = (apr_hash_t *) 0 ;
    apr_hash_t *arg6 = (apr_hash_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_repos_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_repos_t **)&temp1;
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        if (NIL_P(argv[1])) {
            arg3 = NULL;
        } else {
            arg3 = StringValuePtr(argv[1]);
        }
    }
    {
        if (NIL_P(argv[2])) {
            arg4 = NULL;
        } else {
            arg4 = StringValuePtr(argv[2]);
        }
    }
    {
        if (NIL_P(argv[3])) {
            arg5 = NULL;
        } else {
            arg5 = svn_swig_rb_hash_to_apr_hash_swig_type(argv[3], "svn_config_t *", _global_pool);
        }
    }
    {
        arg6 = svn_swig_rb_hash_to_apr_hash_string(argv[4], _global_pool);
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_repos_create(arg1,(char const *)arg2,(char const *)arg3,(char const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_repos_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_delete(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    arg1 = StringValuePtr(argv[0]);
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_repos_delete((char const *)arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_hotcopy(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_boolean_t arg3 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg1 = StringValuePtr(argv[0]);
    arg2 = StringValuePtr(argv[1]);
    arg3 = RTEST(argv[2]);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_repos_hotcopy((char const *)arg1,(char const *)arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_recover(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    arg1 = StringValuePtr(argv[0]);
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_repos_recover((char const *)arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_recover2(int argc, VALUE *argv, VALUE self) {
    char *arg1 = (char *) 0 ;
    svn_boolean_t arg2 ;
    svn_error_t *(*arg3)(void *) = (svn_error_t *(*)(void *)) 0 ;
    void *arg4 = (void *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg1 = StringValuePtr(argv[0]);
    arg2 = RTEST(argv[1]);
    {
        SWIG_ConvertPtr(argv[2], &temp3, SWIGTYPE_p_f_p_void__p_svn_error_t, 1);
        
        
        
        arg3 = (svn_error_t *(*)(void *))temp3;
    }
    SWIG_ConvertPtr(argv[3], (void **) &arg4, 0, 1);
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_repos_recover2((char const *)arg1,arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_db_logfiles(int argc, VALUE *argv, VALUE self) {
    apr_array_header_t **arg1 = (apr_array_header_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_boolean_t arg3 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_array_header_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        arg1 = &temp1;
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = RTEST(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_repos_db_logfiles(arg1,(char const *)arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, svn_swig_rb_apr_array_to_array_string(*arg1));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_path(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_path(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_db_env(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_db_env(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_conf_dir(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_conf_dir(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_svnserve_conf(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_svnserve_conf(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_lock_dir(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_lock_dir(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_db_lockfile(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_db_lockfile(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_db_logs_lockfile(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_db_logs_lockfile(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_hook_dir(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_hook_dir(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_start_commit_hook(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_start_commit_hook(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_pre_commit_hook(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_pre_commit_hook(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_post_commit_hook(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_post_commit_hook(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_pre_revprop_change_hook(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_pre_revprop_change_hook(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_post_revprop_change_hook(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_post_revprop_change_hook(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_pre_lock_hook(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_pre_lock_hook(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_post_lock_hook(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_post_lock_hook(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_pre_unlock_hook(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_pre_unlock_hook(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_post_unlock_hook(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    char *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (char *)svn_repos_post_unlock_hook(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_begin_report(int argc, VALUE *argv, VALUE self) {
    void **arg1 = (void **) 0 ;
    svn_revnum_t arg2 ;
    char *arg3 = (char *) 0 ;
    svn_repos_t *arg4 = (svn_repos_t *) 0 ;
    char *arg5 = (char *) 0 ;
    char *arg6 = (char *) 0 ;
    char *arg7 = (char *) 0 ;
    svn_boolean_t arg8 ;
    svn_boolean_t arg9 ;
    svn_boolean_t arg10 ;
    svn_delta_editor_t *arg11 = (svn_delta_editor_t *) 0 ;
    void *arg12 = (void *) 0 ;
    svn_repos_authz_func_t arg13 = (svn_repos_authz_func_t) 0 ;
    void *arg14 = (void *) 0 ;
    apr_pool_t *arg15 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg15);
        _global_pool = arg15;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (void **)&temp1;
    }
    if ((argc < 11) || (argc > 12))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 11)",argc);
    arg2 = NUM2LONG(argv[0]);
    arg3 = StringValuePtr(argv[1]);
    {
        SWIG_ConvertPtr(argv[2], &temp4, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg4 = (svn_repos_t *)temp4;
    }
    arg5 = StringValuePtr(argv[3]);
    arg6 = StringValuePtr(argv[4]);
    {
        if (NIL_P(argv[5])) {
            arg7 = NULL;
        } else {
            arg7 = StringValuePtr(argv[5]);
        }
    }
    arg8 = RTEST(argv[6]);
    arg9 = RTEST(argv[7]);
    arg10 = RTEST(argv[8]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[9],
        svn_swig_rb_svn_delta_editor()))) {
            arg11 = svn_swig_rb_to_swig_type(argv[9],
            "svn_delta_editor_t *",
            _global_pool);
            arg12 = svn_swig_rb_to_swig_type(rb_funcall(argv[9], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg11, &arg12, argv[9], _global_pool);
        }
    }
    {
        arg13 = svn_swig_rb_repos_authz_func;
        arg14 = (void *)svn_swig_rb_make_baton(argv[10], _global_svn_swig_rb_pool);
    }
    if (argc > 11) {
        
    }
    {
        result = (svn_error_t *)svn_repos_begin_report(arg1,arg2,(char const *)arg3,arg4,(char const *)arg5,(char const *)arg6,(char const *)arg7,arg8,arg9,arg10,(struct svn_delta_editor_t const *)arg11,arg12,arg13,arg14,arg15);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_set_path2(int argc, VALUE *argv, VALUE self) {
    void *arg1 = (void *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_revnum_t arg3 ;
    svn_boolean_t arg4 ;
    char *arg5 = (char *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    SWIG_ConvertPtr(argv[0], (void **) &arg1, 0, 1);
    arg2 = StringValuePtr(argv[1]);
    arg3 = NUM2LONG(argv[2]);
    arg4 = RTEST(argv[3]);
    {
        if (NIL_P(argv[4])) {
            arg5 = NULL;
        } else {
            arg5 = StringValuePtr(argv[4]);
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_repos_set_path2(arg1,(char const *)arg2,arg3,arg4,(char const *)arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_set_path(int argc, VALUE *argv, VALUE self) {
    void *arg1 = (void *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_revnum_t arg3 ;
    svn_boolean_t arg4 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    SWIG_ConvertPtr(argv[0], (void **) &arg1, 0, 1);
    arg2 = StringValuePtr(argv[1]);
    arg3 = NUM2LONG(argv[2]);
    arg4 = RTEST(argv[3]);
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_repos_set_path(arg1,(char const *)arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_link_path2(int argc, VALUE *argv, VALUE self) {
    void *arg1 = (void *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_revnum_t arg4 ;
    svn_boolean_t arg5 ;
    char *arg6 = (char *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    SWIG_ConvertPtr(argv[0], (void **) &arg1, 0, 1);
    arg2 = StringValuePtr(argv[1]);
    arg3 = StringValuePtr(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    arg5 = RTEST(argv[4]);
    {
        if (NIL_P(argv[5])) {
            arg6 = NULL;
        } else {
            arg6 = StringValuePtr(argv[5]);
        }
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_repos_link_path2(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,(char const *)arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_link_path(int argc, VALUE *argv, VALUE self) {
    void *arg1 = (void *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_revnum_t arg4 ;
    svn_boolean_t arg5 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    SWIG_ConvertPtr(argv[0], (void **) &arg1, 0, 1);
    arg2 = StringValuePtr(argv[1]);
    arg3 = StringValuePtr(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    arg5 = RTEST(argv[4]);
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_repos_link_path(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_delete_path(int argc, VALUE *argv, VALUE self) {
    void *arg1 = (void *) 0 ;
    char *arg2 = (char *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    SWIG_ConvertPtr(argv[0], (void **) &arg1, 0, 1);
    arg2 = StringValuePtr(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_repos_delete_path(arg1,(char const *)arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_finish_report(int argc, VALUE *argv, VALUE self) {
    void *arg1 = (void *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    SWIG_ConvertPtr(argv[0], (void **) &arg1, 0, 1);
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_repos_finish_report(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_abort_report(int argc, VALUE *argv, VALUE self) {
    void *arg1 = (void *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    SWIG_ConvertPtr(argv[0], (void **) &arg1, 0, 1);
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_repos_abort_report(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_dir_delta(int argc, VALUE *argv, VALUE self) {
    svn_fs_root_t *arg1 = (svn_fs_root_t *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_fs_root_t *arg4 = (svn_fs_root_t *) 0 ;
    char *arg5 = (char *) 0 ;
    svn_delta_editor_t *arg6 = (svn_delta_editor_t *) 0 ;
    void *arg7 = (void *) 0 ;
    svn_repos_authz_func_t arg8 = (svn_repos_authz_func_t) 0 ;
    void *arg9 = (void *) 0 ;
    svn_boolean_t arg10 ;
    svn_boolean_t arg11 ;
    svn_boolean_t arg12 ;
    svn_boolean_t arg13 ;
    apr_pool_t *arg14 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg14);
        _global_pool = arg14;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 11) || (argc > 12))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 11)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_fs_root_t, 1);
        
        
        
        arg1 = (svn_fs_root_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    {
        if (NIL_P(argv[2])) {
            arg3 = NULL;
        } else {
            arg3 = StringValuePtr(argv[2]);
        }
    }
    {
        SWIG_ConvertPtr(argv[3], &temp4, SWIGTYPE_p_svn_fs_root_t, 1);
        
        
        
        arg4 = (svn_fs_root_t *)temp4;
    }
    {
        if (NIL_P(argv[4])) {
            arg5 = NULL;
        } else {
            arg5 = StringValuePtr(argv[4]);
        }
    }
    {
        if (RTEST(rb_obj_is_kind_of(argv[5],
        svn_swig_rb_svn_delta_editor()))) {
            arg6 = svn_swig_rb_to_swig_type(argv[5],
            "svn_delta_editor_t *",
            _global_pool);
            arg7 = svn_swig_rb_to_swig_type(rb_funcall(argv[5], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg6, &arg7, argv[5], _global_pool);
        }
    }
    {
        arg8 = svn_swig_rb_repos_authz_func;
        arg9 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    arg10 = RTEST(argv[7]);
    arg11 = RTEST(argv[8]);
    arg12 = RTEST(argv[9]);
    arg13 = RTEST(argv[10]);
    if (argc > 11) {
        
    }
    {
        result = (svn_error_t *)svn_repos_dir_delta(arg1,(char const *)arg2,(char const *)arg3,arg4,(char const *)arg5,(struct svn_delta_editor_t const *)arg6,arg7,arg8,arg9,arg10,arg11,arg12,arg13,arg14);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_replay2(int argc, VALUE *argv, VALUE self) {
    svn_fs_root_t *arg1 = (svn_fs_root_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_revnum_t arg3 ;
    svn_boolean_t arg4 ;
    svn_delta_editor_t *arg5 = (svn_delta_editor_t *) 0 ;
    void *arg6 = (void *) 0 ;
    svn_repos_authz_func_t arg7 = (svn_repos_authz_func_t) 0 ;
    void *arg8 = (void *) 0 ;
    apr_pool_t *arg9 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg9);
        _global_pool = arg9;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_fs_root_t, 1);
        
        
        
        arg1 = (svn_fs_root_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    arg3 = NUM2LONG(argv[2]);
    arg4 = RTEST(argv[3]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[4],
        svn_swig_rb_svn_delta_editor()))) {
            arg5 = svn_swig_rb_to_swig_type(argv[4],
            "svn_delta_editor_t *",
            _global_pool);
            arg6 = svn_swig_rb_to_swig_type(rb_funcall(argv[4], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg5, &arg6, argv[4], _global_pool);
        }
    }
    {
        arg7 = svn_swig_rb_repos_authz_func;
        arg8 = (void *)svn_swig_rb_make_baton(argv[5], _global_svn_swig_rb_pool);
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_repos_replay2(arg1,(char const *)arg2,arg3,arg4,(struct svn_delta_editor_t const *)arg5,arg6,arg7,arg8,arg9);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_replay(int argc, VALUE *argv, VALUE self) {
    svn_fs_root_t *arg1 = (svn_fs_root_t *) 0 ;
    svn_delta_editor_t *arg2 = (svn_delta_editor_t *) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_fs_root_t, 1);
        
        
        
        arg1 = (svn_fs_root_t *)temp1;
    }
    {
        if (RTEST(rb_obj_is_kind_of(argv[1],
        svn_swig_rb_svn_delta_editor()))) {
            arg2 = svn_swig_rb_to_swig_type(argv[1],
            "svn_delta_editor_t *",
            _global_pool);
            arg3 = svn_swig_rb_to_swig_type(rb_funcall(argv[1], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg2, &arg3, argv[1], _global_pool);
        }
    }
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_repos_replay(arg1,(struct svn_delta_editor_t const *)arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_get_commit_editor4(int argc, VALUE *argv, VALUE self) {
    svn_delta_editor_t **arg1 = (svn_delta_editor_t **) 0 ;
    void **arg2 = (void **) 0 ;
    svn_repos_t *arg3 = (svn_repos_t *) 0 ;
    svn_fs_txn_t *arg4 = (svn_fs_txn_t *) 0 ;
    char *arg5 = (char *) 0 ;
    char *arg6 = (char *) 0 ;
    char *arg7 = (char *) 0 ;
    char *arg8 = (char *) 0 ;
    svn_commit_callback2_t arg9 = (svn_commit_callback2_t) 0 ;
    void *arg10 = (void *) 0 ;
    svn_repos_authz_callback_t arg11 = (svn_repos_authz_callback_t) 0 ;
    void *arg12 = (void *) 0 ;
    apr_pool_t *arg13 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_delta_editor_t const *temp1 ;
    void *temp2 ;
    void *temp3 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg13);
        _global_pool = arg13;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_delta_editor_t **)&temp1;
    }
    {
        temp2 = NULL;
        arg2 = (void **)&temp2;
    }
    if ((argc < 8) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp3, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg3 = (svn_repos_t *)temp3;
    }
    {
        SWIG_ConvertPtr(argv[1], &temp4, SWIGTYPE_p_svn_fs_txn_t, 1);
        
        
        
        arg4 = (svn_fs_txn_t *)temp4;
    }
    arg5 = StringValuePtr(argv[2]);
    arg6 = StringValuePtr(argv[3]);
    {
        if (NIL_P(argv[4])) {
            arg7 = NULL;
        } else {
            arg7 = StringValuePtr(argv[4]);
        }
    }
    {
        if (NIL_P(argv[5])) {
            arg8 = NULL;
        } else {
            arg8 = StringValuePtr(argv[5]);
        }
    }
    {
        arg9 = svn_swig_rb_commit_callback2;
        arg10 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    {
        arg11 = svn_swig_rb_repos_authz_callback;
        arg12 = (void *)svn_swig_rb_make_baton(argv[7], _global_svn_swig_rb_pool);
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_repos_get_commit_editor4((struct svn_delta_editor_t const **)arg1,arg2,arg3,arg4,(char const *)arg5,(char const *)arg6,(char const *)arg7,(char const *)arg8,arg9,arg10,arg11,arg12,arg13);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_delta_editor_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg10);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_get_commit_editor3(int argc, VALUE *argv, VALUE self) {
    svn_delta_editor_t **arg1 = (svn_delta_editor_t **) 0 ;
    void **arg2 = (void **) 0 ;
    svn_repos_t *arg3 = (svn_repos_t *) 0 ;
    svn_fs_txn_t *arg4 = (svn_fs_txn_t *) 0 ;
    char *arg5 = (char *) 0 ;
    char *arg6 = (char *) 0 ;
    char *arg7 = (char *) 0 ;
    char *arg8 = (char *) 0 ;
    svn_commit_callback_t arg9 = (svn_commit_callback_t) 0 ;
    void *arg10 = (void *) 0 ;
    svn_repos_authz_callback_t arg11 = (svn_repos_authz_callback_t) 0 ;
    void *arg12 = (void *) 0 ;
    apr_pool_t *arg13 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_delta_editor_t const *temp1 ;
    void *temp2 ;
    void *temp3 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg13);
        _global_pool = arg13;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_delta_editor_t **)&temp1;
    }
    {
        temp2 = NULL;
        arg2 = (void **)&temp2;
    }
    if ((argc < 8) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp3, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg3 = (svn_repos_t *)temp3;
    }
    {
        SWIG_ConvertPtr(argv[1], &temp4, SWIGTYPE_p_svn_fs_txn_t, 1);
        
        
        
        arg4 = (svn_fs_txn_t *)temp4;
    }
    arg5 = StringValuePtr(argv[2]);
    arg6 = StringValuePtr(argv[3]);
    {
        if (NIL_P(argv[4])) {
            arg7 = NULL;
        } else {
            arg7 = StringValuePtr(argv[4]);
        }
    }
    {
        if (NIL_P(argv[5])) {
            arg8 = NULL;
        } else {
            arg8 = StringValuePtr(argv[5]);
        }
    }
    {
        arg9 = svn_swig_rb_commit_callback;
        arg10 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    {
        arg11 = svn_swig_rb_repos_authz_callback;
        arg12 = (void *)svn_swig_rb_make_baton(argv[7], _global_svn_swig_rb_pool);
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_repos_get_commit_editor3((struct svn_delta_editor_t const **)arg1,arg2,arg3,arg4,(char const *)arg5,(char const *)arg6,(char const *)arg7,(char const *)arg8,arg9,arg10,arg11,arg12,arg13);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_delta_editor_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg10);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_get_commit_editor2(int argc, VALUE *argv, VALUE self) {
    svn_delta_editor_t **arg1 = (svn_delta_editor_t **) 0 ;
    void **arg2 = (void **) 0 ;
    svn_repos_t *arg3 = (svn_repos_t *) 0 ;
    svn_fs_txn_t *arg4 = (svn_fs_txn_t *) 0 ;
    char *arg5 = (char *) 0 ;
    char *arg6 = (char *) 0 ;
    char *arg7 = (char *) 0 ;
    char *arg8 = (char *) 0 ;
    svn_commit_callback_t arg9 = (svn_commit_callback_t) 0 ;
    void *arg10 = (void *) 0 ;
    apr_pool_t *arg11 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_delta_editor_t const *temp1 ;
    void *temp2 ;
    void *temp3 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg11);
        _global_pool = arg11;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_delta_editor_t **)&temp1;
    }
    {
        temp2 = NULL;
        arg2 = (void **)&temp2;
    }
    if ((argc < 7) || (argc > 8))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp3, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg3 = (svn_repos_t *)temp3;
    }
    {
        SWIG_ConvertPtr(argv[1], &temp4, SWIGTYPE_p_svn_fs_txn_t, 1);
        
        
        
        arg4 = (svn_fs_txn_t *)temp4;
    }
    arg5 = StringValuePtr(argv[2]);
    arg6 = StringValuePtr(argv[3]);
    {
        if (NIL_P(argv[4])) {
            arg7 = NULL;
        } else {
            arg7 = StringValuePtr(argv[4]);
        }
    }
    {
        if (NIL_P(argv[5])) {
            arg8 = NULL;
        } else {
            arg8 = StringValuePtr(argv[5]);
        }
    }
    {
        arg9 = svn_swig_rb_commit_callback;
        arg10 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    if (argc > 7) {
        
    }
    {
        result = (svn_error_t *)svn_repos_get_commit_editor2((struct svn_delta_editor_t const **)arg1,arg2,arg3,arg4,(char const *)arg5,(char const *)arg6,(char const *)arg7,(char const *)arg8,arg9,arg10,arg11);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_delta_editor_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg10);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_get_commit_editor(int argc, VALUE *argv, VALUE self) {
    svn_delta_editor_t **arg1 = (svn_delta_editor_t **) 0 ;
    void **arg2 = (void **) 0 ;
    svn_repos_t *arg3 = (svn_repos_t *) 0 ;
    char *arg4 = (char *) 0 ;
    char *arg5 = (char *) 0 ;
    char *arg6 = (char *) 0 ;
    char *arg7 = (char *) 0 ;
    svn_commit_callback_t arg8 = (svn_commit_callback_t) 0 ;
    void *arg9 = (void *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_delta_editor_t const *temp1 ;
    void *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_delta_editor_t **)&temp1;
    }
    {
        temp2 = NULL;
        arg2 = (void **)&temp2;
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp3, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg3 = (svn_repos_t *)temp3;
    }
    arg4 = StringValuePtr(argv[1]);
    arg5 = StringValuePtr(argv[2]);
    {
        if (NIL_P(argv[3])) {
            arg6 = NULL;
        } else {
            arg6 = StringValuePtr(argv[3]);
        }
    }
    {
        if (NIL_P(argv[4])) {
            arg7 = NULL;
        } else {
            arg7 = StringValuePtr(argv[4]);
        }
    }
    {
        arg8 = svn_swig_rb_commit_callback;
        arg9 = (void *)svn_swig_rb_make_baton(argv[5], _global_svn_swig_rb_pool);
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_repos_get_commit_editor((struct svn_delta_editor_t const **)arg1,arg2,arg3,(char const *)arg4,(char const *)arg5,(char const *)arg6,(char const *)arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_delta_editor_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg9);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_dated_revision(int argc, VALUE *argv, VALUE self) {
    svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
    svn_repos_t *arg2 = (svn_repos_t *) 0 ;
    apr_time_t arg3 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_revnum_t temp1 ;
    void *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg2 = (svn_repos_t *)temp2;
    }
    arg3 = (apr_time_t) NUM2LL(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_repos_dated_revision(arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg1));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_get_committed_info(int argc, VALUE *argv, VALUE self) {
    svn_revnum_t *arg1 = (svn_revnum_t *) 0 ;
    char **arg2 = (char **) 0 ;
    char **arg3 = (char **) 0 ;
    svn_fs_root_t *arg4 = (svn_fs_root_t *) 0 ;
    char *arg5 = (char *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_revnum_t temp1 ;
    char const *temp2 = NULL ;
    char const *temp3 = NULL ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    arg2 = (char **)&temp2;
    arg3 = (char **)&temp3;
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp4, SWIGTYPE_p_svn_fs_root_t, 1);
        
        
        
        arg4 = (svn_fs_root_t *)temp4;
    }
    arg5 = StringValuePtr(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_repos_get_committed_info(arg1,(char const **)arg2,(char const **)arg3,arg4,(char const *)arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg1));
        vresult = output_helper(vresult, o);
    }
    {
        if (*arg2) {
            vresult = output_helper(vresult, rb_str_new2(*arg2));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        if (*arg3) {
            vresult = output_helper(vresult, rb_str_new2(*arg3));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_stat(int argc, VALUE *argv, VALUE self) {
    svn_dirent_t **arg1 = (svn_dirent_t **) 0 ;
    svn_fs_root_t *arg2 = (svn_fs_root_t *) 0 ;
    char *arg3 = (char *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_dirent_t *temp1 ;
    void *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_dirent_t **)&temp1;
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_fs_root_t, 1);
        
        
        
        arg2 = (svn_fs_root_t *)temp2;
    }
    arg3 = StringValuePtr(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_repos_stat(arg1,arg2,(char const *)arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_dirent_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_history2(int argc, VALUE *argv, VALUE self) {
    svn_fs_t *arg1 = (svn_fs_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_repos_history_func_t arg3 = (svn_repos_history_func_t) 0 ;
    void *arg4 = (void *) 0 ;
    svn_repos_authz_func_t arg5 = (svn_repos_authz_func_t) 0 ;
    void *arg6 = (void *) 0 ;
    svn_revnum_t arg7 ;
    svn_revnum_t arg8 ;
    svn_boolean_t arg9 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 7) || (argc > 8))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_fs_t, 1);
        
        
        
        arg1 = (svn_fs_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    {
        arg3 = svn_swig_rb_repos_history_func;
        arg4 = (void *)svn_swig_rb_make_baton(argv[2], _global_svn_swig_rb_pool);
    }
    {
        arg5 = svn_swig_rb_repos_authz_func;
        arg6 = (void *)svn_swig_rb_make_baton(argv[3], _global_svn_swig_rb_pool);
    }
    arg7 = NUM2LONG(argv[4]);
    arg8 = NUM2LONG(argv[5]);
    arg9 = RTEST(argv[6]);
    if (argc > 7) {
        
    }
    {
        result = (svn_error_t *)svn_repos_history2(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_history(int argc, VALUE *argv, VALUE self) {
    svn_fs_t *arg1 = (svn_fs_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_repos_history_func_t arg3 = (svn_repos_history_func_t) 0 ;
    void *arg4 = (void *) 0 ;
    svn_revnum_t arg5 ;
    svn_revnum_t arg6 ;
    svn_boolean_t arg7 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_fs_t, 1);
        
        
        
        arg1 = (svn_fs_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    {
        arg3 = svn_swig_rb_repos_history_func;
        arg4 = (void *)svn_swig_rb_make_baton(argv[2], _global_svn_swig_rb_pool);
    }
    arg5 = NUM2LONG(argv[3]);
    arg6 = NUM2LONG(argv[4]);
    arg7 = RTEST(argv[5]);
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_repos_history(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_trace_node_locations(int argc, VALUE *argv, VALUE self) {
    svn_fs_t *arg1 = (svn_fs_t *) 0 ;
    apr_hash_t **arg2 = (apr_hash_t **) 0 ;
    char *arg3 = (char *) 0 ;
    svn_revnum_t arg4 ;
    apr_array_header_t *arg5 = (apr_array_header_t *) 0 ;
    svn_repos_authz_func_t arg6 = (svn_repos_authz_func_t) 0 ;
    void *arg7 = (void *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    apr_hash_t *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg2 = &temp2;
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_fs_t, 1);
        
        
        
        arg1 = (svn_fs_t *)temp1;
    }
    arg3 = StringValuePtr(argv[1]);
    arg4 = NUM2LONG(argv[2]);
    {
        arg5 = svn_swig_rb_array_to_apr_array_revnum(argv[3], _global_pool);
    }
    {
        arg6 = svn_swig_rb_repos_authz_func;
        arg7 = (void *)svn_swig_rb_make_baton(argv[4], _global_svn_swig_rb_pool);
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_repos_trace_node_locations(arg1,arg2,(char const *)arg3,arg4,arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = svn_swig_rb_apr_revnum_key_hash_to_hash_string(*arg2);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_get_logs3(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_revnum_t arg3 ;
    svn_revnum_t arg4 ;
    int arg5 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_repos_authz_func_t arg8 = (svn_repos_authz_func_t) 0 ;
    void *arg9 = (void *) 0 ;
    svn_log_message_receiver_t arg10 = (svn_log_message_receiver_t) 0 ;
    void *arg11 = (void *) 0 ;
    apr_pool_t *arg12 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg12);
        _global_pool = arg12;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 9) || (argc > 10))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 9)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[1], _global_pool);
    }
    arg3 = NUM2LONG(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    arg5 = NUM2INT(argv[4]);
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    {
        arg8 = svn_swig_rb_repos_authz_func;
        arg9 = (void *)svn_swig_rb_make_baton(argv[7], _global_svn_swig_rb_pool);
    }
    {
        arg10 = svn_swig_rb_log_receiver;
        arg11 = (void *)svn_swig_rb_make_baton(argv[8], _global_svn_swig_rb_pool);
    }
    if (argc > 9) {
        
    }
    {
        result = (svn_error_t *)svn_repos_get_logs3(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10,arg11,arg12);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_get_logs2(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_revnum_t arg3 ;
    svn_revnum_t arg4 ;
    svn_boolean_t arg5 ;
    svn_boolean_t arg6 ;
    svn_repos_authz_func_t arg7 = (svn_repos_authz_func_t) 0 ;
    void *arg8 = (void *) 0 ;
    svn_log_message_receiver_t arg9 = (svn_log_message_receiver_t) 0 ;
    void *arg10 = (void *) 0 ;
    apr_pool_t *arg11 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg11);
        _global_pool = arg11;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 8) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[1], _global_pool);
    }
    arg3 = NUM2LONG(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    arg5 = RTEST(argv[4]);
    arg6 = RTEST(argv[5]);
    {
        arg7 = svn_swig_rb_repos_authz_func;
        arg8 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    {
        arg9 = svn_swig_rb_log_receiver;
        arg10 = (void *)svn_swig_rb_make_baton(argv[7], _global_svn_swig_rb_pool);
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_repos_get_logs2(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10,arg11);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_get_logs(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_revnum_t arg3 ;
    svn_revnum_t arg4 ;
    svn_boolean_t arg5 ;
    svn_boolean_t arg6 ;
    svn_log_message_receiver_t arg7 = (svn_log_message_receiver_t) 0 ;
    void *arg8 = (void *) 0 ;
    apr_pool_t *arg9 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg9);
        _global_pool = arg9;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 7) || (argc > 8))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[1], _global_pool);
    }
    arg3 = NUM2LONG(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    arg5 = RTEST(argv[4]);
    arg6 = RTEST(argv[5]);
    {
        arg7 = svn_swig_rb_log_receiver;
        arg8 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    if (argc > 7) {
        
    }
    {
        result = (svn_error_t *)svn_repos_get_logs(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_get_file_revs(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_revnum_t arg3 ;
    svn_revnum_t arg4 ;
    svn_repos_authz_func_t arg5 = (svn_repos_authz_func_t) 0 ;
    void *arg6 = (void *) 0 ;
    svn_repos_file_rev_handler_t arg7 = (svn_repos_file_rev_handler_t) 0 ;
    void *arg8 = (void *) 0 ;
    apr_pool_t *arg9 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg9);
        _global_pool = arg9;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    arg3 = NUM2LONG(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    {
        arg5 = svn_swig_rb_repos_authz_func;
        arg6 = (void *)svn_swig_rb_make_baton(argv[4], _global_svn_swig_rb_pool);
    }
    {
        arg7 = svn_swig_rb_repos_file_rev_handler;
        arg8 = (void *)svn_swig_rb_make_baton(argv[5], _global_svn_swig_rb_pool);
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_repos_get_file_revs(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_commit_txn(int argc, VALUE *argv, VALUE self) {
    char **arg1 = (char **) 0 ;
    svn_repos_t *arg2 = (svn_repos_t *) 0 ;
    svn_revnum_t *arg3 = (svn_revnum_t *) 0 ;
    svn_fs_txn_t *arg4 = (svn_fs_txn_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    char const *temp1 = NULL ;
    void *temp2 ;
    svn_revnum_t temp3 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = (char **)&temp1;
    arg3 = &temp3;
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg2 = (svn_repos_t *)temp2;
    }
    {
        SWIG_ConvertPtr(argv[1], &temp4, SWIGTYPE_p_svn_fs_txn_t, 1);
        
        
        
        arg4 = (svn_fs_txn_t *)temp4;
    }
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_commit_txn((char const **)arg1,arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg1) {
            vresult = output_helper(vresult, rb_str_new2(*arg1));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        VALUE o = INT2NUM((long) (*arg3));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_begin_txn_for_commit(int argc, VALUE *argv, VALUE self) {
    svn_fs_txn_t **arg1 = (svn_fs_txn_t **) 0 ;
    svn_repos_t *arg2 = (svn_repos_t *) 0 ;
    svn_revnum_t arg3 ;
    char *arg4 = (char *) 0 ;
    char *arg5 = (char *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_fs_txn_t *temp1 ;
    void *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_fs_txn_t **)&temp1;
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg2 = (svn_repos_t *)temp2;
    }
    arg3 = NUM2LONG(argv[1]);
    arg4 = StringValuePtr(argv[2]);
    {
        if (NIL_P(argv[3])) {
            arg5 = NULL;
        } else {
            arg5 = StringValuePtr(argv[3]);
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_begin_txn_for_commit(arg1,arg2,arg3,(char const *)arg4,(char const *)arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_fs_txn_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_begin_txn_for_update(int argc, VALUE *argv, VALUE self) {
    svn_fs_txn_t **arg1 = (svn_fs_txn_t **) 0 ;
    svn_repos_t *arg2 = (svn_repos_t *) 0 ;
    svn_revnum_t arg3 ;
    char *arg4 = (char *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_fs_txn_t *temp1 ;
    void *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_fs_txn_t **)&temp1;
    }
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg2 = (svn_repos_t *)temp2;
    }
    arg3 = NUM2LONG(argv[1]);
    arg4 = StringValuePtr(argv[2]);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_begin_txn_for_update(arg1,arg2,arg3,(char const *)arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_fs_txn_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_lock(int argc, VALUE *argv, VALUE self) {
    svn_lock_t **arg1 = (svn_lock_t **) 0 ;
    svn_repos_t *arg2 = (svn_repos_t *) 0 ;
    char *arg3 = (char *) 0 ;
    char *arg4 = (char *) 0 ;
    char *arg5 = (char *) 0 ;
    svn_boolean_t arg6 ;
    apr_time_t arg7 ;
    svn_revnum_t arg8 ;
    svn_boolean_t arg9 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_lock_t *temp1 ;
    void *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_lock_t **)&temp1;
    }
    if ((argc < 8) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg2 = (svn_repos_t *)temp2;
    }
    arg3 = StringValuePtr(argv[1]);
    {
        if (NIL_P(argv[2])) {
            arg4 = NULL;
        } else {
            arg4 = StringValuePtr(argv[2]);
        }
    }
    {
        if (NIL_P(argv[3])) {
            arg5 = NULL;
        } else {
            arg5 = StringValuePtr(argv[3]);
        }
    }
    arg6 = RTEST(argv[4]);
    arg7 = (apr_time_t) NUM2LL(argv[5]);
    arg8 = NUM2LONG(argv[6]);
    arg9 = RTEST(argv[7]);
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_lock(arg1,arg2,(char const *)arg3,(char const *)arg4,(char const *)arg5,arg6,arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_lock_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_unlock(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_boolean_t arg4 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    {
        if (NIL_P(argv[2])) {
            arg3 = NULL;
        } else {
            arg3 = StringValuePtr(argv[2]);
        }
    }
    arg4 = RTEST(argv[3]);
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_unlock(arg1,(char const *)arg2,(char const *)arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_get_locks(int argc, VALUE *argv, VALUE self) {
    apr_hash_t **arg1 = (apr_hash_t **) 0 ;
    svn_repos_t *arg2 = (svn_repos_t *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_repos_authz_func_t arg4 = (svn_repos_authz_func_t) 0 ;
    void *arg5 = (void *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_hash_t *temp1 ;
    void *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg2 = (svn_repos_t *)temp2;
    }
    arg3 = StringValuePtr(argv[1]);
    {
        arg4 = svn_swig_rb_repos_authz_func;
        arg5 = (void *)svn_swig_rb_make_baton(argv[2], _global_svn_swig_rb_pool);
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_get_locks(arg1,arg2,(char const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_swig_type
        (*arg1, "svn_lock_t *"));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_change_rev_prop2(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    svn_revnum_t arg2 ;
    char *arg3 = (char *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_string_t *arg5 = (svn_string_t *) 0 ;
    svn_repos_authz_func_t arg6 = (svn_repos_authz_func_t) 0 ;
    void *arg7 = (void *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_string_t value5 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    arg2 = NUM2LONG(argv[1]);
    arg3 = StringValuePtr(argv[2]);
    arg4 = StringValuePtr(argv[3]);
    {
        if (NIL_P(argv[4])) {
            arg5 = NULL;
        } else {
            value5.data = StringValuePtr(argv[4]);
            value5.len = RSTRING(argv[4])->len;
            arg5 = &value5;
        }
    }
    {
        arg6 = svn_swig_rb_repos_authz_func;
        arg7 = (void *)svn_swig_rb_make_baton(argv[5], _global_svn_swig_rb_pool);
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_change_rev_prop2(arg1,arg2,(char const *)arg3,(char const *)arg4,(struct svn_string_t const *)arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_change_rev_prop(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    svn_revnum_t arg2 ;
    char *arg3 = (char *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_string_t *arg5 = (svn_string_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_string_t value5 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    arg2 = NUM2LONG(argv[1]);
    arg3 = StringValuePtr(argv[2]);
    arg4 = StringValuePtr(argv[3]);
    {
        if (NIL_P(argv[4])) {
            arg5 = NULL;
        } else {
            value5.data = StringValuePtr(argv[4]);
            value5.len = RSTRING(argv[4])->len;
            arg5 = &value5;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_change_rev_prop(arg1,arg2,(char const *)arg3,(char const *)arg4,(struct svn_string_t const *)arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_revision_prop(int argc, VALUE *argv, VALUE self) {
    svn_string_t **arg1 = (svn_string_t **) 0 ;
    svn_repos_t *arg2 = (svn_repos_t *) 0 ;
    svn_revnum_t arg3 ;
    char *arg4 = (char *) 0 ;
    svn_repos_authz_func_t arg5 = (svn_repos_authz_func_t) 0 ;
    void *arg6 = (void *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_string_t *temp1 ;
    void *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        arg1 = &temp1;
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg2 = (svn_repos_t *)temp2;
    }
    arg3 = NUM2LONG(argv[1]);
    arg4 = StringValuePtr(argv[2]);
    {
        arg5 = svn_swig_rb_repos_authz_func;
        arg6 = (void *)svn_swig_rb_make_baton(argv[3], _global_svn_swig_rb_pool);
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_revision_prop(arg1,arg2,arg3,(char const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg1) {
            vresult = output_helper(vresult, rb_str_new((*arg1)->data, (*arg1)->len));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_revision_proplist(int argc, VALUE *argv, VALUE self) {
    apr_hash_t **arg1 = (apr_hash_t **) 0 ;
    svn_repos_t *arg2 = (svn_repos_t *) 0 ;
    svn_revnum_t arg3 ;
    svn_repos_authz_func_t arg4 = (svn_repos_authz_func_t) 0 ;
    void *arg5 = (void *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    apr_hash_t *temp1 ;
    void *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg1 = &temp1;
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg2 = (svn_repos_t *)temp2;
    }
    arg3 = NUM2LONG(argv[1]);
    {
        arg4 = svn_swig_rb_repos_authz_func;
        arg5 = (void *)svn_swig_rb_make_baton(argv[2], _global_svn_swig_rb_pool);
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_revision_proplist(arg1,arg2,arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_svn_string(*arg1));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_change_node_prop(int argc, VALUE *argv, VALUE self) {
    svn_fs_root_t *arg1 = (svn_fs_root_t *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_string_t *arg4 = (svn_string_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_string_t value4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_fs_root_t, 1);
        
        
        
        arg1 = (svn_fs_root_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    arg3 = StringValuePtr(argv[2]);
    {
        if (NIL_P(argv[3])) {
            arg4 = NULL;
        } else {
            value4.data = StringValuePtr(argv[3]);
            value4.len = RSTRING(argv[3])->len;
            arg4 = &value4;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_change_node_prop(arg1,(char const *)arg2,(char const *)arg3,(struct svn_string_t const *)arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_change_txn_prop(int argc, VALUE *argv, VALUE self) {
    svn_fs_txn_t *arg1 = (svn_fs_txn_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_string_t *arg3 = (svn_string_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_string_t value3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_fs_txn_t, 1);
        
        
        
        arg1 = (svn_fs_txn_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    {
        if (NIL_P(argv[2])) {
            arg3 = NULL;
        } else {
            value3.data = StringValuePtr(argv[2]);
            value3.len = RSTRING(argv[2])->len;
            arg3 = &value3;
        }
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_repos_fs_change_txn_prop(arg1,(char const *)arg2,(struct svn_string_t const *)arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


swig_class cSvn_repos_node_t;

static VALUE
_wrap_svn_repos_node_t_kind_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    svn_node_kind_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    arg2 = (svn_node_kind_t) NUM2INT(argv[0]);
    if (arg1) (arg1)->kind = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_node_t_kind_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    svn_node_kind_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    result = (svn_node_kind_t) ((arg1)->kind);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_repos_node_t_action_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    char arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    arg2 = NUM2CHR(argv[0]);
    if (arg1) (arg1)->action = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_node_t_action_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    char result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    result = (char) ((arg1)->action);
    
    vresult = rb_str_new(&result,1);
    return vresult;
}


static VALUE
_wrap_svn_repos_node_t_text_mod_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    svn_boolean_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    arg2 = RTEST(argv[0]);
    if (arg1) (arg1)->text_mod = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_node_t_text_mod_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    svn_boolean_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    result = (svn_boolean_t) ((arg1)->text_mod);
    
    {
        vresult = output_helper(vresult, result ? Qtrue : Qfalse);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_node_t_prop_mod_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    svn_boolean_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    arg2 = RTEST(argv[0]);
    if (arg1) (arg1)->prop_mod = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_node_t_prop_mod_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    svn_boolean_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    result = (svn_boolean_t) ((arg1)->prop_mod);
    
    {
        vresult = output_helper(vresult, result ? Qtrue : Qfalse);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_node_t_name_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->name) free((char *)arg1->name);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->name = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_repos_node_t_name_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    result = (char *) ((arg1)->name);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_node_t_copyfrom_rev_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    svn_revnum_t arg2 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    arg2 = NUM2LONG(argv[0]);
    if (arg1) (arg1)->copyfrom_rev = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_node_t_copyfrom_rev_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    svn_revnum_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    result = (svn_revnum_t) ((arg1)->copyfrom_rev);
    
    vresult = INT2NUM(result);
    return vresult;
}


static VALUE
_wrap_svn_repos_node_t_copyfrom_path_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    {
        if (NIL_P(argv[0])) {
            arg2 = NULL;
        } else {
            arg2 = StringValuePtr(argv[0]);
        }
    }
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->copyfrom_path) free((char *)arg1->copyfrom_path);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->copyfrom_path = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_repos_node_t_copyfrom_path_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    result = (char *) ((arg1)->copyfrom_path);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_node_t_sibling_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    struct svn_repos_node_t *arg2 = (struct svn_repos_node_t *) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg2 = (struct svn_repos_node_t *)temp2;
    }
    if (arg1) (arg1)->sibling = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_node_t_sibling_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    struct svn_repos_node_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    result = (struct svn_repos_node_t *) ((arg1)->sibling);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_repos_node_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_node_t_child_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    struct svn_repos_node_t *arg2 = (struct svn_repos_node_t *) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg2 = (struct svn_repos_node_t *)temp2;
    }
    if (arg1) (arg1)->child = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_node_t_child_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    struct svn_repos_node_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    result = (struct svn_repos_node_t *) ((arg1)->child);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_repos_node_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_node_t_parent_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    struct svn_repos_node_t *arg2 = (struct svn_repos_node_t *) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg2 = (struct svn_repos_node_t *)temp2;
    }
    if (arg1) (arg1)->parent = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_node_t_parent_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_node_t *arg1 = (svn_repos_node_t *) 0 ;
    struct svn_repos_node_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_node_t, 1);
        
        
        
        arg1 = (svn_repos_node_t *)temp1;
    }
    result = (struct svn_repos_node_t *) ((arg1)->parent);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_repos_node_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_node_editor(int argc, VALUE *argv, VALUE self) {
    svn_delta_editor_t **arg1 = (svn_delta_editor_t **) 0 ;
    void **arg2 = (void **) 0 ;
    svn_repos_t *arg3 = (svn_repos_t *) 0 ;
    svn_fs_root_t *arg4 = (svn_fs_root_t *) 0 ;
    svn_fs_root_t *arg5 = (svn_fs_root_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_delta_editor_t const *temp1 ;
    void *temp2 ;
    void *temp3 ;
    void *temp4 ;
    void *temp5 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_delta_editor_t **)&temp1;
    }
    {
        temp2 = NULL;
        arg2 = (void **)&temp2;
    }
    if ((argc < 3) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp3, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg3 = (svn_repos_t *)temp3;
    }
    {
        SWIG_ConvertPtr(argv[1], &temp4, SWIGTYPE_p_svn_fs_root_t, 1);
        
        
        
        arg4 = (svn_fs_root_t *)temp4;
    }
    {
        SWIG_ConvertPtr(argv[2], &temp5, SWIGTYPE_p_svn_fs_root_t, 1);
        
        
        
        arg5 = (svn_fs_root_t *)temp5;
    }
    if (argc > 3) {
        
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_repos_node_editor((struct svn_delta_editor_t const **)arg1,arg2,arg3,arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_delta_editor_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_node_from_baton(int argc, VALUE *argv, VALUE self) {
    void *arg1 = (void *) 0 ;
    svn_repos_node_t *result;
    VALUE vresult = Qnil;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    SWIG_ConvertPtr(argv[0], (void **) &arg1, 0, 1);
    {
        result = (svn_repos_node_t *)svn_repos_node_from_baton(arg1);
        
        
        
        
    }
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_repos_node_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_dump_fs2(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    svn_stream_t *arg2 = (svn_stream_t *) 0 ;
    svn_stream_t *arg3 = (svn_stream_t *) 0 ;
    svn_revnum_t arg4 ;
    svn_revnum_t arg5 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_cancel_func_t arg8 = (svn_cancel_func_t) 0 ;
    void *arg9 = (void *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 8) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_make_stream(argv[1]);
    }
    {
        arg3 = svn_swig_rb_make_stream(argv[2]);
    }
    arg4 = NUM2LONG(argv[3]);
    arg5 = NUM2LONG(argv[4]);
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    {
        arg8 = svn_swig_rb_cancel_func;
        arg9 = (void *)svn_swig_rb_make_baton(argv[7], _global_svn_swig_rb_pool);
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_repos_dump_fs2(arg1,arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg9);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_dump_fs(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    svn_stream_t *arg2 = (svn_stream_t *) 0 ;
    svn_stream_t *arg3 = (svn_stream_t *) 0 ;
    svn_revnum_t arg4 ;
    svn_revnum_t arg5 ;
    svn_boolean_t arg6 ;
    svn_cancel_func_t arg7 = (svn_cancel_func_t) 0 ;
    void *arg8 = (void *) 0 ;
    apr_pool_t *arg9 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg9);
        _global_pool = arg9;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 7) || (argc > 8))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_make_stream(argv[1]);
    }
    {
        arg3 = svn_swig_rb_make_stream(argv[2]);
    }
    arg4 = NUM2LONG(argv[3]);
    arg5 = NUM2LONG(argv[4]);
    arg6 = RTEST(argv[5]);
    {
        arg7 = svn_swig_rb_cancel_func;
        arg8 = (void *)svn_swig_rb_make_baton(argv[6], _global_svn_swig_rb_pool);
    }
    if (argc > 7) {
        
    }
    {
        result = (svn_error_t *)svn_repos_dump_fs(arg1,arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg8);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_load_fs2(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    svn_stream_t *arg2 = (svn_stream_t *) 0 ;
    svn_stream_t *arg3 = (svn_stream_t *) 0 ;
    enum svn_repos_load_uuid arg4 ;
    char *arg5 = (char *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_cancel_func_t arg8 = (svn_cancel_func_t) 0 ;
    void *arg9 = (void *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 8) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_make_stream(argv[1]);
    }
    {
        arg3 = svn_swig_rb_make_stream(argv[2]);
    }
    arg4 = (enum svn_repos_load_uuid) NUM2INT(argv[3]);
    {
        if (NIL_P(argv[4])) {
            arg5 = NULL;
        } else {
            arg5 = StringValuePtr(argv[4]);
        }
    }
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    {
        arg8 = svn_swig_rb_cancel_func;
        arg9 = (void *)svn_swig_rb_make_baton(argv[7], _global_svn_swig_rb_pool);
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_repos_load_fs2(arg1,arg2,arg3,arg4,(char const *)arg5,arg6,arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg9);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_load_fs(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    svn_stream_t *arg2 = (svn_stream_t *) 0 ;
    svn_stream_t *arg3 = (svn_stream_t *) 0 ;
    enum svn_repos_load_uuid arg4 ;
    char *arg5 = (char *) 0 ;
    svn_cancel_func_t arg6 = (svn_cancel_func_t) 0 ;
    void *arg7 = (void *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_make_stream(argv[1]);
    }
    {
        arg3 = svn_swig_rb_make_stream(argv[2]);
    }
    arg4 = (enum svn_repos_load_uuid) NUM2INT(argv[3]);
    {
        if (NIL_P(argv[4])) {
            arg5 = NULL;
        } else {
            arg5 = StringValuePtr(argv[4]);
        }
    }
    {
        arg6 = svn_swig_rb_cancel_func;
        arg7 = (void *)svn_swig_rb_make_baton(argv[5], _global_svn_swig_rb_pool);
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_repos_load_fs(arg1,arg2,arg3,arg4,(char const *)arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg7);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


swig_class cSvn_repos_parse_fns2_t;

static VALUE
_wrap_svn_repos_parse_fns2_t_new_revision_record_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*arg2)(void **,apr_hash_t *,void *,apr_pool_t *) = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->new_revision_record = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_new_revision_record_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*result)(void **,apr_hash_t *,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    result = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) ((arg1)->new_revision_record);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_uuid_record_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*arg2)(char const *,void *,apr_pool_t *) = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(char const *,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->uuid_record = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_uuid_record_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*result)(char const *,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    result = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) ((arg1)->uuid_record);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_new_node_record_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*arg2)(void **,apr_hash_t *,void *,apr_pool_t *) = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->new_node_record = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_new_node_record_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*result)(void **,apr_hash_t *,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    result = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) ((arg1)->new_node_record);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_set_revision_property_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_string_t const *) = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,svn_string_t const *))temp2;
    }
    if (arg1) (arg1)->set_revision_property = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_set_revision_property_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_string_t const *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) ((arg1)->set_revision_property);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_set_node_property_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_string_t const *) = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,svn_string_t const *))temp2;
    }
    if (arg1) (arg1)->set_node_property = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_set_node_property_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_string_t const *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) ((arg1)->set_node_property);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_delete_node_property_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *) = (svn_error_t *(*)(void *,char const *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *))temp2;
    }
    if (arg1) (arg1)->delete_node_property = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_delete_node_property_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*result)(void *,char const *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *)) ((arg1)->delete_node_property);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_remove_node_props_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *))temp2;
    }
    if (arg1) (arg1)->remove_node_props = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_remove_node_props_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*result)(void *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    result = (svn_error_t *(*)(void *)) ((arg1)->remove_node_props);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_set_fulltext_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*arg2)(svn_stream_t **,void *) = (svn_error_t *(*)(svn_stream_t **,void *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_p_svn_stream_t_p_void__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(svn_stream_t **,void *))temp2;
    }
    if (arg1) (arg1)->set_fulltext = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_set_fulltext_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*result)(svn_stream_t **,void *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    result = (svn_error_t *(*)(svn_stream_t **,void *)) ((arg1)->set_fulltext);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_p_svn_stream_t_p_void__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_apply_textdelta_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*arg2)(svn_txdelta_window_handler_t *,void **,void *) = (svn_error_t *(*)(svn_txdelta_window_handler_t *,void **,void *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(svn_txdelta_window_handler_t *,void **,void *))temp2;
    }
    if (arg1) (arg1)->apply_textdelta = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_apply_textdelta_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*result)(svn_txdelta_window_handler_t *,void **,void *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    result = (svn_error_t *(*)(svn_txdelta_window_handler_t *,void **,void *)) ((arg1)->apply_textdelta);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_close_node_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *))temp2;
    }
    if (arg1) (arg1)->close_node = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_close_node_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*result)(void *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    result = (svn_error_t *(*)(void *)) ((arg1)->close_node);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_close_revision_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *))temp2;
    }
    if (arg1) (arg1)->close_revision = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parse_fns2_t_close_revision_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_error_t *(*result)(void *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    result = (svn_error_t *(*)(void *)) ((arg1)->close_revision);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_dumpstream2(int argc, VALUE *argv, VALUE self) {
    svn_stream_t *arg1 = (svn_stream_t *) 0 ;
    svn_repos_parse_fns2_t *arg2 = (svn_repos_parse_fns2_t *) 0 ;
    void *arg3 = (void *) 0 ;
    svn_cancel_func_t arg4 = (svn_cancel_func_t) 0 ;
    void *arg5 = (void *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        arg1 = svn_swig_rb_make_stream(argv[0]);
    }
    {
        SWIG_ConvertPtr(argv[1], &temp2, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg2 = (svn_repos_parse_fns2_t *)temp2;
    }
    SWIG_ConvertPtr(argv[2], (void **) &arg3, 0, 1);
    {
        arg4 = svn_swig_rb_cancel_func;
        arg5 = (void *)svn_swig_rb_make_baton(argv[3], _global_svn_swig_rb_pool);
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_repos_parse_dumpstream2(arg1,(struct svn_repos_parse_fns2_t const *)arg2,arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg5);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_get_fs_build_parser2(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t **arg1 = (svn_repos_parse_fns2_t **) 0 ;
    void **arg2 = (void **) 0 ;
    svn_repos_t *arg3 = (svn_repos_t *) 0 ;
    svn_boolean_t arg4 ;
    enum svn_repos_load_uuid arg5 ;
    svn_stream_t *arg6 = (svn_stream_t *) 0 ;
    char *arg7 = (char *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    void *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (void **)&temp2;
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t **)temp1;
    }
    {
        SWIG_ConvertPtr(argv[1], &temp3, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg3 = (svn_repos_t *)temp3;
    }
    arg4 = RTEST(argv[2]);
    arg5 = (enum svn_repos_load_uuid) NUM2INT(argv[3]);
    {
        arg6 = svn_swig_rb_make_stream(argv[4]);
    }
    {
        if (NIL_P(argv[5])) {
            arg7 = NULL;
        } else {
            arg7 = StringValuePtr(argv[5]);
        }
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_repos_get_fs_build_parser2((struct svn_repos_parse_fns2_t const **)arg1,arg2,arg3,arg4,arg5,arg6,(char const *)arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


swig_class cSvn_repos_parser_fns_t;

static VALUE
_wrap_svn_repos_parser_fns_t_new_revision_record_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*arg2)(void **,apr_hash_t *,void *,apr_pool_t *) = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->new_revision_record = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parser_fns_t_new_revision_record_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*result)(void **,apr_hash_t *,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    result = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) ((arg1)->new_revision_record);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parser_fns_t_uuid_record_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*arg2)(char const *,void *,apr_pool_t *) = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(char const *,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->uuid_record = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parser_fns_t_uuid_record_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*result)(char const *,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    result = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) ((arg1)->uuid_record);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parser_fns_t_new_node_record_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*arg2)(void **,apr_hash_t *,void *,apr_pool_t *) = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->new_node_record = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parser_fns_t_new_node_record_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*result)(void **,apr_hash_t *,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    result = (svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)) ((arg1)->new_node_record);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parser_fns_t_set_revision_property_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_string_t const *) = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,svn_string_t const *))temp2;
    }
    if (arg1) (arg1)->set_revision_property = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parser_fns_t_set_revision_property_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_string_t const *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) ((arg1)->set_revision_property);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parser_fns_t_set_node_property_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_string_t const *) = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,svn_string_t const *))temp2;
    }
    if (arg1) (arg1)->set_node_property = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parser_fns_t_set_node_property_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_string_t const *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,svn_string_t const *)) ((arg1)->set_node_property);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parser_fns_t_remove_node_props_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *))temp2;
    }
    if (arg1) (arg1)->remove_node_props = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parser_fns_t_remove_node_props_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*result)(void *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    result = (svn_error_t *(*)(void *)) ((arg1)->remove_node_props);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parser_fns_t_set_fulltext_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*arg2)(svn_stream_t **,void *) = (svn_error_t *(*)(svn_stream_t **,void *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_p_svn_stream_t_p_void__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(svn_stream_t **,void *))temp2;
    }
    if (arg1) (arg1)->set_fulltext = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parser_fns_t_set_fulltext_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*result)(svn_stream_t **,void *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    result = (svn_error_t *(*)(svn_stream_t **,void *)) ((arg1)->set_fulltext);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_p_svn_stream_t_p_void__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parser_fns_t_close_node_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *))temp2;
    }
    if (arg1) (arg1)->close_node = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parser_fns_t_close_node_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*result)(void *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    result = (svn_error_t *(*)(void *)) ((arg1)->close_node);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parser_fns_t_close_revision_set(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*arg2)(void *) = (svn_error_t *(*)(void *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *))temp2;
    }
    if (arg1) (arg1)->close_revision = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_repos_parser_fns_t_close_revision_get(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t *arg1 = (svn_repos_parser_fns_t *) 0 ;
    svn_error_t *(*result)(void *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t *)temp1;
    }
    result = (svn_error_t *(*)(void *)) ((arg1)->close_revision);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_dumpstream(int argc, VALUE *argv, VALUE self) {
    svn_stream_t *arg1 = (svn_stream_t *) 0 ;
    svn_repos_parser_fns_t *arg2 = (svn_repos_parser_fns_t *) 0 ;
    void *arg3 = (void *) 0 ;
    svn_cancel_func_t arg4 = (svn_cancel_func_t) 0 ;
    void *arg5 = (void *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        arg1 = svn_swig_rb_make_stream(argv[0]);
    }
    {
        SWIG_ConvertPtr(argv[1], &temp2, SWIGTYPE_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg2 = (svn_repos_parser_fns_t *)temp2;
    }
    SWIG_ConvertPtr(argv[2], (void **) &arg3, 0, 1);
    {
        arg4 = svn_swig_rb_cancel_func;
        arg5 = (void *)svn_swig_rb_make_baton(argv[3], _global_svn_swig_rb_pool);
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_repos_parse_dumpstream(arg1,(struct svn_repos_parse_fns_t const *)arg2,arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg5);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_get_fs_build_parser(int argc, VALUE *argv, VALUE self) {
    svn_repos_parser_fns_t **arg1 = (svn_repos_parser_fns_t **) 0 ;
    void **arg2 = (void **) 0 ;
    svn_repos_t *arg3 = (svn_repos_t *) 0 ;
    svn_boolean_t arg4 ;
    enum svn_repos_load_uuid arg5 ;
    svn_stream_t *arg6 = (svn_stream_t *) 0 ;
    char *arg7 = (char *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    void *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (void **)&temp2;
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_p_svn_repos_parse_fns_t, 1);
        
        
        
        arg1 = (svn_repos_parser_fns_t **)temp1;
    }
    {
        SWIG_ConvertPtr(argv[1], &temp3, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg3 = (svn_repos_t *)temp3;
    }
    arg4 = RTEST(argv[2]);
    arg5 = (enum svn_repos_load_uuid) NUM2INT(argv[3]);
    {
        arg6 = svn_swig_rb_make_stream(argv[4]);
    }
    {
        if (NIL_P(argv[5])) {
            arg7 = NULL;
        } else {
            arg7 = StringValuePtr(argv[5]);
        }
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_repos_get_fs_build_parser((struct svn_repos_parse_fns_t const **)arg1,arg2,arg3,arg4,arg5,arg6,(char const *)arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_authz_read(int argc, VALUE *argv, VALUE self) {
    svn_authz_t **arg1 = (svn_authz_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_boolean_t arg3 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_authz_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_authz_t **)&temp1;
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    arg2 = StringValuePtr(argv[0]);
    arg3 = RTEST(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_repos_authz_read(arg1,(char const *)arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_authz_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_authz_check_access(int argc, VALUE *argv, VALUE self) {
    svn_authz_t *arg1 = (svn_authz_t *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_repos_authz_access_t arg5 ;
    svn_boolean_t *arg6 = (svn_boolean_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_boolean_t temp6 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        arg6 = &temp6;
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_authz_t, 1);
        
        
        
        arg1 = (svn_authz_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    arg3 = StringValuePtr(argv[2]);
    {
        if (NIL_P(argv[3])) {
            arg4 = NULL;
        } else {
            arg4 = StringValuePtr(argv[3]);
        }
    }
    arg5 = (svn_repos_authz_access_t) NUM2INT(argv[4]);
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_repos_authz_check_access(arg1,(char const *)arg2,(char const *)arg3,(char const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, *arg6 ? Qtrue : Qfalse);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_invoke_new_revision_record(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    void **arg2 = (void **) 0 ;
    apr_hash_t *arg3 = (apr_hash_t *) 0 ;
    void *arg4 = (void *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    void *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (void **)&temp2;
    }
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[1], &temp3, SWIGTYPE_p_apr_hash_t, 1);
        
        
        
        arg3 = (apr_hash_t *)temp3;
    }
    SWIG_ConvertPtr(argv[2], (void **) &arg4, 0, 1);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_repos_parse_fns2_invoke_new_revision_record(arg1,arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_invoke_uuid_record(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    SWIG_ConvertPtr(argv[2], (void **) &arg3, 0, 1);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_repos_parse_fns2_invoke_uuid_record(arg1,(char const *)arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_invoke_new_node_record(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    void **arg2 = (void **) 0 ;
    apr_hash_t *arg3 = (apr_hash_t *) 0 ;
    void *arg4 = (void *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    void *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (void **)&temp2;
    }
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[1], &temp3, SWIGTYPE_p_apr_hash_t, 1);
        
        
        
        arg3 = (apr_hash_t *)temp3;
    }
    SWIG_ConvertPtr(argv[2], (void **) &arg4, 0, 1);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_repos_parse_fns2_invoke_new_node_record(arg1,arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_invoke_set_revision_property(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_string_t *arg4 = (svn_string_t *) 0 ;
    svn_error_t *result;
    void *temp1 ;
    svn_string_t value4 ;
    VALUE vresult = Qnil;
    
    if ((argc < 4) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    {
        if (NIL_P(argv[3])) {
            arg4 = NULL;
        } else {
            value4.data = StringValuePtr(argv[3]);
            value4.len = RSTRING(argv[3])->len;
            arg4 = &value4;
        }
    }
    {
        result = (svn_error_t *)svn_repos_parse_fns2_invoke_set_revision_property(arg1,arg2,(char const *)arg3,(struct svn_string_t const *)arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_invoke_set_node_property(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_string_t *arg4 = (svn_string_t *) 0 ;
    svn_error_t *result;
    void *temp1 ;
    svn_string_t value4 ;
    VALUE vresult = Qnil;
    
    if ((argc < 4) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    {
        if (NIL_P(argv[3])) {
            arg4 = NULL;
        } else {
            value4.data = StringValuePtr(argv[3]);
            value4.len = RSTRING(argv[3])->len;
            arg4 = &value4;
        }
    }
    {
        result = (svn_error_t *)svn_repos_parse_fns2_invoke_set_node_property(arg1,arg2,(char const *)arg3,(struct svn_string_t const *)arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_invoke_delete_node_property(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_error_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 3) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    {
        result = (svn_error_t *)svn_repos_parse_fns2_invoke_delete_node_property(arg1,arg2,(char const *)arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_invoke_remove_node_props(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_error_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 2) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    {
        result = (svn_error_t *)svn_repos_parse_fns2_invoke_remove_node_props(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_invoke_set_fulltext(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_stream_t **arg2 = (svn_stream_t **) 0 ;
    void *arg3 = (void *) 0 ;
    svn_error_t *result;
    void *temp1 ;
    svn_stream_t *temp2 ;
    VALUE vresult = Qnil;
    
    {
        temp2 = NULL;
        arg2 = (svn_stream_t **)&temp2;
    }
    if ((argc < 2) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg3, 0, 1);
    {
        result = (svn_error_t *)svn_repos_parse_fns2_invoke_set_fulltext(arg1,arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_svn_stream_t, 0));
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_invoke_apply_textdelta(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    svn_txdelta_window_handler_t *arg2 = (svn_txdelta_window_handler_t *) 0 ;
    void **arg3 = (void **) 0 ;
    void *arg4 = (void *) 0 ;
    svn_error_t *result;
    void *temp1 ;
    svn_txdelta_window_handler_t temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        temp2 = NULL;
        arg2 = (svn_txdelta_window_handler_t *)&temp2;
    }
    {
        temp3 = NULL;
        arg3 = (void **)&temp3;
    }
    if ((argc < 2) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg4, 0, 1);
    {
        result = (svn_error_t *)svn_repos_parse_fns2_invoke_apply_textdelta(arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg3, SWIGTYPE_p_void, 0));
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_invoke_close_node(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_error_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 2) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    {
        result = (svn_error_t *)svn_repos_parse_fns2_invoke_close_node(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_parse_fns2_invoke_close_revision(int argc, VALUE *argv, VALUE self) {
    svn_repos_parse_fns2_t *arg1 = (svn_repos_parse_fns2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_error_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 2) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_parse_fns2_t, 1);
        
        
        
        arg1 = (svn_repos_parse_fns2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    {
        result = (svn_error_t *)svn_repos_parse_fns2_invoke_close_revision(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    return vresult;
}


static VALUE
_wrap_svn_repos_fs_wrapper(int argc, VALUE *argv, VALUE self) {
    svn_repos_t *arg1 = (svn_repos_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_fs_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_repos_t, 1);
        
        
        
        arg1 = (svn_repos_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (svn_fs_t *)svn_repos_fs_wrapper(arg1,arg2);
        
        
        
        
    }
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_fs_t,0);
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}



/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (BEGIN) -------- */

static swig_type_info _swigt__p_apr_array_header_t = {"_p_apr_array_header_t", "apr_array_header_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_hash_t = {"_p_apr_hash_t", "apr_hash_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int32_t = {"_p_apr_int32_t", "apr_int32_t *|time_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int64_t = {"_p_apr_int64_t", "apr_int64_t *|svn_filesize_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_pool_t = {"_p_apr_pool_t", "apr_pool_t *", 0, 0, 0};
static swig_type_info _swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(apr_getopt_t *,void *,apr_pool_t *)|svn_opt_subcommand_t *", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_svn_stream_t_p_void__p_svn_error_t = {"_p_f_p_p_svn_stream_t_p_void__p_svn_error_t", "struct svn_error_t *(*)(svn_stream_t **,void *)|svn_error_t *(*)(svn_stream_t **,void *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)|svn_error_t *(*)(void **,apr_hash_t *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(char const *,void *,apr_pool_t *)|svn_error_t *(*)(char const *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_commit_info_t const *,void *,apr_pool_t *)|svn_commit_callback2_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_boolean_t *,svn_fs_root_t *,char const *,void *,apr_pool_t *)|svn_repos_authz_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t = {"_p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t", "struct svn_error_t *(*)(svn_txdelta_window_handler_t *,void **,void *)|svn_error_t *(*)(svn_txdelta_window_handler_t *,void **,void *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t = {"_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t", "struct svn_error_t *(*)(svn_txdelta_window_t *,void *)|svn_txdelta_window_handler_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void__p_svn_error_t = {"_p_f_p_void__p_svn_error_t", "struct svn_error_t *(*)(void *)|svn_cancel_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_hash_t *,svn_revnum_t,char const *,char const *,char const *,apr_pool_t *)|svn_log_message_receiver_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char__p_svn_error_t = {"_p_f_p_void_p_q_const__char__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *)|svn_error_t *(*)(void *,char const *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_string_t const *)|svn_error_t *(*)(void *,char const *,svn_string_t const *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t *,svn_txdelta_window_handler_t *,void **,apr_array_header_t *,apr_pool_t *)|svn_repos_file_rev_handler_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_pool_t *)|svn_repos_history_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_repos_authz_access_t,svn_boolean_t *,svn_fs_root_t *,char const *,void *,apr_pool_t *)|svn_repos_authz_callback_t", 0, 0, 0};
static swig_type_info _swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t = {"_p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t", "struct svn_error_t *(*)(svn_revnum_t,char const *,char const *,void *)|svn_commit_callback_t", 0, 0, 0};
static swig_type_info _swigt__p_int = {"_p_int", "int *|svn_boolean_t *", 0, 0, 0};
static swig_type_info _swigt__p_long = {"_p_long", "long *|svn_revnum_t *", 0, 0, 0};
static swig_type_info _swigt__p_p_apr_array_header_t = {"_p_p_apr_array_header_t", "apr_array_header_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_apr_hash_t = {"_p_p_apr_hash_t", "apr_hash_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_char = {"_p_p_char", "char **", 0, 0, 0};
static swig_type_info _swigt__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t = {"_p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t", "struct svn_error_t *(**)(svn_txdelta_window_t *,void *)|svn_txdelta_window_handler_t *", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_authz_t = {"_p_p_svn_authz_t", "struct svn_authz_t **|svn_authz_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_delta_editor_t = {"_p_p_svn_delta_editor_t", "struct svn_delta_editor_t **|svn_delta_editor_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_dirent_t = {"_p_p_svn_dirent_t", "struct svn_dirent_t **|svn_dirent_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_fs_txn_t = {"_p_p_svn_fs_txn_t", "struct svn_fs_txn_t **|svn_fs_txn_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_lock_t = {"_p_p_svn_lock_t", "struct svn_lock_t **|svn_lock_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_repos_parse_fns2_t = {"_p_p_svn_repos_parse_fns2_t", "struct svn_repos_parse_fns2_t **|svn_repos_parse_fns2_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_repos_parse_fns_t = {"_p_p_svn_repos_parse_fns_t", "struct svn_repos_parse_fns_t **|svn_repos_parser_fns_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_repos_t = {"_p_p_svn_repos_t", "struct svn_repos_t **|svn_repos_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_stream_t = {"_p_p_svn_stream_t", "struct svn_stream_t **|svn_stream_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_string_t = {"_p_p_svn_string_t", "struct svn_string_t **|svn_string_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_void = {"_p_p_void", "void **", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_baton_t = {"_p_svn_auth_baton_t", "struct svn_auth_baton_t *|svn_auth_baton_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_simple_t = {"_p_svn_auth_cred_simple_t", "struct svn_auth_cred_simple_t *|svn_auth_cred_simple_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_pw_t = {"_p_svn_auth_cred_ssl_client_cert_pw_t", "struct svn_auth_cred_ssl_client_cert_pw_t *|svn_auth_cred_ssl_client_cert_pw_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_t = {"_p_svn_auth_cred_ssl_client_cert_t", "struct svn_auth_cred_ssl_client_cert_t *|svn_auth_cred_ssl_client_cert_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_server_trust_t = {"_p_svn_auth_cred_ssl_server_trust_t", "struct svn_auth_cred_ssl_server_trust_t *|svn_auth_cred_ssl_server_trust_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_username_t = {"_p_svn_auth_cred_username_t", "struct svn_auth_cred_username_t *|svn_auth_cred_username_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_iterstate_t = {"_p_svn_auth_iterstate_t", "struct svn_auth_iterstate_t *|svn_auth_iterstate_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_object_t = {"_p_svn_auth_provider_object_t", "struct svn_auth_provider_object_t *|svn_auth_provider_object_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_t = {"_p_svn_auth_provider_t", "struct svn_auth_provider_t *|svn_auth_provider_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_ssl_server_cert_info_t = {"_p_svn_auth_ssl_server_cert_info_t", "struct svn_auth_ssl_server_cert_info_t *|svn_auth_ssl_server_cert_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_authz_t = {"_p_svn_authz_t", "struct svn_authz_t *|svn_authz_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_commit_info_t = {"_p_svn_commit_info_t", "struct svn_commit_info_t *|svn_commit_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_config_t = {"_p_svn_config_t", "struct svn_config_t *|svn_config_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_delta_editor_t = {"_p_svn_delta_editor_t", "struct svn_delta_editor_t *|svn_delta_editor_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_datasource_e = {"_p_svn_diff_datasource_e", "enum svn_diff_datasource_e *|svn_diff_datasource_e *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_file_ignore_space_t = {"_p_svn_diff_file_ignore_space_t", "enum svn_diff_file_ignore_space_t *|svn_diff_file_ignore_space_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_file_options_t = {"_p_svn_diff_file_options_t", "struct svn_diff_file_options_t *|svn_diff_file_options_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_fns_t = {"_p_svn_diff_fns_t", "struct svn_diff_fns_t *|svn_diff_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_output_fns_t = {"_p_svn_diff_output_fns_t", "struct svn_diff_output_fns_t *|svn_diff_output_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_t = {"_p_svn_diff_t", "struct svn_diff_t *|svn_diff_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_dirent_t = {"_p_svn_dirent_t", "struct svn_dirent_t *|svn_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_errno_t = {"_p_svn_errno_t", "enum svn_errno_t *|svn_errno_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_error_t = {"_p_svn_error_t", "struct svn_error_t *|svn_error_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_access_t = {"_p_svn_fs_access_t", "struct svn_fs_access_t *|svn_fs_access_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_dirent_t = {"_p_svn_fs_dirent_t", "struct svn_fs_dirent_t *|svn_fs_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_history_t = {"_p_svn_fs_history_t", "struct svn_fs_history_t *|svn_fs_history_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_id_t = {"_p_svn_fs_id_t", "struct svn_fs_id_t *|svn_fs_id_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_path_change_kind_t = {"_p_svn_fs_path_change_kind_t", "enum svn_fs_path_change_kind_t *|svn_fs_path_change_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_path_change_t = {"_p_svn_fs_path_change_t", "struct svn_fs_path_change_t *|svn_fs_path_change_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_root_t = {"_p_svn_fs_root_t", "struct svn_fs_root_t *|svn_fs_root_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_t = {"_p_svn_fs_t", "struct svn_fs_t *|svn_fs_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_fs_txn_t = {"_p_svn_fs_txn_t", "struct svn_fs_txn_t *|svn_fs_txn_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_dirent_t = {"_p_svn_io_dirent_t", "struct svn_io_dirent_t *|svn_io_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_file_del_t = {"_p_svn_io_file_del_t", "enum svn_io_file_del_t *|svn_io_file_del_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_lock_t = {"_p_svn_lock_t", "struct svn_lock_t *|svn_lock_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_log_changed_path_t = {"_p_svn_log_changed_path_t", "struct svn_log_changed_path_t *|svn_log_changed_path_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_node_kind_t = {"_p_svn_node_kind_t", "enum svn_node_kind_t *|svn_node_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_t = {"_p_svn_opt_revision_t", "struct svn_opt_revision_t *|svn_opt_revision_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_value_t = {"_p_svn_opt_revision_value_t", "union svn_opt_revision_value_t *|svn_opt_revision_value_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc2_t = {"_p_svn_opt_subcommand_desc2_t", "struct svn_opt_subcommand_desc2_t *|svn_opt_subcommand_desc2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc_t = {"_p_svn_opt_subcommand_desc_t", "struct svn_opt_subcommand_desc_t *|svn_opt_subcommand_desc_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_prop_kind = {"_p_svn_prop_kind", "enum svn_prop_kind *|svn_prop_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_prop_t = {"_p_svn_prop_t", "struct svn_prop_t *|svn_prop_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_repos_authz_access_t = {"_p_svn_repos_authz_access_t", "enum svn_repos_authz_access_t *|svn_repos_authz_access_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_repos_node_t = {"_p_svn_repos_node_t", "struct svn_repos_node_t *|svn_repos_node_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_repos_parse_fns2_t = {"_p_svn_repos_parse_fns2_t", "struct svn_repos_parse_fns2_t *|svn_repos_parse_fns2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_repos_parse_fns_t = {"_p_svn_repos_parse_fns_t", "struct svn_repos_parse_fns_t *|svn_repos_parser_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_repos_t = {"_p_svn_repos_t", "struct svn_repos_t *|svn_repos_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stream_t = {"_p_svn_stream_t", "struct svn_stream_t *|svn_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_string_t = {"_p_svn_string_t", "struct svn_string_t *|svn_string_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stringbuf_t = {"_p_svn_stringbuf_t", "struct svn_stringbuf_t *|svn_stringbuf_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_op_t = {"_p_svn_txdelta_op_t", "struct svn_txdelta_op_t *|svn_txdelta_op_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_stream_t = {"_p_svn_txdelta_stream_t", "struct svn_txdelta_stream_t *|svn_txdelta_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_window_t = {"_p_svn_txdelta_window_t", "struct svn_txdelta_window_t *|svn_txdelta_window_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_checklist_t = {"_p_svn_version_checklist_t", "struct svn_version_checklist_t *|svn_version_checklist_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_t = {"_p_svn_version_t", "struct svn_version_t *|svn_version_t *", 0, 0, 0};
static swig_type_info _swigt__p_unsigned_long = {"_p_unsigned_long", "unsigned long *|VALUE *", 0, 0, 0};
static swig_type_info _swigt__p_void = {"_p_void", "void *", 0, 0, 0};

static swig_type_info *swig_type_initial[] = {
  &_swigt__p_apr_array_header_t,
  &_swigt__p_apr_hash_t,
  &_swigt__p_apr_int32_t,
  &_swigt__p_apr_int64_t,
  &_swigt__p_apr_pool_t,
  &_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_svn_stream_t_p_void__p_svn_error_t,
  &_swigt__p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t,
  &_swigt__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  &_swigt__p_f_p_void__p_svn_error_t,
  &_swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t,
  &_swigt__p_int,
  &_swigt__p_long,
  &_swigt__p_p_apr_array_header_t,
  &_swigt__p_p_apr_hash_t,
  &_swigt__p_p_char,
  &_swigt__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  &_swigt__p_p_svn_authz_t,
  &_swigt__p_p_svn_delta_editor_t,
  &_swigt__p_p_svn_dirent_t,
  &_swigt__p_p_svn_fs_txn_t,
  &_swigt__p_p_svn_lock_t,
  &_swigt__p_p_svn_repos_parse_fns2_t,
  &_swigt__p_p_svn_repos_parse_fns_t,
  &_swigt__p_p_svn_repos_t,
  &_swigt__p_p_svn_stream_t,
  &_swigt__p_p_svn_string_t,
  &_swigt__p_p_void,
  &_swigt__p_svn_auth_baton_t,
  &_swigt__p_svn_auth_cred_simple_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_pw_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_t,
  &_swigt__p_svn_auth_cred_ssl_server_trust_t,
  &_swigt__p_svn_auth_cred_username_t,
  &_swigt__p_svn_auth_iterstate_t,
  &_swigt__p_svn_auth_provider_object_t,
  &_swigt__p_svn_auth_provider_t,
  &_swigt__p_svn_auth_ssl_server_cert_info_t,
  &_swigt__p_svn_authz_t,
  &_swigt__p_svn_commit_info_t,
  &_swigt__p_svn_config_t,
  &_swigt__p_svn_delta_editor_t,
  &_swigt__p_svn_diff_datasource_e,
  &_swigt__p_svn_diff_file_ignore_space_t,
  &_swigt__p_svn_diff_file_options_t,
  &_swigt__p_svn_diff_fns_t,
  &_swigt__p_svn_diff_output_fns_t,
  &_swigt__p_svn_diff_t,
  &_swigt__p_svn_dirent_t,
  &_swigt__p_svn_errno_t,
  &_swigt__p_svn_error_t,
  &_swigt__p_svn_fs_access_t,
  &_swigt__p_svn_fs_dirent_t,
  &_swigt__p_svn_fs_history_t,
  &_swigt__p_svn_fs_id_t,
  &_swigt__p_svn_fs_path_change_kind_t,
  &_swigt__p_svn_fs_path_change_t,
  &_swigt__p_svn_fs_root_t,
  &_swigt__p_svn_fs_t,
  &_swigt__p_svn_fs_txn_t,
  &_swigt__p_svn_io_dirent_t,
  &_swigt__p_svn_io_file_del_t,
  &_swigt__p_svn_lock_t,
  &_swigt__p_svn_log_changed_path_t,
  &_swigt__p_svn_node_kind_t,
  &_swigt__p_svn_opt_revision_t,
  &_swigt__p_svn_opt_revision_value_t,
  &_swigt__p_svn_opt_subcommand_desc2_t,
  &_swigt__p_svn_opt_subcommand_desc_t,
  &_swigt__p_svn_prop_kind,
  &_swigt__p_svn_prop_t,
  &_swigt__p_svn_repos_authz_access_t,
  &_swigt__p_svn_repos_node_t,
  &_swigt__p_svn_repos_parse_fns2_t,
  &_swigt__p_svn_repos_parse_fns_t,
  &_swigt__p_svn_repos_t,
  &_swigt__p_svn_stream_t,
  &_swigt__p_svn_string_t,
  &_swigt__p_svn_stringbuf_t,
  &_swigt__p_svn_txdelta_op_t,
  &_swigt__p_svn_txdelta_stream_t,
  &_swigt__p_svn_txdelta_window_t,
  &_swigt__p_svn_version_checklist_t,
  &_swigt__p_svn_version_t,
  &_swigt__p_unsigned_long,
  &_swigt__p_void,
};

static swig_cast_info _swigc__p_apr_array_header_t[] = {  {&_swigt__p_apr_array_header_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_hash_t[] = {  {&_swigt__p_apr_hash_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int32_t[] = {  {&_swigt__p_apr_int32_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int64_t[] = {  {&_swigt__p_apr_int64_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_pool_t[] = {  {&_swigt__p_apr_pool_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_svn_stream_t_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_p_svn_stream_t_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t[] = {  {&_swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_int[] = {  {&_swigt__p_int, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_long[] = {  {&_swigt__p_long, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_apr_array_header_t[] = {  {&_swigt__p_p_apr_array_header_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_apr_hash_t[] = {  {&_swigt__p_p_apr_hash_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_char[] = {  {&_swigt__p_p_char, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t[] = {  {&_swigt__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_authz_t[] = {  {&_swigt__p_p_svn_authz_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_delta_editor_t[] = {  {&_swigt__p_p_svn_delta_editor_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_dirent_t[] = {  {&_swigt__p_p_svn_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_fs_txn_t[] = {  {&_swigt__p_p_svn_fs_txn_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_lock_t[] = {  {&_swigt__p_p_svn_lock_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_repos_parse_fns2_t[] = {  {&_swigt__p_p_svn_repos_parse_fns2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_repos_parse_fns_t[] = {  {&_swigt__p_p_svn_repos_parse_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_repos_t[] = {  {&_swigt__p_p_svn_repos_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_stream_t[] = {  {&_swigt__p_p_svn_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_string_t[] = {  {&_swigt__p_p_svn_string_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_void[] = {  {&_swigt__p_p_void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_baton_t[] = {  {&_swigt__p_svn_auth_baton_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_simple_t[] = {  {&_swigt__p_svn_auth_cred_simple_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_pw_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_pw_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_server_trust_t[] = {  {&_swigt__p_svn_auth_cred_ssl_server_trust_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_username_t[] = {  {&_swigt__p_svn_auth_cred_username_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_iterstate_t[] = {  {&_swigt__p_svn_auth_iterstate_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_object_t[] = {  {&_swigt__p_svn_auth_provider_object_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_t[] = {  {&_swigt__p_svn_auth_provider_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_ssl_server_cert_info_t[] = {  {&_swigt__p_svn_auth_ssl_server_cert_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_authz_t[] = {  {&_swigt__p_svn_authz_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_commit_info_t[] = {  {&_swigt__p_svn_commit_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_config_t[] = {  {&_swigt__p_svn_config_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_delta_editor_t[] = {  {&_swigt__p_svn_delta_editor_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_datasource_e[] = {  {&_swigt__p_svn_diff_datasource_e, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_file_ignore_space_t[] = {  {&_swigt__p_svn_diff_file_ignore_space_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_file_options_t[] = {  {&_swigt__p_svn_diff_file_options_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_fns_t[] = {  {&_swigt__p_svn_diff_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_output_fns_t[] = {  {&_swigt__p_svn_diff_output_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_t[] = {  {&_swigt__p_svn_diff_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_dirent_t[] = {  {&_swigt__p_svn_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_errno_t[] = {  {&_swigt__p_svn_errno_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_error_t[] = {  {&_swigt__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_access_t[] = {  {&_swigt__p_svn_fs_access_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_dirent_t[] = {  {&_swigt__p_svn_fs_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_history_t[] = {  {&_swigt__p_svn_fs_history_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_id_t[] = {  {&_swigt__p_svn_fs_id_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_path_change_kind_t[] = {  {&_swigt__p_svn_fs_path_change_kind_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_path_change_t[] = {  {&_swigt__p_svn_fs_path_change_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_root_t[] = {  {&_swigt__p_svn_fs_root_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_t[] = {  {&_swigt__p_svn_fs_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_fs_txn_t[] = {  {&_swigt__p_svn_fs_txn_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_dirent_t[] = {  {&_swigt__p_svn_io_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_file_del_t[] = {  {&_swigt__p_svn_io_file_del_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_lock_t[] = {  {&_swigt__p_svn_lock_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_log_changed_path_t[] = {  {&_swigt__p_svn_log_changed_path_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_node_kind_t[] = {  {&_swigt__p_svn_node_kind_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_t[] = {  {&_swigt__p_svn_opt_revision_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_value_t[] = {  {&_swigt__p_svn_opt_revision_value_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc2_t[] = {  {&_swigt__p_svn_opt_subcommand_desc2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc_t[] = {  {&_swigt__p_svn_opt_subcommand_desc_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_prop_kind[] = {  {&_swigt__p_svn_prop_kind, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_prop_t[] = {  {&_swigt__p_svn_prop_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_repos_authz_access_t[] = {  {&_swigt__p_svn_repos_authz_access_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_repos_node_t[] = {  {&_swigt__p_svn_repos_node_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_repos_parse_fns2_t[] = {  {&_swigt__p_svn_repos_parse_fns2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_repos_parse_fns_t[] = {  {&_swigt__p_svn_repos_parse_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_repos_t[] = {  {&_swigt__p_svn_repos_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stream_t[] = {  {&_swigt__p_svn_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_string_t[] = {  {&_swigt__p_svn_string_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stringbuf_t[] = {  {&_swigt__p_svn_stringbuf_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_op_t[] = {  {&_swigt__p_svn_txdelta_op_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_stream_t[] = {  {&_swigt__p_svn_txdelta_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_window_t[] = {  {&_swigt__p_svn_txdelta_window_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_checklist_t[] = {  {&_swigt__p_svn_version_checklist_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_t[] = {  {&_swigt__p_svn_version_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_unsigned_long[] = {  {&_swigt__p_unsigned_long, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_void[] = {  {&_swigt__p_void, 0, 0, 0},{0, 0, 0, 0}};

static swig_cast_info *swig_cast_initial[] = {
  _swigc__p_apr_array_header_t,
  _swigc__p_apr_hash_t,
  _swigc__p_apr_int32_t,
  _swigc__p_apr_int64_t,
  _swigc__p_apr_pool_t,
  _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_svn_stream_t_p_void__p_svn_error_t,
  _swigc__p_f_p_p_void_p_apr_hash_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_svn_txdelta_window_handler_t_p_p_void_p_void__p_svn_error_t,
  _swigc__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  _swigc__p_f_p_void__p_svn_error_t,
  _swigc__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__svn_string_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_svn_repos_authz_access_t_p_svn_boolean_t_p_svn_fs_root_t_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t,
  _swigc__p_int,
  _swigc__p_long,
  _swigc__p_p_apr_array_header_t,
  _swigc__p_p_apr_hash_t,
  _swigc__p_p_char,
  _swigc__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  _swigc__p_p_svn_authz_t,
  _swigc__p_p_svn_delta_editor_t,
  _swigc__p_p_svn_dirent_t,
  _swigc__p_p_svn_fs_txn_t,
  _swigc__p_p_svn_lock_t,
  _swigc__p_p_svn_repos_parse_fns2_t,
  _swigc__p_p_svn_repos_parse_fns_t,
  _swigc__p_p_svn_repos_t,
  _swigc__p_p_svn_stream_t,
  _swigc__p_p_svn_string_t,
  _swigc__p_p_void,
  _swigc__p_svn_auth_baton_t,
  _swigc__p_svn_auth_cred_simple_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_pw_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_t,
  _swigc__p_svn_auth_cred_ssl_server_trust_t,
  _swigc__p_svn_auth_cred_username_t,
  _swigc__p_svn_auth_iterstate_t,
  _swigc__p_svn_auth_provider_object_t,
  _swigc__p_svn_auth_provider_t,
  _swigc__p_svn_auth_ssl_server_cert_info_t,
  _swigc__p_svn_authz_t,
  _swigc__p_svn_commit_info_t,
  _swigc__p_svn_config_t,
  _swigc__p_svn_delta_editor_t,
  _swigc__p_svn_diff_datasource_e,
  _swigc__p_svn_diff_file_ignore_space_t,
  _swigc__p_svn_diff_file_options_t,
  _swigc__p_svn_diff_fns_t,
  _swigc__p_svn_diff_output_fns_t,
  _swigc__p_svn_diff_t,
  _swigc__p_svn_dirent_t,
  _swigc__p_svn_errno_t,
  _swigc__p_svn_error_t,
  _swigc__p_svn_fs_access_t,
  _swigc__p_svn_fs_dirent_t,
  _swigc__p_svn_fs_history_t,
  _swigc__p_svn_fs_id_t,
  _swigc__p_svn_fs_path_change_kind_t,
  _swigc__p_svn_fs_path_change_t,
  _swigc__p_svn_fs_root_t,
  _swigc__p_svn_fs_t,
  _swigc__p_svn_fs_txn_t,
  _swigc__p_svn_io_dirent_t,
  _swigc__p_svn_io_file_del_t,
  _swigc__p_svn_lock_t,
  _swigc__p_svn_log_changed_path_t,
  _swigc__p_svn_node_kind_t,
  _swigc__p_svn_opt_revision_t,
  _swigc__p_svn_opt_revision_value_t,
  _swigc__p_svn_opt_subcommand_desc2_t,
  _swigc__p_svn_opt_subcommand_desc_t,
  _swigc__p_svn_prop_kind,
  _swigc__p_svn_prop_t,
  _swigc__p_svn_repos_authz_access_t,
  _swigc__p_svn_repos_node_t,
  _swigc__p_svn_repos_parse_fns2_t,
  _swigc__p_svn_repos_parse_fns_t,
  _swigc__p_svn_repos_t,
  _swigc__p_svn_stream_t,
  _swigc__p_svn_string_t,
  _swigc__p_svn_stringbuf_t,
  _swigc__p_svn_txdelta_op_t,
  _swigc__p_svn_txdelta_stream_t,
  _swigc__p_svn_txdelta_window_t,
  _swigc__p_svn_version_checklist_t,
  _swigc__p_svn_version_t,
  _swigc__p_unsigned_long,
  _swigc__p_void,
};


/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (END) -------- */

/*************************************************************************
 * Type initialization:
 * This problem is tough by the requirement that no dynamic 
 * memory is used. Also, since swig_type_info structures store pointers to 
 * swig_cast_info structures and swig_cast_info structures store pointers back
 * to swig_type_info structures, we need some lookup code at initialization. 
 * The idea is that swig generates all the structures that are needed. 
 * The runtime then collects these partially filled structures. 
 * The SWIG_InitializeModule function takes these initial arrays out of 
 * swig_module, and does all the lookup, filling in the swig_module.types
 * array with the correct data and linking the correct swig_cast_info
 * structures together.

 * The generated swig_type_info structures are assigned staticly to an initial 
 * array. We just loop though that array, and handle each type individually.
 * First we lookup if this type has been already loaded, and if so, use the
 * loaded structure instead of the generated one. Then we have to fill in the
 * cast linked list. The cast data is initially stored in something like a
 * two-dimensional array. Each row corresponds to a type (there are the same
 * number of rows as there are in the swig_type_initial array). Each entry in
 * a column is one of the swig_cast_info structures for that type.
 * The cast_initial array is actually an array of arrays, because each row has
 * a variable number of columns. So to actually build the cast linked list,
 * we find the array of casts associated with the type, and loop through it 
 * adding the casts to the list. The one last trick we need to do is making
 * sure the type pointer in the swig_cast_info struct is correct.

 * First off, we lookup the cast->type name to see if it is already loaded. 
 * There are three cases to handle:
 *  1) If the cast->type has already been loaded AND the type we are adding
 *     casting info to has not been loaded (it is in this module), THEN we
 *     replace the cast->type pointer with the type pointer that has already
 *     been loaded.
 *  2) If BOTH types (the one we are adding casting info to, and the 
 *     cast->type) are loaded, THEN the cast info has already been loaded by
 *     the previous module so we just ignore it.
 *  3) Finally, if cast->type has not already been loaded, then we add that
 *     swig_cast_info to the linked list (because the cast->type) pointer will
 *     be correct.
**/

#ifdef __cplusplus
extern "C" {
#endif

SWIGRUNTIME void
SWIG_InitializeModule(void *clientdata) {
  swig_type_info *type, *ret;
  swig_cast_info *cast;
  size_t i;
  swig_module_info *module_head;
  static int init_run = 0;

  clientdata = clientdata;

  if (init_run) return;
  init_run = 1;

  /* Initialize the swig_module */
  swig_module.type_initial = swig_type_initial;
  swig_module.cast_initial = swig_cast_initial;

  /* Try and load any already created modules */
  module_head = SWIG_GetModule(clientdata);
  if (module_head) {
    swig_module.next = module_head->next;
    module_head->next = &swig_module;
  } else {
    /* This is the first module loaded */
    swig_module.next = &swig_module;
    SWIG_SetModule(clientdata, &swig_module);
  }
		 
  /* Now work on filling in swig_module.types */
  for (i = 0; i < swig_module.size; ++i) {
    type = 0;

    /* if there is another module already loaded */
    if (swig_module.next != &swig_module) {
      type = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, swig_module.type_initial[i]->name);
    }
    if (type) {
      /* Overwrite clientdata field */
      if (swig_module.type_initial[i]->clientdata) type->clientdata = swig_module.type_initial[i]->clientdata;
    } else {
      type = swig_module.type_initial[i];
    }

    /* Insert casting types */
    cast = swig_module.cast_initial[i];
    while (cast->type) {
    
      /* Don't need to add information already in the list */
      ret = 0;
      if (swig_module.next != &swig_module) {
        ret = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, cast->type->name);
      }
      if (ret && type == swig_module.type_initial[i]) {
        cast->type = ret;
        ret = 0;
      }
      
      if (!ret) {
        if (type->cast) {
          type->cast->prev = cast;
          cast->next = type->cast;
        }
        type->cast = cast;
      }

      cast++;
    }

    /* Set entry in modules->types array equal to the type */
    swig_module.types[i] = type;
  }
}

/* This function will propagate the clientdata field of type to
* any new swig_type_info structures that have been added into the list
* of equivalent types.  It is like calling
* SWIG_TypeClientData(type, clientdata) a second time.
*/
SWIGRUNTIME void
SWIG_PropagateClientData(void) {
  size_t i;
  swig_cast_info *equiv;
  static int init_run = 0;

  if (init_run) return;
  init_run = 1;

  for (i = 0; i < swig_module.size; i++) {
    if (swig_module.types[i]->clientdata) {
      equiv = swig_module.types[i]->cast;
      while (equiv) {
        if (!equiv->converter) {
          if (equiv->type && !equiv->type->clientdata)
            SWIG_TypeClientData(equiv->type, swig_module.types[i]->clientdata);
        }
        equiv = equiv->next;
      }
    }
  }
}

#ifdef __cplusplus
}
#endif


#ifdef __cplusplus
extern "C"
#endif
SWIGEXPORT void Init_repos(void) {
    int i;
    
    SWIG_InitRuntime();
    mRepos = rb_define_module("Svn");
    mRepos = rb_define_module_under(mRepos, "Ext");
    mRepos = rb_define_module_under(mRepos, "Repos");
    
    SWIG_InitializeModule(0);
    for (i = 0; i < swig_module.size; i++) {
        SWIG_define_class(swig_module.types[i]);
    }
    
    rb_require("svn/ext/core");
    rb_require("svn/ext/delta");
    rb_require("svn/ext/fs");
    rb_define_module_function(mRepos, "svn_repos_version", _wrap_svn_repos_version, -1);
    rb_define_const(mRepos,"Svn_authz_none", INT2NUM(svn_authz_none));
    rb_define_const(mRepos,"Svn_authz_read", INT2NUM(svn_authz_read));
    rb_define_const(mRepos,"Svn_authz_write", INT2NUM(svn_authz_write));
    rb_define_const(mRepos,"Svn_authz_recursive", INT2NUM(svn_authz_recursive));
    rb_define_module_function(mRepos, "svn_repos_find_root_path", _wrap_svn_repos_find_root_path, -1);
    rb_define_module_function(mRepos, "svn_repos_open", _wrap_svn_repos_open, -1);
    rb_define_module_function(mRepos, "svn_repos_create", _wrap_svn_repos_create, -1);
    rb_define_module_function(mRepos, "svn_repos_delete", _wrap_svn_repos_delete, -1);
    rb_define_module_function(mRepos, "svn_repos_hotcopy", _wrap_svn_repos_hotcopy, -1);
    rb_define_module_function(mRepos, "svn_repos_recover", _wrap_svn_repos_recover, -1);
    rb_define_module_function(mRepos, "svn_repos_recover2", _wrap_svn_repos_recover2, -1);
    rb_define_module_function(mRepos, "svn_repos_db_logfiles", _wrap_svn_repos_db_logfiles, -1);
    rb_define_module_function(mRepos, "svn_repos_path", _wrap_svn_repos_path, -1);
    rb_define_module_function(mRepos, "svn_repos_db_env", _wrap_svn_repos_db_env, -1);
    rb_define_module_function(mRepos, "svn_repos_conf_dir", _wrap_svn_repos_conf_dir, -1);
    rb_define_module_function(mRepos, "svn_repos_svnserve_conf", _wrap_svn_repos_svnserve_conf, -1);
    rb_define_module_function(mRepos, "svn_repos_lock_dir", _wrap_svn_repos_lock_dir, -1);
    rb_define_module_function(mRepos, "svn_repos_db_lockfile", _wrap_svn_repos_db_lockfile, -1);
    rb_define_module_function(mRepos, "svn_repos_db_logs_lockfile", _wrap_svn_repos_db_logs_lockfile, -1);
    rb_define_module_function(mRepos, "svn_repos_hook_dir", _wrap_svn_repos_hook_dir, -1);
    rb_define_module_function(mRepos, "svn_repos_start_commit_hook", _wrap_svn_repos_start_commit_hook, -1);
    rb_define_module_function(mRepos, "svn_repos_pre_commit_hook", _wrap_svn_repos_pre_commit_hook, -1);
    rb_define_module_function(mRepos, "svn_repos_post_commit_hook", _wrap_svn_repos_post_commit_hook, -1);
    rb_define_module_function(mRepos, "svn_repos_pre_revprop_change_hook", _wrap_svn_repos_pre_revprop_change_hook, -1);
    rb_define_module_function(mRepos, "svn_repos_post_revprop_change_hook", _wrap_svn_repos_post_revprop_change_hook, -1);
    rb_define_module_function(mRepos, "svn_repos_pre_lock_hook", _wrap_svn_repos_pre_lock_hook, -1);
    rb_define_module_function(mRepos, "svn_repos_post_lock_hook", _wrap_svn_repos_post_lock_hook, -1);
    rb_define_module_function(mRepos, "svn_repos_pre_unlock_hook", _wrap_svn_repos_pre_unlock_hook, -1);
    rb_define_module_function(mRepos, "svn_repos_post_unlock_hook", _wrap_svn_repos_post_unlock_hook, -1);
    rb_define_module_function(mRepos, "svn_repos_begin_report", _wrap_svn_repos_begin_report, -1);
    rb_define_module_function(mRepos, "svn_repos_set_path2", _wrap_svn_repos_set_path2, -1);
    rb_define_module_function(mRepos, "svn_repos_set_path", _wrap_svn_repos_set_path, -1);
    rb_define_module_function(mRepos, "svn_repos_link_path2", _wrap_svn_repos_link_path2, -1);
    rb_define_module_function(mRepos, "svn_repos_link_path", _wrap_svn_repos_link_path, -1);
    rb_define_module_function(mRepos, "svn_repos_delete_path", _wrap_svn_repos_delete_path, -1);
    rb_define_module_function(mRepos, "svn_repos_finish_report", _wrap_svn_repos_finish_report, -1);
    rb_define_module_function(mRepos, "svn_repos_abort_report", _wrap_svn_repos_abort_report, -1);
    rb_define_module_function(mRepos, "svn_repos_dir_delta", _wrap_svn_repos_dir_delta, -1);
    rb_define_module_function(mRepos, "svn_repos_replay2", _wrap_svn_repos_replay2, -1);
    rb_define_module_function(mRepos, "svn_repos_replay", _wrap_svn_repos_replay, -1);
    rb_define_module_function(mRepos, "svn_repos_get_commit_editor4", _wrap_svn_repos_get_commit_editor4, -1);
    rb_define_module_function(mRepos, "svn_repos_get_commit_editor3", _wrap_svn_repos_get_commit_editor3, -1);
    rb_define_module_function(mRepos, "svn_repos_get_commit_editor2", _wrap_svn_repos_get_commit_editor2, -1);
    rb_define_module_function(mRepos, "svn_repos_get_commit_editor", _wrap_svn_repos_get_commit_editor, -1);
    rb_define_module_function(mRepos, "svn_repos_dated_revision", _wrap_svn_repos_dated_revision, -1);
    rb_define_module_function(mRepos, "svn_repos_get_committed_info", _wrap_svn_repos_get_committed_info, -1);
    rb_define_module_function(mRepos, "svn_repos_stat", _wrap_svn_repos_stat, -1);
    rb_define_module_function(mRepos, "svn_repos_history2", _wrap_svn_repos_history2, -1);
    rb_define_module_function(mRepos, "svn_repos_history", _wrap_svn_repos_history, -1);
    rb_define_module_function(mRepos, "svn_repos_trace_node_locations", _wrap_svn_repos_trace_node_locations, -1);
    rb_define_module_function(mRepos, "svn_repos_get_logs3", _wrap_svn_repos_get_logs3, -1);
    rb_define_module_function(mRepos, "svn_repos_get_logs2", _wrap_svn_repos_get_logs2, -1);
    rb_define_module_function(mRepos, "svn_repos_get_logs", _wrap_svn_repos_get_logs, -1);
    rb_define_module_function(mRepos, "svn_repos_get_file_revs", _wrap_svn_repos_get_file_revs, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_commit_txn", _wrap_svn_repos_fs_commit_txn, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_begin_txn_for_commit", _wrap_svn_repos_fs_begin_txn_for_commit, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_begin_txn_for_update", _wrap_svn_repos_fs_begin_txn_for_update, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_lock", _wrap_svn_repos_fs_lock, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_unlock", _wrap_svn_repos_fs_unlock, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_get_locks", _wrap_svn_repos_fs_get_locks, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_change_rev_prop2", _wrap_svn_repos_fs_change_rev_prop2, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_change_rev_prop", _wrap_svn_repos_fs_change_rev_prop, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_revision_prop", _wrap_svn_repos_fs_revision_prop, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_revision_proplist", _wrap_svn_repos_fs_revision_proplist, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_change_node_prop", _wrap_svn_repos_fs_change_node_prop, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_change_txn_prop", _wrap_svn_repos_fs_change_txn_prop, -1);
    
    cSvn_repos_node_t.klass = rb_define_class_under(mRepos, "Svn_repos_node_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_repos_node_t, (void *) &cSvn_repos_node_t);
    rb_undef_alloc_func(cSvn_repos_node_t.klass);
    rb_define_method(cSvn_repos_node_t.klass, "kind=", _wrap_svn_repos_node_t_kind_set, -1);
    rb_define_method(cSvn_repos_node_t.klass, "kind", _wrap_svn_repos_node_t_kind_get, -1);
    rb_define_method(cSvn_repos_node_t.klass, "action=", _wrap_svn_repos_node_t_action_set, -1);
    rb_define_method(cSvn_repos_node_t.klass, "action", _wrap_svn_repos_node_t_action_get, -1);
    rb_define_method(cSvn_repos_node_t.klass, "text_mod=", _wrap_svn_repos_node_t_text_mod_set, -1);
    rb_define_method(cSvn_repos_node_t.klass, "text_mod", _wrap_svn_repos_node_t_text_mod_get, -1);
    rb_define_method(cSvn_repos_node_t.klass, "prop_mod=", _wrap_svn_repos_node_t_prop_mod_set, -1);
    rb_define_method(cSvn_repos_node_t.klass, "prop_mod", _wrap_svn_repos_node_t_prop_mod_get, -1);
    rb_define_method(cSvn_repos_node_t.klass, "name=", _wrap_svn_repos_node_t_name_set, -1);
    rb_define_method(cSvn_repos_node_t.klass, "name", _wrap_svn_repos_node_t_name_get, -1);
    rb_define_method(cSvn_repos_node_t.klass, "copyfrom_rev=", _wrap_svn_repos_node_t_copyfrom_rev_set, -1);
    rb_define_method(cSvn_repos_node_t.klass, "copyfrom_rev", _wrap_svn_repos_node_t_copyfrom_rev_get, -1);
    rb_define_method(cSvn_repos_node_t.klass, "copyfrom_path=", _wrap_svn_repos_node_t_copyfrom_path_set, -1);
    rb_define_method(cSvn_repos_node_t.klass, "copyfrom_path", _wrap_svn_repos_node_t_copyfrom_path_get, -1);
    rb_define_method(cSvn_repos_node_t.klass, "sibling=", _wrap_svn_repos_node_t_sibling_set, -1);
    rb_define_method(cSvn_repos_node_t.klass, "sibling", _wrap_svn_repos_node_t_sibling_get, -1);
    rb_define_method(cSvn_repos_node_t.klass, "child=", _wrap_svn_repos_node_t_child_set, -1);
    rb_define_method(cSvn_repos_node_t.klass, "child", _wrap_svn_repos_node_t_child_get, -1);
    rb_define_method(cSvn_repos_node_t.klass, "parent=", _wrap_svn_repos_node_t_parent_set, -1);
    rb_define_method(cSvn_repos_node_t.klass, "parent", _wrap_svn_repos_node_t_parent_get, -1);
    cSvn_repos_node_t.mark = 0;
    rb_define_module_function(mRepos, "svn_repos_node_editor", _wrap_svn_repos_node_editor, -1);
    rb_define_module_function(mRepos, "svn_repos_node_from_baton", _wrap_svn_repos_node_from_baton, -1);
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_MAGIC_HEADER", rb_str_new2("SVN-fs-dump-format-version"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_FORMAT_VERSION", INT2NUM(3));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_UUID", rb_str_new2("UUID"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_CONTENT_LENGTH", rb_str_new2("Content-length"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_REVISION_NUMBER", rb_str_new2("Revision-number"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_NODE_PATH", rb_str_new2("Node-path"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_NODE_KIND", rb_str_new2("Node-kind"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_NODE_ACTION", rb_str_new2("Node-action"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_NODE_COPYFROM_PATH", rb_str_new2("Node-copyfrom-path"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_NODE_COPYFROM_REV", rb_str_new2("Node-copyfrom-rev"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_TEXT_COPY_SOURCE_CHECKSUM", rb_str_new2("Text-copy-source-md5"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_TEXT_CONTENT_CHECKSUM", rb_str_new2("Text-content-md5"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_PROP_CONTENT_LENGTH", rb_str_new2("Prop-content-length"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_TEXT_CONTENT_LENGTH", rb_str_new2("Text-content-length"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_PROP_DELTA", rb_str_new2("Prop-delta"));
    rb_define_const(mRepos,"SVN_REPOS_DUMPFILE_TEXT_DELTA", rb_str_new2("Text-delta"));
    rb_define_const(mRepos,"Svn_node_action_change", INT2NUM(svn_node_action_change));
    rb_define_const(mRepos,"Svn_node_action_add", INT2NUM(svn_node_action_add));
    rb_define_const(mRepos,"Svn_node_action_delete", INT2NUM(svn_node_action_delete));
    rb_define_const(mRepos,"Svn_node_action_replace", INT2NUM(svn_node_action_replace));
    rb_define_const(mRepos,"Svn_repos_load_uuid_default", INT2NUM(svn_repos_load_uuid_default));
    rb_define_const(mRepos,"Svn_repos_load_uuid_ignore", INT2NUM(svn_repos_load_uuid_ignore));
    rb_define_const(mRepos,"Svn_repos_load_uuid_force", INT2NUM(svn_repos_load_uuid_force));
    rb_define_module_function(mRepos, "svn_repos_dump_fs2", _wrap_svn_repos_dump_fs2, -1);
    rb_define_module_function(mRepos, "svn_repos_dump_fs", _wrap_svn_repos_dump_fs, -1);
    rb_define_module_function(mRepos, "svn_repos_load_fs2", _wrap_svn_repos_load_fs2, -1);
    rb_define_module_function(mRepos, "svn_repos_load_fs", _wrap_svn_repos_load_fs, -1);
    
    cSvn_repos_parse_fns2_t.klass = rb_define_class_under(mRepos, "Svn_repos_parse_fns2_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_repos_parse_fns2_t, (void *) &cSvn_repos_parse_fns2_t);
    rb_undef_alloc_func(cSvn_repos_parse_fns2_t.klass);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "new_revision_record=", _wrap_svn_repos_parse_fns2_t_new_revision_record_set, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "new_revision_record", _wrap_svn_repos_parse_fns2_t_new_revision_record_get, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "uuid_record=", _wrap_svn_repos_parse_fns2_t_uuid_record_set, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "uuid_record", _wrap_svn_repos_parse_fns2_t_uuid_record_get, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "new_node_record=", _wrap_svn_repos_parse_fns2_t_new_node_record_set, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "new_node_record", _wrap_svn_repos_parse_fns2_t_new_node_record_get, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "set_revision_property=", _wrap_svn_repos_parse_fns2_t_set_revision_property_set, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "set_revision_property", _wrap_svn_repos_parse_fns2_t_set_revision_property_get, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "set_node_property=", _wrap_svn_repos_parse_fns2_t_set_node_property_set, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "set_node_property", _wrap_svn_repos_parse_fns2_t_set_node_property_get, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "delete_node_property=", _wrap_svn_repos_parse_fns2_t_delete_node_property_set, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "delete_node_property", _wrap_svn_repos_parse_fns2_t_delete_node_property_get, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "remove_node_props=", _wrap_svn_repos_parse_fns2_t_remove_node_props_set, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "remove_node_props", _wrap_svn_repos_parse_fns2_t_remove_node_props_get, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "set_fulltext=", _wrap_svn_repos_parse_fns2_t_set_fulltext_set, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "set_fulltext", _wrap_svn_repos_parse_fns2_t_set_fulltext_get, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "apply_textdelta=", _wrap_svn_repos_parse_fns2_t_apply_textdelta_set, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "apply_textdelta", _wrap_svn_repos_parse_fns2_t_apply_textdelta_get, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "close_node=", _wrap_svn_repos_parse_fns2_t_close_node_set, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "close_node", _wrap_svn_repos_parse_fns2_t_close_node_get, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "close_revision=", _wrap_svn_repos_parse_fns2_t_close_revision_set, -1);
    rb_define_method(cSvn_repos_parse_fns2_t.klass, "close_revision", _wrap_svn_repos_parse_fns2_t_close_revision_get, -1);
    cSvn_repos_parse_fns2_t.mark = 0;
    rb_define_module_function(mRepos, "svn_repos_parse_dumpstream2", _wrap_svn_repos_parse_dumpstream2, -1);
    rb_define_module_function(mRepos, "svn_repos_get_fs_build_parser2", _wrap_svn_repos_get_fs_build_parser2, -1);
    
    cSvn_repos_parser_fns_t.klass = rb_define_class_under(mRepos, "Svn_repos_parser_fns_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_repos_parse_fns_t, (void *) &cSvn_repos_parser_fns_t);
    rb_undef_alloc_func(cSvn_repos_parser_fns_t.klass);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "new_revision_record=", _wrap_svn_repos_parser_fns_t_new_revision_record_set, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "new_revision_record", _wrap_svn_repos_parser_fns_t_new_revision_record_get, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "uuid_record=", _wrap_svn_repos_parser_fns_t_uuid_record_set, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "uuid_record", _wrap_svn_repos_parser_fns_t_uuid_record_get, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "new_node_record=", _wrap_svn_repos_parser_fns_t_new_node_record_set, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "new_node_record", _wrap_svn_repos_parser_fns_t_new_node_record_get, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "set_revision_property=", _wrap_svn_repos_parser_fns_t_set_revision_property_set, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "set_revision_property", _wrap_svn_repos_parser_fns_t_set_revision_property_get, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "set_node_property=", _wrap_svn_repos_parser_fns_t_set_node_property_set, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "set_node_property", _wrap_svn_repos_parser_fns_t_set_node_property_get, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "remove_node_props=", _wrap_svn_repos_parser_fns_t_remove_node_props_set, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "remove_node_props", _wrap_svn_repos_parser_fns_t_remove_node_props_get, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "set_fulltext=", _wrap_svn_repos_parser_fns_t_set_fulltext_set, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "set_fulltext", _wrap_svn_repos_parser_fns_t_set_fulltext_get, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "close_node=", _wrap_svn_repos_parser_fns_t_close_node_set, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "close_node", _wrap_svn_repos_parser_fns_t_close_node_get, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "close_revision=", _wrap_svn_repos_parser_fns_t_close_revision_set, -1);
    rb_define_method(cSvn_repos_parser_fns_t.klass, "close_revision", _wrap_svn_repos_parser_fns_t_close_revision_get, -1);
    cSvn_repos_parser_fns_t.mark = 0;
    rb_define_module_function(mRepos, "svn_repos_parse_dumpstream", _wrap_svn_repos_parse_dumpstream, -1);
    rb_define_module_function(mRepos, "svn_repos_get_fs_build_parser", _wrap_svn_repos_get_fs_build_parser, -1);
    rb_define_module_function(mRepos, "svn_repos_authz_read", _wrap_svn_repos_authz_read, -1);
    rb_define_module_function(mRepos, "svn_repos_authz_check_access", _wrap_svn_repos_authz_check_access, -1);
    rb_define_module_function(mRepos, "svn_repos_parse_fns2_invoke_new_revision_record", _wrap_svn_repos_parse_fns2_invoke_new_revision_record, -1);
    rb_define_module_function(mRepos, "svn_repos_parse_fns2_invoke_uuid_record", _wrap_svn_repos_parse_fns2_invoke_uuid_record, -1);
    rb_define_module_function(mRepos, "svn_repos_parse_fns2_invoke_new_node_record", _wrap_svn_repos_parse_fns2_invoke_new_node_record, -1);
    rb_define_module_function(mRepos, "svn_repos_parse_fns2_invoke_set_revision_property", _wrap_svn_repos_parse_fns2_invoke_set_revision_property, -1);
    rb_define_module_function(mRepos, "svn_repos_parse_fns2_invoke_set_node_property", _wrap_svn_repos_parse_fns2_invoke_set_node_property, -1);
    rb_define_module_function(mRepos, "svn_repos_parse_fns2_invoke_delete_node_property", _wrap_svn_repos_parse_fns2_invoke_delete_node_property, -1);
    rb_define_module_function(mRepos, "svn_repos_parse_fns2_invoke_remove_node_props", _wrap_svn_repos_parse_fns2_invoke_remove_node_props, -1);
    rb_define_module_function(mRepos, "svn_repos_parse_fns2_invoke_set_fulltext", _wrap_svn_repos_parse_fns2_invoke_set_fulltext, -1);
    rb_define_module_function(mRepos, "svn_repos_parse_fns2_invoke_apply_textdelta", _wrap_svn_repos_parse_fns2_invoke_apply_textdelta, -1);
    rb_define_module_function(mRepos, "svn_repos_parse_fns2_invoke_close_node", _wrap_svn_repos_parse_fns2_invoke_close_node, -1);
    rb_define_module_function(mRepos, "svn_repos_parse_fns2_invoke_close_revision", _wrap_svn_repos_parse_fns2_invoke_close_revision, -1);
    rb_define_module_function(mRepos, "svn_repos_fs_wrapper", _wrap_svn_repos_fs_wrapper, -1);
}

