/* ----------------------------------------------------------------------------
 * This file was automatically generated by SWIG (http://www.swig.org).
 * Version 1.3.25
 * 
 * This file is not intended to be easily readable and contains a number of 
 * coding conventions designed to improve portability and efficiency. Do not make
 * changes to this file unless you know what you are doing--modify the SWIG 
 * interface file instead. 
 * ----------------------------------------------------------------------------- */

/***********************************************************************
 *
 *  This section contains generic SWIG labels for method/variable
 *  declarations/attributes, and other compiler dependent labels.
 *
 ************************************************************************/

/* template workaround for compilers that cannot correctly implement the C++ standard */
#ifndef SWIGTEMPLATEDISAMBIGUATOR
#  if defined(__SUNPRO_CC) && (__SUNPRO_CC <= 0x560)
#    define SWIGTEMPLATEDISAMBIGUATOR template
#  else
#    define SWIGTEMPLATEDISAMBIGUATOR 
#  endif
#endif

/* inline attribute */
#ifndef SWIGINLINE
# if defined(__cplusplus) || (defined(__GNUC__) && !defined(__STRICT_ANSI__))
#   define SWIGINLINE inline
# else
#   define SWIGINLINE
# endif
#endif

/* attribute recognised by some compilers to avoid 'unused' warnings */
#ifndef SWIGUNUSED
# if defined(__GNUC__) || defined(__ICC)
#   define SWIGUNUSED __attribute__ ((unused)) 
# else
#   define SWIGUNUSED 
# endif
#endif

/* internal SWIG method */
#ifndef SWIGINTERN
# define SWIGINTERN static SWIGUNUSED
#endif

/* internal inline SWIG method */
#ifndef SWIGINTERNINLINE
# define SWIGINTERNINLINE SWIGINTERN SWIGINLINE
#endif

/* exporting methods for Windows DLLs */
#ifndef SWIGEXPORT
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   if defined(STATIC_LINKED)
#     define SWIGEXPORT
#   else
#     define SWIGEXPORT __declspec(dllexport)
#   endif
# else
#   define SWIGEXPORT
# endif
#endif

/* calling conventions for Windows */
#ifndef SWIGSTDCALL
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   define SWIGSTDCALL __stdcall
# else
#   define SWIGSTDCALL
# endif 
#endif


/* ruby.swg */
/* Implementation : RUBY */
#define SWIGRUBY 1

#include "ruby.h"

/* Flags for pointer conversion */
#define SWIG_POINTER_EXCEPTION     0x1
#define SWIG_POINTER_DISOWN        0x2

#define NUM2USHRT(n) (\
    (0 <= NUM2UINT(n) && NUM2UINT(n) <= USHRT_MAX)\
    ? (unsigned short) NUM2UINT(n) \
    : (rb_raise(rb_eArgError, "integer %d out of range of `unsigned short'",\
               NUM2UINT(n)), (short)0)\
)

#define NUM2SHRT(n) (\
    (SHRT_MIN <= NUM2INT(n) && NUM2INT(n) <= SHRT_MAX)\
    ? (short)NUM2INT(n)\
    : (rb_raise(rb_eArgError, "integer %d out of range of `short'",\
               NUM2INT(n)), (short)0)\
)

/* Ruby 1.7 defines NUM2LL(), LL2NUM() and ULL2NUM() macros */
#ifndef NUM2LL
#define NUM2LL(x) NUM2LONG((x))
#endif
#ifndef LL2NUM
#define LL2NUM(x) INT2NUM((long) (x))
#endif
#ifndef ULL2NUM
#define ULL2NUM(x) UINT2NUM((unsigned long) (x))
#endif

/* Ruby 1.7 doesn't (yet) define NUM2ULL() */
#ifndef NUM2ULL
#ifdef HAVE_LONG_LONG
#define NUM2ULL(x) rb_num2ull((x))
#else
#define NUM2ULL(x) NUM2ULONG(x)
#endif
#endif

/*
 * Need to be very careful about how these macros are defined, especially
 * when compiling C++ code or C code with an ANSI C compiler.
 *
 * VALUEFUNC(f) is a macro used to typecast a C function that implements
 * a Ruby method so that it can be passed as an argument to API functions
 * like rb_define_method() and rb_define_singleton_method().
 *
 * VOIDFUNC(f) is a macro used to typecast a C function that implements
 * either the "mark" or "free" stuff for a Ruby Data object, so that it
 * can be passed as an argument to API functions like Data_Wrap_Struct()
 * and Data_Make_Struct().
 */
 
#ifdef __cplusplus
#  ifndef RUBY_METHOD_FUNC /* These definitions should work for Ruby 1.4.6 */
#    define PROTECTFUNC(f) ((VALUE (*)()) f)
#    define VALUEFUNC(f) ((VALUE (*)()) f)
#    define VOIDFUNC(f)  ((void (*)()) f)
#  else
#    ifndef ANYARGS /* These definitions should work for Ruby 1.6 */
#      define PROTECTFUNC(f) ((VALUE (*)()) f)
#      define VALUEFUNC(f) ((VALUE (*)()) f)
#      define VOIDFUNC(f)  ((RUBY_DATA_FUNC) f)
#    else /* These definitions should work for Ruby 1.7+ */
#      define PROTECTFUNC(f) ((VALUE (*)(VALUE)) f)
#      define VALUEFUNC(f) ((VALUE (*)(ANYARGS)) f)
#      define VOIDFUNC(f)  ((RUBY_DATA_FUNC) f)
#    endif
#  endif
#else
#  define VALUEFUNC(f) (f)
#  define VOIDFUNC(f) (f)
#endif

typedef struct {
  VALUE klass;
  VALUE mImpl;
  void  (*mark)(void *);
  void  (*destroy)(void *);
} swig_class;

/* Don't use for expressions have side effect */
#ifndef RB_STRING_VALUE
#define RB_STRING_VALUE(s) (TYPE(s) == T_STRING ? (s) : (*(volatile VALUE *)&(s) = rb_str_to_str(s)))
#endif
#ifndef StringValue
#define StringValue(s) RB_STRING_VALUE(s)
#endif
#ifndef StringValuePtr
#define StringValuePtr(s) RSTRING(RB_STRING_VALUE(s))->ptr
#endif
#ifndef StringValueLen
#define StringValueLen(s) RSTRING(RB_STRING_VALUE(s))->len
#endif
#ifndef SafeStringValue
#define SafeStringValue(v) do {\
    StringValue(v);\
    rb_check_safe_str(v);\
} while (0)
#endif

#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
#define rb_define_alloc_func(klass, func) rb_define_singleton_method((klass), "new", VALUEFUNC((func)), -1)
#define rb_undef_alloc_func(klass) rb_undef_method(CLASS_OF((klass)), "new")
#endif

/* Contract support */

#define SWIG_contract_assert(expr, msg) if (!(expr)) { rb_raise(rb_eRuntimeError, (char *) msg ); } else



/***********************************************************************
 * swigrun.swg
 *
 *     This file contains generic CAPI SWIG runtime support for pointer
 *     type checking.
 *
 ************************************************************************/

/* This should only be incremented when either the layout of swig_type_info changes,
   or for whatever reason, the runtime changes incompatibly */
#define SWIG_RUNTIME_VERSION "2"

/* define SWIG_TYPE_TABLE_NAME as "SWIG_TYPE_TABLE" */
#ifdef SWIG_TYPE_TABLE
# define SWIG_QUOTE_STRING(x) #x
# define SWIG_EXPAND_AND_QUOTE_STRING(x) SWIG_QUOTE_STRING(x)
# define SWIG_TYPE_TABLE_NAME SWIG_EXPAND_AND_QUOTE_STRING(SWIG_TYPE_TABLE)
#else
# define SWIG_TYPE_TABLE_NAME
#endif

/*
  You can use the SWIGRUNTIME and SWIGRUNTIMEINLINE macros for
  creating a static or dynamic library from the swig runtime code.
  In 99.9% of the cases, swig just needs to declare them as 'static'.
  
  But only do this if is strictly necessary, ie, if you have problems
  with your compiler or so.
*/

#ifndef SWIGRUNTIME
# define SWIGRUNTIME SWIGINTERN
#endif

#ifndef SWIGRUNTIMEINLINE
# define SWIGRUNTIMEINLINE SWIGRUNTIME SWIGINLINE
#endif

#include <string.h>

#ifdef __cplusplus
extern "C" {
#endif

typedef void *(*swig_converter_func)(void *);
typedef struct swig_type_info *(*swig_dycast_func)(void **);

/* Structure to store inforomation on one type */
typedef struct swig_type_info {
  const char             *name;			/* mangled name of this type */
  const char             *str;			/* human readable name of this type */
  swig_dycast_func        dcast;		/* dynamic cast function down a hierarchy */
  struct swig_cast_info  *cast;			/* linked list of types that can cast into this type */
  void                   *clientdata;		/* language specific type data */
} swig_type_info;

/* Structure to store a type and conversion function used for casting */
typedef struct swig_cast_info {
  swig_type_info         *type;			/* pointer to type that is equivalent to this type */
  swig_converter_func     converter;		/* function to cast the void pointers */
  struct swig_cast_info  *next;			/* pointer to next cast in linked list */
  struct swig_cast_info  *prev;			/* pointer to the previous cast */
} swig_cast_info;

/* Structure used to store module information
 * Each module generates one structure like this, and the runtime collects
 * all of these structures and stores them in a circularly linked list.*/
typedef struct swig_module_info {
  swig_type_info         **types;		/* Array of pointers to swig_type_info structures that are in this module */
  size_t                 size;		        /* Number of types in this module */
  struct swig_module_info *next;		/* Pointer to next element in circularly linked list */
  swig_type_info         **type_initial;	/* Array of initially generated type structures */
  swig_cast_info         **cast_initial;	/* Array of initially generated casting structures */
  void                    *clientdata;		/* Language specific module data */
} swig_module_info;


/* 
  Compare two type names skipping the space characters, therefore
  "char*" == "char *" and "Class<int>" == "Class<int >", etc.

  Return 0 when the two name types are equivalent, as in
  strncmp, but skipping ' '.
*/
SWIGRUNTIME int
SWIG_TypeNameComp(const char *f1, const char *l1,
		  const char *f2, const char *l2) {
  for (;(f1 != l1) && (f2 != l2); ++f1, ++f2) {
    while ((*f1 == ' ') && (f1 != l1)) ++f1;
    while ((*f2 == ' ') && (f2 != l2)) ++f2;
    if (*f1 != *f2) return (int)(*f1 - *f2);
  }
  return (l1 - f1) - (l2 - f2);
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if not equal, 1 if equal
*/
SWIGRUNTIME int
SWIG_TypeEquiv(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if equal, -1 if nb < tb, 1 if nb > tb
*/
SWIGRUNTIME int
SWIG_TypeCompare(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}


/* think of this as a c++ template<> or a scheme macro */
#define SWIG_TypeCheck_Template(comparison, ty)         \
  if (ty) {                                             \
    swig_cast_info *iter = ty->cast;                    \
    while (iter) {                                      \
      if (comparison) {                                 \
        if (iter == ty->cast) return iter;              \
        /* Move iter to the top of the linked list */   \
        iter->prev->next = iter->next;                  \
        if (iter->next)                                 \
          iter->next->prev = iter->prev;                \
        iter->next = ty->cast;                          \
        iter->prev = 0;                                 \
        if (ty->cast) ty->cast->prev = iter;            \
        ty->cast = iter;                                \
        return iter;                                    \
      }                                                 \
      iter = iter->next;                                \
    }                                                   \
  }                                                     \
  return 0

/*
  Check the typename
*/
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheck(const char *c, swig_type_info *ty) {
  SWIG_TypeCheck_Template(strcmp(iter->type->name, c) == 0, ty);
}

/* Same as previous function, except strcmp is replaced with a pointer comparison */
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheckStruct(swig_type_info *from, swig_type_info *into) {
  SWIG_TypeCheck_Template(iter->type == from, into);
}

/*
  Cast a pointer up an inheritance hierarchy
*/
SWIGRUNTIMEINLINE void *
SWIG_TypeCast(swig_cast_info *ty, void *ptr) {
  return ((!ty) || (!ty->converter)) ? ptr : (*ty->converter)(ptr);
}

/* 
   Dynamic pointer casting. Down an inheritance hierarchy
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeDynamicCast(swig_type_info *ty, void **ptr) {
  swig_type_info *lastty = ty;
  if (!ty || !ty->dcast) return ty;
  while (ty && (ty->dcast)) {
    ty = (*ty->dcast)(ptr);
    if (ty) lastty = ty;
  }
  return lastty;
}

/*
  Return the name associated with this type
*/
SWIGRUNTIMEINLINE const char *
SWIG_TypeName(const swig_type_info *ty) {
  return ty->name;
}

/*
  Return the pretty name associated with this type,
  that is an unmangled type name in a form presentable to the user.
*/
SWIGRUNTIME const char *
SWIG_TypePrettyName(const swig_type_info *type) {
  /* The "str" field contains the equivalent pretty names of the
     type, separated by vertical-bar characters.  We choose
     to print the last name, as it is often (?) the most
     specific. */
  if (type->str != NULL) {
    const char *last_name = type->str;
    const char *s;
    for (s = type->str; *s; s++)
      if (*s == '|') last_name = s+1;
    return last_name;
  }
  else
    return type->name;
}

/* 
   Set the clientdata field for a type
*/
SWIGRUNTIME void
SWIG_TypeClientData(swig_type_info *ti, void *clientdata) {
  if (!ti->clientdata) {
    swig_cast_info *cast = ti->cast;
    /* if (ti->clientdata == clientdata) return; */
    ti->clientdata = clientdata;
    
    while (cast) {
      if (!cast->converter)
	SWIG_TypeClientData(cast->type, clientdata);
      cast = cast->next;
    }
  }
}

/*
  Search for a swig_type_info structure only by mangled name
  Search is a O(log #types)
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_MangledTypeQueryModule(swig_module_info *start, 
                            swig_module_info *end, 
		            const char *name) {
  swig_module_info *iter = start;
  do {
    if (iter->size) {
      register size_t l = 0;
      register size_t r = iter->size - 1;
      do {
	/* since l+r >= 0, we can (>> 1) instead (/ 2) */
	register size_t i = (l + r) >> 1; 
	const char *iname = iter->types[i]->name;
	if (iname) {
	  register int compare = strcmp(name, iname);
	  if (compare == 0) {	    
	    return iter->types[i];
	  } else if (compare < 0) {
	    if (i) {
	      r = i - 1;
	    } else {
	      break;
	    }
	  } else if (compare > 0) {
	    l = i + 1;
	  }
	} else {
	  break; /* should never happen */
	}
      } while (l <= r);
    }
    iter = iter->next;
  } while (iter != end);
  return 0;
}

/*
  Search for a swig_type_info structure for either a mangled name or a human readable name.
  It first searches the mangled names of the types, which is a O(log #types)
  If a type is not found it then searches the human readable names, which is O(#types).
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeQueryModule(swig_module_info *start, 
                     swig_module_info *end, 
		     const char *name) {
  /* STEP 1: Search the name field using binary search */
  swig_type_info *ret = SWIG_MangledTypeQueryModule(start, end, name);
  if (ret) {
    return ret;
  } else {
    /* STEP 2: If the type hasn't been found, do a complete search
       of the str field (the human readable name) */
    swig_module_info *iter = start;
    do {
      register size_t i = 0;
      for (; i < iter->size; ++i) {
	if (iter->types[i]->str && (SWIG_TypeEquiv(iter->types[i]->str, name)))
	  return iter->types[i];
      }
      iter = iter->next;
    } while (iter != end);
  }
  
  /* neither found a match */
  return 0;
}


/* 
   Pack binary data into a string
*/
SWIGRUNTIME char *
SWIG_PackData(char *c, void *ptr, size_t sz) {
  static const char hex[17] = "0123456789abcdef";
  register const unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu =  u + sz;
  for (; u != eu; ++u) {
    register unsigned char uu = *u;
    *(c++) = hex[(uu & 0xf0) >> 4];
    *(c++) = hex[uu & 0xf];
  }
  return c;
}

/* 
   Unpack binary data from a string
*/
SWIGRUNTIME const char *
SWIG_UnpackData(const char *c, void *ptr, size_t sz) {
  register unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu = u + sz;
  for (; u != eu; ++u) {
    register char d = *(c++);
    register unsigned char uu = 0;
    if ((d >= '0') && (d <= '9'))
      uu = ((d - '0') << 4);
    else if ((d >= 'a') && (d <= 'f'))
      uu = ((d - ('a'-10)) << 4);
    else 
      return (char *) 0;
    d = *(c++);
    if ((d >= '0') && (d <= '9'))
      uu |= (d - '0');
    else if ((d >= 'a') && (d <= 'f'))
      uu |= (d - ('a'-10));
    else 
      return (char *) 0;
    *u = uu;
  }
  return c;
}

/* 
   Pack 'void *' into a string buffer.
*/
SWIGRUNTIME char *
SWIG_PackVoidPtr(char *buff, void *ptr, const char *name, size_t bsz) {
  char *r = buff;
  if ((2*sizeof(void *) + 2) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,&ptr,sizeof(void *));
  if (strlen(name) + 1 > (bsz - (r - buff))) return 0;
  strcpy(r,name);
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackVoidPtr(const char *c, void **ptr, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      *ptr = (void *) 0;
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sizeof(void *));
}

SWIGRUNTIME char *
SWIG_PackDataName(char *buff, void *ptr, size_t sz, const char *name, size_t bsz) {
  char *r = buff;
  size_t lname = (name ? strlen(name) : 0);
  if ((2*sz + 2 + lname) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,ptr,sz);
  if (lname) {
    strncpy(r,name,lname+1);
  } else {
    *r = 0;
  }
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackDataName(const char *c, void *ptr, size_t sz, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      memset(ptr,0,sz);
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sz);
}

#ifdef __cplusplus
}
#endif


/* Common SWIG API */
#define SWIG_ConvertPtr(obj, pp, type, flags) \
  SWIG_Ruby_ConvertPtr(obj, pp, type, flags)
#define SWIG_NewPointerObj(p, type, flags) \
  SWIG_Ruby_NewPointerObj(p, type, flags)
#define SWIG_MustGetPtr(p, type, argnum, flags) \
  SWIG_Ruby_MustGetPtr(p, type, argnum, flags)
#define SWIG_GetModule(clientdata) \
  SWIG_Ruby_GetModule()
#define SWIG_SetModule(clientdata, pointer) \
  SWIG_Ruby_SetModule(pointer)

/* Ruby-specific SWIG API */

#define SWIG_InitRuntime() \
  SWIG_Ruby_InitRuntime()
#define SWIG_define_class(ty) \
  SWIG_Ruby_define_class(ty)
#define SWIG_NewClassInstance(value, ty) \
  SWIG_Ruby_NewClassInstance(value, ty)
#define SWIG_MangleStr(value) \
  SWIG_Ruby_MangleStr(value)
#define SWIG_CheckConvert(value, ty) \
  SWIG_Ruby_CheckConvert(value, ty)
#define SWIG_NewPackedObj(ptr, sz, ty) \
  SWIG_Ruby_NewPackedObj(ptr, sz, ty)
#define SWIG_ConvertPacked(obj, ptr, sz, ty, flags) \
  SWIG_Ruby_ConvertPacked(obj, ptr, sz, ty, flags)

/* rubydef.swg */
#ifdef __cplusplus
extern "C" {
#endif

static VALUE _mSWIG = Qnil;
static VALUE _cSWIG_Pointer = Qnil;
static VALUE swig_runtime_data_type_pointer = Qnil;

/* Initialize Ruby runtime support */
static void
SWIG_Ruby_InitRuntime(void)
{
    if (_mSWIG == Qnil) {
        _mSWIG = rb_define_module("SWIG");
    }
}

/* Define Ruby class for C type */
static void
SWIG_Ruby_define_class(swig_type_info *type)
{
    VALUE klass;
    char *klass_name = (char *) malloc(4 + strlen(type->name) + 1);
    sprintf(klass_name, "TYPE%s", type->name);
    if (NIL_P(_cSWIG_Pointer)) {
	_cSWIG_Pointer = rb_define_class_under(_mSWIG, "Pointer", rb_cObject);
	rb_undef_method(CLASS_OF(_cSWIG_Pointer), "new");
    }
    klass = rb_define_class_under(_mSWIG, klass_name, _cSWIG_Pointer);
    free((void *) klass_name);
}

/* Create a new pointer object */
static VALUE
SWIG_Ruby_NewPointerObj(void *ptr, swig_type_info *type, int own)
{
    char *klass_name;
    swig_class *sklass;
    VALUE klass;
    VALUE obj;
    
    if (!ptr)
	return Qnil;
    
    if (type->clientdata) {
      sklass = (swig_class *) type->clientdata;
      obj = Data_Wrap_Struct(sklass->klass, VOIDFUNC(sklass->mark), (own ? VOIDFUNC(sklass->destroy) : 0), ptr);
    } else {
      klass_name = (char *) malloc(4 + strlen(type->name) + 1);
      sprintf(klass_name, "TYPE%s", type->name);
      klass = rb_const_get(_mSWIG, rb_intern(klass_name));
      free((void *) klass_name);
      obj = Data_Wrap_Struct(klass, 0, 0, ptr);
    }
    rb_iv_set(obj, "__swigtype__", rb_str_new2(type->name));
    return obj;
}

/* Create a new class instance (always owned) */
static VALUE
SWIG_Ruby_NewClassInstance(VALUE klass, swig_type_info *type)
{
    VALUE obj;
    swig_class *sklass = (swig_class *) type->clientdata;
    obj = Data_Wrap_Struct(klass, VOIDFUNC(sklass->mark), VOIDFUNC(sklass->destroy), 0);
    rb_iv_set(obj, "__swigtype__", rb_str_new2(type->name));
    return obj;
}

/* Get type mangle from class name */
static SWIGINLINE char *
SWIG_Ruby_MangleStr(VALUE obj)
{
  VALUE stype = rb_iv_get(obj, "__swigtype__");
  return StringValuePtr(stype);
}

/* Convert a pointer value */
static int
SWIG_Ruby_ConvertPtr(VALUE obj, void **ptr, swig_type_info *ty, int flags)
{
  char *c;
  swig_cast_info *tc;

  /* Grab the pointer */
  if (NIL_P(obj)) {
    *ptr = 0;
    return 0;
  } else {
    Data_Get_Struct(obj, void, *ptr);
  }
  
  /* Do type-checking if type info was provided */
  if (ty) {
    if (ty->clientdata) {
        if (rb_obj_is_kind_of(obj, ((swig_class *) (ty->clientdata))->klass)) {
          if (*ptr == 0)
            rb_raise(rb_eRuntimeError, "This %s already released", ty->str);
          return 0;
        }
    }
    if ((c = SWIG_MangleStr(obj)) == NULL) {
      if (flags & SWIG_POINTER_EXCEPTION)
        rb_raise(rb_eTypeError, "Expected %s", ty->str);
      else
        return -1;
    }
    tc = SWIG_TypeCheck(c, ty);
    if (!tc) {
      if (flags & SWIG_POINTER_EXCEPTION)
        rb_raise(rb_eTypeError, "Expected %s", ty->str);
      else
        return -1;
    }
    *ptr = SWIG_TypeCast(tc, *ptr);
  }
  return 0;
}

/* Convert a pointer value, signal an exception on a type mismatch */
static SWIGINLINE void *
SWIG_Ruby_MustGetPtr(VALUE obj, swig_type_info *ty, int argnum, int flags)
{
  void *result;
  SWIG_ConvertPtr(obj, &result, ty, flags | SWIG_POINTER_EXCEPTION);
  return result;
}

/* Check convert */
static SWIGINLINE int
SWIG_Ruby_CheckConvert(VALUE obj, swig_type_info *ty)
{
  char *c = SWIG_MangleStr(obj);
  if (!c)
    return 0;
  return SWIG_TypeCheck(c,ty) != 0;
}

static VALUE
SWIG_Ruby_NewPackedObj(void *ptr, int sz, swig_type_info *type) {
  char result[1024];
  char *r = result;
  if ((2*sz + 1 + strlen(type->name)) > 1000) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r, ptr, sz);
  strcpy(r, type->name);
  return rb_str_new2(result);
}

/* Convert a packed value value */
static void
SWIG_Ruby_ConvertPacked(VALUE obj, void *ptr, int sz, swig_type_info *ty, int flags) {
  swig_cast_info *tc;
  const char  *c;

  if (TYPE(obj) != T_STRING) goto type_error;
  c = StringValuePtr(obj);
  /* Pointer values must start with leading underscore */
  if (*c != '_') goto type_error;
  c++;
  c = SWIG_UnpackData(c, ptr, sz);
  if (ty) {
    tc = SWIG_TypeCheck(c, ty);
    if (!tc) goto type_error;
  }
  return;

type_error:

  if (flags) {
    if (ty) {
      rb_raise(rb_eTypeError, "Type error. Expected %s", ty->name);
    } else {
      rb_raise(rb_eTypeError, "Expected a pointer");
    }
  }
}

static swig_module_info *SWIG_Ruby_GetModule() {
    VALUE pointer;
    swig_module_info *ret = 0;

   /* first check if pointer already created */
    pointer = rb_gv_get("$swig_runtime_data_type_pointer" SWIG_RUNTIME_VERSION SWIG_TYPE_TABLE_NAME);
    if (pointer != Qnil) {
      Data_Get_Struct(pointer, swig_module_info, ret);
    }
    return ret;
}

static void SWIG_Ruby_SetModule(swig_module_info *pointer) {
      /* register a new class */
      VALUE cl = rb_define_class("swig_runtime_data", rb_cObject);
      /* create and store the structure pointer to a global variable */
      swig_runtime_data_type_pointer = Data_Wrap_Struct(cl, 0, 0, pointer);
      rb_define_readonly_variable("$swig_runtime_data_type_pointer" SWIG_RUNTIME_VERSION SWIG_TYPE_TABLE_NAME, &swig_runtime_data_type_pointer);
}

#ifdef __cplusplus
}
#endif




/* -------- TYPES TABLE (BEGIN) -------- */

#define SWIGTYPE_p_apr_array_header_t swig_types[0]
#define SWIGTYPE_p_apr_file_t swig_types[1]
#define SWIGTYPE_p_apr_hash_t swig_types[2]
#define SWIGTYPE_p_apr_int32_t swig_types[3]
#define SWIGTYPE_p_apr_int64_t swig_types[4]
#define SWIGTYPE_p_apr_pool_t swig_types[5]
#define SWIGTYPE_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void swig_types[6]
#define SWIGTYPE_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[7]
#define SWIGTYPE_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[8]
#define SWIGTYPE_p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t swig_types[9]
#define SWIGTYPE_p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[10]
#define SWIGTYPE_p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[11]
#define SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t swig_types[12]
#define SWIGTYPE_p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t swig_types[13]
#define SWIGTYPE_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[14]
#define SWIGTYPE_p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[15]
#define SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[16]
#define SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[17]
#define SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[18]
#define SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[19]
#define SWIGTYPE_p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[20]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[21]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[22]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t swig_types[23]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t swig_types[24]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t swig_types[25]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[26]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t swig_types[27]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t swig_types[28]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t swig_types[29]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t swig_types[30]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t swig_types[31]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t swig_types[32]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[33]
#define SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[34]
#define SWIGTYPE_p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t swig_types[35]
#define SWIGTYPE_p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t swig_types[36]
#define SWIGTYPE_p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t swig_types[37]
#define SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t swig_types[38]
#define SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t swig_types[39]
#define SWIGTYPE_p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t swig_types[40]
#define SWIGTYPE_p_f_void__p_svn_version_t swig_types[41]
#define SWIGTYPE_p_int swig_types[42]
#define SWIGTYPE_p_long swig_types[43]
#define SWIGTYPE_p_p_apr_file_t swig_types[44]
#define SWIGTYPE_p_p_apr_hash_t swig_types[45]
#define SWIGTYPE_p_p_char swig_types[46]
#define SWIGTYPE_p_p_svn_delta_editor_t swig_types[47]
#define SWIGTYPE_p_p_svn_dirent_t swig_types[48]
#define SWIGTYPE_p_p_svn_lock_t swig_types[49]
#define SWIGTYPE_p_p_svn_ra_callbacks2_t swig_types[50]
#define SWIGTYPE_p_p_svn_ra_plugin_t swig_types[51]
#define SWIGTYPE_p_p_svn_ra_reporter2_t swig_types[52]
#define SWIGTYPE_p_p_svn_ra_reporter_t swig_types[53]
#define SWIGTYPE_p_p_svn_ra_session_t swig_types[54]
#define SWIGTYPE_p_p_svn_string_t swig_types[55]
#define SWIGTYPE_p_p_svn_stringbuf_t swig_types[56]
#define SWIGTYPE_p_p_void swig_types[57]
#define SWIGTYPE_p_svn_auth_baton_t swig_types[58]
#define SWIGTYPE_p_svn_auth_cred_simple_t swig_types[59]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_pw_t swig_types[60]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_t swig_types[61]
#define SWIGTYPE_p_svn_auth_cred_ssl_server_trust_t swig_types[62]
#define SWIGTYPE_p_svn_auth_cred_username_t swig_types[63]
#define SWIGTYPE_p_svn_auth_iterstate_t swig_types[64]
#define SWIGTYPE_p_svn_auth_provider_object_t swig_types[65]
#define SWIGTYPE_p_svn_auth_provider_t swig_types[66]
#define SWIGTYPE_p_svn_auth_ssl_server_cert_info_t swig_types[67]
#define SWIGTYPE_p_svn_commit_info_t swig_types[68]
#define SWIGTYPE_p_svn_config_t swig_types[69]
#define SWIGTYPE_p_svn_delta_editor_t swig_types[70]
#define SWIGTYPE_p_svn_diff_datasource_e swig_types[71]
#define SWIGTYPE_p_svn_diff_file_ignore_space_t swig_types[72]
#define SWIGTYPE_p_svn_diff_file_options_t swig_types[73]
#define SWIGTYPE_p_svn_diff_fns_t swig_types[74]
#define SWIGTYPE_p_svn_diff_output_fns_t swig_types[75]
#define SWIGTYPE_p_svn_diff_t swig_types[76]
#define SWIGTYPE_p_svn_dirent_t swig_types[77]
#define SWIGTYPE_p_svn_errno_t swig_types[78]
#define SWIGTYPE_p_svn_error_t swig_types[79]
#define SWIGTYPE_p_svn_io_dirent_t swig_types[80]
#define SWIGTYPE_p_svn_io_file_del_t swig_types[81]
#define SWIGTYPE_p_svn_lock_t swig_types[82]
#define SWIGTYPE_p_svn_log_changed_path_t swig_types[83]
#define SWIGTYPE_p_svn_node_kind_t swig_types[84]
#define SWIGTYPE_p_svn_opt_revision_t swig_types[85]
#define SWIGTYPE_p_svn_opt_revision_value_t swig_types[86]
#define SWIGTYPE_p_svn_opt_subcommand_desc2_t swig_types[87]
#define SWIGTYPE_p_svn_opt_subcommand_desc_t swig_types[88]
#define SWIGTYPE_p_svn_prop_kind swig_types[89]
#define SWIGTYPE_p_svn_prop_t swig_types[90]
#define SWIGTYPE_p_svn_ra_callbacks2_t swig_types[91]
#define SWIGTYPE_p_svn_ra_callbacks_t swig_types[92]
#define SWIGTYPE_p_svn_ra_plugin_t swig_types[93]
#define SWIGTYPE_p_svn_ra_reporter2_t swig_types[94]
#define SWIGTYPE_p_svn_ra_reporter_t swig_types[95]
#define SWIGTYPE_p_svn_ra_session_t swig_types[96]
#define SWIGTYPE_p_svn_stream_t swig_types[97]
#define SWIGTYPE_p_svn_string_t swig_types[98]
#define SWIGTYPE_p_svn_stringbuf_t swig_types[99]
#define SWIGTYPE_p_svn_txdelta_op_t swig_types[100]
#define SWIGTYPE_p_svn_txdelta_stream_t swig_types[101]
#define SWIGTYPE_p_svn_txdelta_window_t swig_types[102]
#define SWIGTYPE_p_svn_version_checklist_t swig_types[103]
#define SWIGTYPE_p_svn_version_t swig_types[104]
#define SWIGTYPE_p_unsigned_long swig_types[105]
#define SWIGTYPE_p_void swig_types[106]
static swig_type_info *swig_types[107];
static swig_module_info swig_module = {swig_types, 107, 0, 0, 0, 0};
#define SWIG_TypeQuery(name) SWIG_TypeQueryModule(&swig_module, &swig_module, name)
#define SWIG_MangledTypeQuery(name) SWIG_MangledTypeQueryModule(&swig_module, &swig_module, name)

/* -------- TYPES TABLE (END) -------- */

#define SWIG_init    Init_ra
#define SWIG_name    "Svn::Ext::Ra"

static VALUE mRa;

static void SWIG_AsVal(VALUE obj, int *val)
{
    *val = (int) NUM2INT(obj);
}


#ifdef __cplusplus
extern "C" {
#endif
#ifdef HAVE_SYS_TIME_H
# include <sys/time.h>
struct timeval rb_time_timeval(VALUE);
#endif
#ifdef __cplusplus
}
#endif


#ifdef __cplusplus
extern "C" {
#endif
#include "rubyio.h"
#ifdef __cplusplus
}
#endif


static VALUE _global_svn_swig_rb_pool = Qnil;


#include "svn_time.h"
#include "svn_pools.h"


#ifdef SWIGPYTHON
#include "swigutil_py.h"
#endif

#ifdef SWIGPERL
#include "swigutil_pl.h"
#endif

#ifdef SWIGRUBY
#include "swigutil_rb.h"
#endif


#include "svn_ra.h"


static VALUE output_helper(VALUE target, VALUE o) {
    if (NIL_P(target)) {
	target = o;
    } else {
	if (TYPE(target) != T_ARRAY) {
	    VALUE o2 = target;
	    target = rb_ary_new();
	    rb_ary_push(target, o2);
	}
	rb_ary_push(target, o);
    }
    return target;
}


static svn_error_t *svn_ra_reporter2_invoke_set_path(
  svn_ra_reporter2_t *_obj, void *report_baton, const char *path, svn_revnum_t revision, svn_boolean_t start_empty, const char *lock_token, apr_pool_t *pool) {
  return _obj->set_path(report_baton, path, revision, start_empty, lock_token, pool);
}

static svn_error_t *svn_ra_reporter2_invoke_delete_path(
  svn_ra_reporter2_t *_obj, void *report_baton, const char *path, apr_pool_t *pool) {
  return _obj->delete_path(report_baton, path, pool);
}

static svn_error_t *svn_ra_reporter2_invoke_link_path(
  svn_ra_reporter2_t *_obj, void *report_baton, const char *path, const char *url, svn_revnum_t revision, svn_boolean_t start_empty, const char *lock_token, apr_pool_t *pool) {
  return _obj->link_path(report_baton, path, url, revision, start_empty, lock_token, pool);
}

static svn_error_t *svn_ra_reporter2_invoke_finish_report(
  svn_ra_reporter2_t *_obj, void *report_baton, apr_pool_t *pool) {
  return _obj->finish_report(report_baton, pool);
}

static svn_error_t *svn_ra_reporter2_invoke_abort_report(
  svn_ra_reporter2_t *_obj, void *report_baton, apr_pool_t *pool) {
  return _obj->abort_report(report_baton, pool);
}

static svn_error_t *svn_ra_reporter_invoke_set_path(
  svn_ra_reporter_t *_obj, void *report_baton, const char *path, svn_revnum_t revision, svn_boolean_t start_empty, apr_pool_t *pool) {
  return _obj->set_path(report_baton, path, revision, start_empty, pool);
}

static svn_error_t *svn_ra_reporter_invoke_delete_path(
  svn_ra_reporter_t *_obj, void *report_baton, const char *path, apr_pool_t *pool) {
  return _obj->delete_path(report_baton, path, pool);
}

static svn_error_t *svn_ra_reporter_invoke_link_path(
  svn_ra_reporter_t *_obj, void *report_baton, const char *path, const char *url, svn_revnum_t revision, svn_boolean_t start_empty, apr_pool_t *pool) {
  return _obj->link_path(report_baton, path, url, revision, start_empty, pool);
}

static svn_error_t *svn_ra_reporter_invoke_finish_report(
  svn_ra_reporter_t *_obj, void *report_baton, apr_pool_t *pool) {
  return _obj->finish_report(report_baton, pool);
}

static svn_error_t *svn_ra_reporter_invoke_abort_report(
  svn_ra_reporter_t *_obj, void *report_baton, apr_pool_t *pool) {
  return _obj->abort_report(report_baton, pool);
}

static svn_error_t *svn_ra_callbacks2_invoke_open_tmp_file(
  svn_ra_callbacks2_t *_obj, apr_file_t **fp, void *callback_baton, apr_pool_t *pool) {
  return _obj->open_tmp_file(fp, callback_baton, pool);
}

static svn_error_t *svn_ra_callbacks_invoke_open_tmp_file(
  svn_ra_callbacks_t *_obj, apr_file_t **fp, void *callback_baton, apr_pool_t *pool) {
  return _obj->open_tmp_file(fp, callback_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_open(
  svn_ra_plugin_t *_obj, void **session_baton, const char *repos_URL, const svn_ra_callbacks_t *callbacks, void *callback_baton, apr_hash_t *config, apr_pool_t *pool) {
  return _obj->open(session_baton, repos_URL, callbacks, callback_baton, config, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_latest_revnum(
  svn_ra_plugin_t *_obj, void *session_baton, svn_revnum_t *latest_revnum, apr_pool_t *pool) {
  return _obj->get_latest_revnum(session_baton, latest_revnum, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_dated_revision(
  svn_ra_plugin_t *_obj, void *session_baton, svn_revnum_t *revision, apr_time_t tm, apr_pool_t *pool) {
  return _obj->get_dated_revision(session_baton, revision, tm, pool);
}

static svn_error_t *svn_ra_plugin_invoke_change_rev_prop(
  svn_ra_plugin_t *_obj, void *session_baton, svn_revnum_t rev, const char *name, const svn_string_t *value, apr_pool_t *pool) {
  return _obj->change_rev_prop(session_baton, rev, name, value, pool);
}

static svn_error_t *svn_ra_plugin_invoke_rev_proplist(
  svn_ra_plugin_t *_obj, void *session_baton, svn_revnum_t rev, apr_hash_t **props, apr_pool_t *pool) {
  return _obj->rev_proplist(session_baton, rev, props, pool);
}

static svn_error_t *svn_ra_plugin_invoke_rev_prop(
  svn_ra_plugin_t *_obj, void *session_baton, svn_revnum_t rev, const char *name, svn_string_t **value, apr_pool_t *pool) {
  return _obj->rev_prop(session_baton, rev, name, value, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_commit_editor(
  svn_ra_plugin_t *_obj, void *session_baton, const svn_delta_editor_t **editor, void **edit_baton, const char *log_msg, svn_commit_callback_t callback, void *callback_baton, apr_pool_t *pool) {
  return _obj->get_commit_editor(session_baton, editor, edit_baton, log_msg, callback, callback_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_file(
  svn_ra_plugin_t *_obj, void *session_baton, const char *path, svn_revnum_t revision, svn_stream_t *stream, svn_revnum_t *fetched_rev, apr_hash_t **props, apr_pool_t *pool) {
  return _obj->get_file(session_baton, path, revision, stream, fetched_rev, props, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_dir(
  svn_ra_plugin_t *_obj, void *session_baton, const char *path, svn_revnum_t revision, apr_hash_t **dirents, svn_revnum_t *fetched_rev, apr_hash_t **props, apr_pool_t *pool) {
  return _obj->get_dir(session_baton, path, revision, dirents, fetched_rev, props, pool);
}

static svn_error_t *svn_ra_plugin_invoke_do_update(
  svn_ra_plugin_t *_obj, void *session_baton, const svn_ra_reporter_t **reporter, void **report_baton, svn_revnum_t revision_to_update_to, const char *update_target, svn_boolean_t recurse, const svn_delta_editor_t *update_editor, void *update_baton, apr_pool_t *pool) {
  return _obj->do_update(session_baton, reporter, report_baton, revision_to_update_to, update_target, recurse, update_editor, update_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_do_switch(
  svn_ra_plugin_t *_obj, void *session_baton, const svn_ra_reporter_t **reporter, void **report_baton, svn_revnum_t revision_to_switch_to, const char *switch_target, svn_boolean_t recurse, const char *switch_url, const svn_delta_editor_t *switch_editor, void *switch_baton, apr_pool_t *pool) {
  return _obj->do_switch(session_baton, reporter, report_baton, revision_to_switch_to, switch_target, recurse, switch_url, switch_editor, switch_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_do_status(
  svn_ra_plugin_t *_obj, void *session_baton, const svn_ra_reporter_t **reporter, void **report_baton, const char *status_target, svn_revnum_t revision, svn_boolean_t recurse, const svn_delta_editor_t *status_editor, void *status_baton, apr_pool_t *pool) {
  return _obj->do_status(session_baton, reporter, report_baton, status_target, revision, recurse, status_editor, status_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_do_diff(
  svn_ra_plugin_t *_obj, void *session_baton, const svn_ra_reporter_t **reporter, void **report_baton, svn_revnum_t revision, const char *diff_target, svn_boolean_t recurse, svn_boolean_t ignore_ancestry, const char *versus_url, const svn_delta_editor_t *diff_editor, void *diff_baton, apr_pool_t *pool) {
  return _obj->do_diff(session_baton, reporter, report_baton, revision, diff_target, recurse, ignore_ancestry, versus_url, diff_editor, diff_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_log(
  svn_ra_plugin_t *_obj, void *session_baton, const apr_array_header_t *paths, svn_revnum_t start, svn_revnum_t end, svn_boolean_t discover_changed_paths, svn_boolean_t strict_node_history, svn_log_message_receiver_t receiver, void *receiver_baton, apr_pool_t *pool) {
  return _obj->get_log(session_baton, paths, start, end, discover_changed_paths, strict_node_history, receiver, receiver_baton, pool);
}

static svn_error_t *svn_ra_plugin_invoke_check_path(
  svn_ra_plugin_t *_obj, void *session_baton, const char *path, svn_revnum_t revision, svn_node_kind_t *kind, apr_pool_t *pool) {
  return _obj->check_path(session_baton, path, revision, kind, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_uuid(
  svn_ra_plugin_t *_obj, void *session_baton, const char **uuid, apr_pool_t *pool) {
  return _obj->get_uuid(session_baton, uuid, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_repos_root(
  svn_ra_plugin_t *_obj, void *session_baton, const char **url, apr_pool_t *pool) {
  return _obj->get_repos_root(session_baton, url, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_locations(
  svn_ra_plugin_t *_obj, void *session_baton, apr_hash_t **locations, const char *path, svn_revnum_t peg_revision, apr_array_header_t *location_revisions, apr_pool_t *pool) {
  return _obj->get_locations(session_baton, locations, path, peg_revision, location_revisions, pool);
}

static svn_error_t *svn_ra_plugin_invoke_get_file_revs(
  svn_ra_plugin_t *_obj, void *session_baton, const char *path, svn_revnum_t start, svn_revnum_t end, svn_ra_file_rev_handler_t handler, void *handler_baton, apr_pool_t *pool) {
  return _obj->get_file_revs(session_baton, path, start, end, handler, handler_baton, pool);
}


static VALUE
_wrap_svn_ra_version(int argc, VALUE *argv, VALUE self) {
    svn_version_t *result;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_version_t *)svn_ra_version();
        
        
        
        
    }
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_version_t,0);
    return vresult;
}


swig_class cSvn_ra_reporter2_t;

static VALUE
_wrap_svn_ra_reporter2_t_set_path_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->set_path = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_reporter2_t_set_path_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)) ((arg1)->set_path);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter2_t_delete_path_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->delete_path = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_reporter2_t_delete_path_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,apr_pool_t *)) ((arg1)->delete_path);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter2_t_link_path_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->link_path = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_reporter2_t_link_path_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)) ((arg1)->link_path);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter2_t_finish_report_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    svn_error_t *(*arg2)(void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->finish_report = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_reporter2_t_finish_report_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    svn_error_t *(*result)(void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,apr_pool_t *)) ((arg1)->finish_report);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter2_t_abort_report_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    svn_error_t *(*arg2)(void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->abort_report = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_reporter2_t_abort_report_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    svn_error_t *(*result)(void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,apr_pool_t *)) ((arg1)->abort_report);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_ra_reporter2_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_ra_reporter2_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_ra_reporter2_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_ra_reporter2_t(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_ra_reporter2_t *)(svn_ra_reporter2_t *) calloc(1, sizeof(svn_ra_reporter2_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_ra_reporter2_t(svn_ra_reporter2_t *arg1) {
    free((char *) arg1);
}
swig_class cSvn_ra_reporter_t;

static VALUE
_wrap_svn_ra_reporter_t_set_path_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->set_path = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_reporter_t_set_path_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)) ((arg1)->set_path);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter_t_delete_path_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->delete_path = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_reporter_t_delete_path_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,apr_pool_t *)) ((arg1)->delete_path);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter_t_link_path_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->link_path = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_reporter_t_link_path_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)) ((arg1)->link_path);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter_t_finish_report_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    svn_error_t *(*arg2)(void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->finish_report = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_reporter_t_finish_report_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    svn_error_t *(*result)(void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,apr_pool_t *)) ((arg1)->finish_report);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter_t_abort_report_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    svn_error_t *(*arg2)(void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->abort_report = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_reporter_t_abort_report_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    svn_error_t *(*result)(void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,apr_pool_t *)) ((arg1)->abort_report);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_ra_reporter_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_ra_reporter_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_ra_reporter_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_ra_reporter_t(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_ra_reporter_t *)(svn_ra_reporter_t *) calloc(1, sizeof(svn_ra_reporter_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_ra_reporter_t(svn_ra_reporter_t *arg1) {
    free((char *) arg1);
}
swig_class cSvn_ra_callbacks2_t;

static VALUE
_wrap_svn_ra_callbacks2_t_open_tmp_file_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_error_t *(*arg2)(apr_file_t **,void *,apr_pool_t *) = (svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->open_tmp_file = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks2_t_open_tmp_file_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_error_t *(*result)(apr_file_t **,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    result = (svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)) ((arg1)->open_tmp_file);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks2_t_auth_baton_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_auth_baton_t *arg2 = (svn_auth_baton_t *) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_auth_baton_t, 1);
        
        
        
        arg2 = (svn_auth_baton_t *)temp2;
    }
    if (arg1) (arg1)->auth_baton = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks2_t_auth_baton_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_auth_baton_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    result = (svn_auth_baton_t *) ((arg1)->auth_baton);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_auth_baton_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks2_t_get_wc_prop_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_ra_get_wc_prop_func_t arg2 = (svn_ra_get_wc_prop_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_ra_get_wc_prop_func_t)temp2;
    }
    if (arg1) (arg1)->get_wc_prop = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks2_t_get_wc_prop_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_ra_get_wc_prop_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    result = (svn_ra_get_wc_prop_func_t) ((arg1)->get_wc_prop);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks2_t_set_wc_prop_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_ra_set_wc_prop_func_t arg2 = (svn_ra_set_wc_prop_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_ra_set_wc_prop_func_t)temp2;
    }
    if (arg1) (arg1)->set_wc_prop = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks2_t_set_wc_prop_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_ra_set_wc_prop_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    result = (svn_ra_set_wc_prop_func_t) ((arg1)->set_wc_prop);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks2_t_push_wc_prop_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_ra_push_wc_prop_func_t arg2 = (svn_ra_push_wc_prop_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_ra_push_wc_prop_func_t)temp2;
    }
    if (arg1) (arg1)->push_wc_prop = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks2_t_push_wc_prop_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_ra_push_wc_prop_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    result = (svn_ra_push_wc_prop_func_t) ((arg1)->push_wc_prop);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks2_t_invalidate_wc_props_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_ra_invalidate_wc_props_func_t arg2 = (svn_ra_invalidate_wc_props_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_ra_invalidate_wc_props_func_t)temp2;
    }
    if (arg1) (arg1)->invalidate_wc_props = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks2_t_invalidate_wc_props_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_ra_invalidate_wc_props_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    result = (svn_ra_invalidate_wc_props_func_t) ((arg1)->invalidate_wc_props);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks2_t_progress_func_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_ra_progress_notify_func_t arg2 = (svn_ra_progress_notify_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void, 1);
        
        
        
        arg2 = (svn_ra_progress_notify_func_t)temp2;
    }
    if (arg1) (arg1)->progress_func = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks2_t_progress_func_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    svn_ra_progress_notify_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    result = (svn_ra_progress_notify_func_t) ((arg1)->progress_func);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks2_t_progress_baton_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[0], (void **) &arg2, 0, 1);
    if (arg1) (arg1)->progress_baton = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks2_t_progress_baton_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    void *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    result = (void *) ((arg1)->progress_baton);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_void,0);
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_ra_callbacks2_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_ra_callbacks2_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_ra_callbacks2_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_ra_callbacks2_t(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_ra_callbacks2_t *)(svn_ra_callbacks2_t *) calloc(1, sizeof(svn_ra_callbacks2_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_ra_callbacks2_t(svn_ra_callbacks2_t *arg1) {
    free((char *) arg1);
}
swig_class cSvn_ra_callbacks_t;

static VALUE
_wrap_svn_ra_callbacks_t_open_tmp_file_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_error_t *(*arg2)(apr_file_t **,void *,apr_pool_t *) = (svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->open_tmp_file = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks_t_open_tmp_file_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_error_t *(*result)(apr_file_t **,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    result = (svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)) ((arg1)->open_tmp_file);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks_t_auth_baton_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_auth_baton_t *arg2 = (svn_auth_baton_t *) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_svn_auth_baton_t, 1);
        
        
        
        arg2 = (svn_auth_baton_t *)temp2;
    }
    if (arg1) (arg1)->auth_baton = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks_t_auth_baton_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_auth_baton_t *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    result = (svn_auth_baton_t *) ((arg1)->auth_baton);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_svn_auth_baton_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks_t_get_wc_prop_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_ra_get_wc_prop_func_t arg2 = (svn_ra_get_wc_prop_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_ra_get_wc_prop_func_t)temp2;
    }
    if (arg1) (arg1)->get_wc_prop = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks_t_get_wc_prop_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_ra_get_wc_prop_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    result = (svn_ra_get_wc_prop_func_t) ((arg1)->get_wc_prop);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks_t_set_wc_prop_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_ra_set_wc_prop_func_t arg2 = (svn_ra_set_wc_prop_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_ra_set_wc_prop_func_t)temp2;
    }
    if (arg1) (arg1)->set_wc_prop = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks_t_set_wc_prop_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_ra_set_wc_prop_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    result = (svn_ra_set_wc_prop_func_t) ((arg1)->set_wc_prop);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks_t_push_wc_prop_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_ra_push_wc_prop_func_t arg2 = (svn_ra_push_wc_prop_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_ra_push_wc_prop_func_t)temp2;
    }
    if (arg1) (arg1)->push_wc_prop = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks_t_push_wc_prop_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_ra_push_wc_prop_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    result = (svn_ra_push_wc_prop_func_t) ((arg1)->push_wc_prop);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks_t_invalidate_wc_props_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_ra_invalidate_wc_props_func_t arg2 = (svn_ra_invalidate_wc_props_func_t) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_ra_invalidate_wc_props_func_t)temp2;
    }
    if (arg1) (arg1)->invalidate_wc_props = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_callbacks_t_invalidate_wc_props_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    svn_ra_invalidate_wc_props_func_t result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    result = (svn_ra_invalidate_wc_props_func_t) ((arg1)->invalidate_wc_props);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_ra_callbacks_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_ra_callbacks_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_ra_callbacks_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_ra_callbacks_t(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_ra_callbacks_t *)(svn_ra_callbacks_t *) calloc(1, sizeof(svn_ra_callbacks_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_ra_callbacks_t(svn_ra_callbacks_t *arg1) {
    free((char *) arg1);
}
static VALUE
_wrap_svn_ra_initialize(int argc, VALUE *argv, VALUE self) {
    apr_pool_t *arg1 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg1);
        _global_pool = arg1;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 0) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    if (argc > 0) {
        
    }
    {
        result = (svn_error_t *)svn_ra_initialize(arg1);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_create_callbacks(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t **arg1 = (svn_ra_callbacks2_t **) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t **)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_ra_create_callbacks(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_open2(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t **arg1 = (svn_ra_session_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_ra_callbacks2_t *arg3 = (svn_ra_callbacks2_t *) 0 ;
    void *arg4 = (void *) 0 ;
    apr_hash_t *arg5 = (apr_hash_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_ra_session_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_ra_session_t **)&temp1;
    }
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        svn_swig_rb_setup_ra_callbacks(&arg3, &arg4, argv[1], _global_pool);
    }
    {
        if (NIL_P(argv[2])) {
            arg5 = NULL;
        } else {
            arg5 = svn_swig_rb_hash_to_apr_hash_swig_type(argv[2], "svn_config_t *", _global_pool);
        }
    }
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_ra_open2(arg1,(char const *)arg2,(struct svn_ra_callbacks2_t const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_ra_session_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_open(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t **arg1 = (svn_ra_session_t **) 0 ;
    char *arg2 = (char *) 0 ;
    svn_ra_callbacks_t *arg3 = (svn_ra_callbacks_t *) 0 ;
    void *arg4 = (void *) 0 ;
    apr_hash_t *arg5 = (apr_hash_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_ra_session_t *temp1 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_ra_session_t **)&temp1;
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    arg2 = StringValuePtr(argv[0]);
    {
        SWIG_ConvertPtr(argv[1], &temp3, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg3 = (svn_ra_callbacks_t *)temp3;
    }
    SWIG_ConvertPtr(argv[2], (void **) &arg4, 0, 1);
    {
        if (NIL_P(argv[3])) {
            arg5 = NULL;
        } else {
            arg5 = svn_swig_rb_hash_to_apr_hash_swig_type(argv[3], "svn_config_t *", _global_pool);
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_ra_open(arg1,(char const *)arg2,(struct svn_ra_callbacks_t const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_ra_session_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_reparent(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    char *arg2 = (char *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_reparent(arg1,(char const *)arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_latest_revnum(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_revnum_t *arg2 = (svn_revnum_t *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_revnum_t temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg2 = &temp2;
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_latest_revnum(arg1,arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg2));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_dated_revision(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_revnum_t *arg2 = (svn_revnum_t *) 0 ;
    apr_time_t arg3 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_revnum_t temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg2 = &temp2;
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg3 = (apr_time_t) NUM2LL(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_dated_revision(arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg2));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_change_rev_prop(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_revnum_t arg2 ;
    char *arg3 = (char *) 0 ;
    svn_string_t *arg4 = (svn_string_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_string_t value4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg2 = NUM2LONG(argv[1]);
    arg3 = StringValuePtr(argv[2]);
    {
        if (NIL_P(argv[3])) {
            arg4 = NULL;
        } else {
            value4.data = StringValuePtr(argv[3]);
            value4.len = RSTRING(argv[3])->len;
            arg4 = &value4;
        }
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_ra_change_rev_prop(arg1,arg2,(char const *)arg3,(struct svn_string_t const *)arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_rev_proplist(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_revnum_t arg2 ;
    apr_hash_t **arg3 = (apr_hash_t **) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    apr_hash_t *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg3 = &temp3;
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg2 = NUM2LONG(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_rev_proplist(arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_svn_string(*arg3));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_rev_prop(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_revnum_t arg2 ;
    char *arg3 = (char *) 0 ;
    svn_string_t **arg4 = (svn_string_t **) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_string_t *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        arg4 = &temp4;
    }
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg2 = NUM2LONG(argv[1]);
    arg3 = StringValuePtr(argv[2]);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_ra_rev_prop(arg1,arg2,(char const *)arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg4) {
            vresult = output_helper(vresult, rb_str_new((*arg4)->data, (*arg4)->len));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_commit_editor2(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_delta_editor_t **arg2 = (svn_delta_editor_t **) 0 ;
    void **arg3 = (void **) 0 ;
    char *arg4 = (char *) 0 ;
    svn_commit_callback2_t arg5 = (svn_commit_callback2_t) 0 ;
    void *arg6 = (void *) 0 ;
    apr_hash_t *arg7 = (apr_hash_t *) 0 ;
    svn_boolean_t arg8 ;
    apr_pool_t *arg9 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_delta_editor_t const *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg9);
        _global_pool = arg9;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (svn_delta_editor_t **)&temp2;
    }
    {
        temp3 = NULL;
        arg3 = (void **)&temp3;
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg4 = StringValuePtr(argv[1]);
    {
        arg5 = svn_swig_rb_commit_callback2;
        arg6 = (void *)svn_swig_rb_make_baton(argv[2], _global_svn_swig_rb_pool);
    }
    {
        arg7 = svn_swig_rb_hash_to_apr_hash_string(argv[3], _global_pool);
    }
    arg8 = RTEST(argv[4]);
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_commit_editor2(arg1,(struct svn_delta_editor_t const **)arg2,arg3,(char const *)arg4,arg5,arg6,arg7,arg8,arg9);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_svn_delta_editor_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg3, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg6);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_commit_editor(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_delta_editor_t **arg2 = (svn_delta_editor_t **) 0 ;
    void **arg3 = (void **) 0 ;
    char *arg4 = (char *) 0 ;
    svn_commit_callback_t arg5 = (svn_commit_callback_t) 0 ;
    void *arg6 = (void *) 0 ;
    apr_hash_t *arg7 = (apr_hash_t *) 0 ;
    svn_boolean_t arg8 ;
    apr_pool_t *arg9 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_delta_editor_t const *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg9);
        _global_pool = arg9;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (svn_delta_editor_t **)&temp2;
    }
    {
        temp3 = NULL;
        arg3 = (void **)&temp3;
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg4 = StringValuePtr(argv[1]);
    {
        arg5 = svn_swig_rb_commit_callback;
        arg6 = (void *)svn_swig_rb_make_baton(argv[2], _global_svn_swig_rb_pool);
    }
    {
        arg7 = svn_swig_rb_hash_to_apr_hash_string(argv[3], _global_pool);
    }
    arg8 = RTEST(argv[4]);
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_commit_editor(arg1,(struct svn_delta_editor_t const **)arg2,arg3,(char const *)arg4,arg5,arg6,arg7,arg8,arg9);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_svn_delta_editor_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg3, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg6);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_file(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_revnum_t arg3 ;
    svn_stream_t *arg4 = (svn_stream_t *) 0 ;
    svn_revnum_t *arg5 = (svn_revnum_t *) 0 ;
    apr_hash_t **arg6 = (apr_hash_t **) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_revnum_t temp5 ;
    apr_hash_t *temp6 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg5 = &temp5;
    arg6 = &temp6;
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    arg3 = NUM2LONG(argv[2]);
    {
        arg4 = svn_swig_rb_make_stream(argv[3]);
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_file(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg5));
        vresult = output_helper(vresult, o);
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_svn_string(*arg6));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_dir2(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    apr_hash_t **arg2 = (apr_hash_t **) 0 ;
    svn_revnum_t *arg3 = (svn_revnum_t *) 0 ;
    apr_hash_t **arg4 = (apr_hash_t **) 0 ;
    char *arg5 = (char *) 0 ;
    svn_revnum_t arg6 ;
    apr_uint32_t arg7 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    apr_hash_t *temp2 ;
    svn_revnum_t temp3 ;
    apr_hash_t *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg2 = &temp2;
    arg3 = &temp3;
    arg4 = &temp4;
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg5 = StringValuePtr(argv[1]);
    arg6 = NUM2LONG(argv[2]);
    arg7 = NUM2ULONG(argv[3]);
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_dir2(arg1,arg2,arg3,arg4,(char const *)arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_swig_type
        (*arg2, "svn_dirent_t *"));
    }
    {
        VALUE o = INT2NUM((long) (*arg3));
        vresult = output_helper(vresult, o);
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_svn_string(*arg4));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_dir(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_revnum_t arg3 ;
    apr_hash_t **arg4 = (apr_hash_t **) 0 ;
    svn_revnum_t *arg5 = (svn_revnum_t *) 0 ;
    apr_hash_t **arg6 = (apr_hash_t **) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    apr_hash_t *temp4 ;
    svn_revnum_t temp5 ;
    apr_hash_t *temp6 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg4 = &temp4;
    arg5 = &temp5;
    arg6 = &temp6;
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    arg3 = NUM2LONG(argv[2]);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_dir(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_swig_type
        (*arg4, "svn_dirent_t *"));
    }
    {
        VALUE o = INT2NUM((long) (*arg5));
        vresult = output_helper(vresult, o);
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_svn_string(*arg6));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_do_update(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_ra_reporter2_t **arg2 = (svn_ra_reporter2_t **) 0 ;
    void **arg3 = (void **) 0 ;
    svn_revnum_t arg4 ;
    char *arg5 = (char *) 0 ;
    svn_boolean_t arg6 ;
    svn_delta_editor_t *arg7 = (svn_delta_editor_t *) 0 ;
    void *arg8 = (void *) 0 ;
    apr_pool_t *arg9 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_ra_reporter2_t const *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg9);
        _global_pool = arg9;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (svn_ra_reporter2_t **)&temp2;
    }
    {
        temp3 = NULL;
        arg3 = (void **)&temp3;
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg4 = NUM2LONG(argv[1]);
    arg5 = StringValuePtr(argv[2]);
    arg6 = RTEST(argv[3]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[4],
        svn_swig_rb_svn_delta_editor()))) {
            arg7 = svn_swig_rb_to_swig_type(argv[4],
            "svn_delta_editor_t *",
            _global_pool);
            arg8 = svn_swig_rb_to_swig_type(rb_funcall(argv[4], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg7, &arg8, argv[4], _global_pool);
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_do_update(arg1,(struct svn_ra_reporter2_t const **)arg2,arg3,arg4,(char const *)arg5,arg6,(struct svn_delta_editor_t const *)arg7,arg8,arg9);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_svn_ra_reporter2_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg3, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_do_switch(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_ra_reporter2_t **arg2 = (svn_ra_reporter2_t **) 0 ;
    void **arg3 = (void **) 0 ;
    svn_revnum_t arg4 ;
    char *arg5 = (char *) 0 ;
    svn_boolean_t arg6 ;
    char *arg7 = (char *) 0 ;
    svn_delta_editor_t *arg8 = (svn_delta_editor_t *) 0 ;
    void *arg9 = (void *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_ra_reporter2_t const *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (svn_ra_reporter2_t **)&temp2;
    }
    {
        temp3 = NULL;
        arg3 = (void **)&temp3;
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg4 = NUM2LONG(argv[1]);
    arg5 = StringValuePtr(argv[2]);
    arg6 = RTEST(argv[3]);
    arg7 = StringValuePtr(argv[4]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[5],
        svn_swig_rb_svn_delta_editor()))) {
            arg8 = svn_swig_rb_to_swig_type(argv[5],
            "svn_delta_editor_t *",
            _global_pool);
            arg9 = svn_swig_rb_to_swig_type(rb_funcall(argv[5], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg8, &arg9, argv[5], _global_pool);
        }
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_ra_do_switch(arg1,(struct svn_ra_reporter2_t const **)arg2,arg3,arg4,(char const *)arg5,arg6,(char const *)arg7,(struct svn_delta_editor_t const *)arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_svn_ra_reporter2_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg3, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_do_status(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_ra_reporter2_t **arg2 = (svn_ra_reporter2_t **) 0 ;
    void **arg3 = (void **) 0 ;
    char *arg4 = (char *) 0 ;
    svn_revnum_t arg5 ;
    svn_boolean_t arg6 ;
    svn_delta_editor_t *arg7 = (svn_delta_editor_t *) 0 ;
    void *arg8 = (void *) 0 ;
    apr_pool_t *arg9 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_ra_reporter2_t const *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg9);
        _global_pool = arg9;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (svn_ra_reporter2_t **)&temp2;
    }
    {
        temp3 = NULL;
        arg3 = (void **)&temp3;
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg4 = StringValuePtr(argv[1]);
    arg5 = NUM2LONG(argv[2]);
    arg6 = RTEST(argv[3]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[4],
        svn_swig_rb_svn_delta_editor()))) {
            arg7 = svn_swig_rb_to_swig_type(argv[4],
            "svn_delta_editor_t *",
            _global_pool);
            arg8 = svn_swig_rb_to_swig_type(rb_funcall(argv[4], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg7, &arg8, argv[4], _global_pool);
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_do_status(arg1,(struct svn_ra_reporter2_t const **)arg2,arg3,(char const *)arg4,arg5,arg6,(struct svn_delta_editor_t const *)arg7,arg8,arg9);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_svn_ra_reporter2_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg3, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_do_diff2(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_ra_reporter2_t **arg2 = (svn_ra_reporter2_t **) 0 ;
    void **arg3 = (void **) 0 ;
    svn_revnum_t arg4 ;
    char *arg5 = (char *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    char *arg9 = (char *) 0 ;
    svn_delta_editor_t *arg10 = (svn_delta_editor_t *) 0 ;
    void *arg11 = (void *) 0 ;
    apr_pool_t *arg12 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_ra_reporter2_t const *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg12);
        _global_pool = arg12;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (svn_ra_reporter2_t **)&temp2;
    }
    {
        temp3 = NULL;
        arg3 = (void **)&temp3;
    }
    if ((argc < 8) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg4 = NUM2LONG(argv[1]);
    arg5 = StringValuePtr(argv[2]);
    arg6 = RTEST(argv[3]);
    arg7 = RTEST(argv[4]);
    arg8 = RTEST(argv[5]);
    arg9 = StringValuePtr(argv[6]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[7],
        svn_swig_rb_svn_delta_editor()))) {
            arg10 = svn_swig_rb_to_swig_type(argv[7],
            "svn_delta_editor_t *",
            _global_pool);
            arg11 = svn_swig_rb_to_swig_type(rb_funcall(argv[7], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg10, &arg11, argv[7], _global_pool);
        }
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_ra_do_diff2(arg1,(struct svn_ra_reporter2_t const **)arg2,arg3,arg4,(char const *)arg5,arg6,arg7,arg8,(char const *)arg9,(struct svn_delta_editor_t const *)arg10,arg11,arg12);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_svn_ra_reporter2_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg3, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_do_diff(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_ra_reporter2_t **arg2 = (svn_ra_reporter2_t **) 0 ;
    void **arg3 = (void **) 0 ;
    svn_revnum_t arg4 ;
    char *arg5 = (char *) 0 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    char *arg8 = (char *) 0 ;
    svn_delta_editor_t *arg9 = (svn_delta_editor_t *) 0 ;
    void *arg10 = (void *) 0 ;
    apr_pool_t *arg11 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_ra_reporter2_t const *temp2 ;
    void *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg11);
        _global_pool = arg11;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (svn_ra_reporter2_t **)&temp2;
    }
    {
        temp3 = NULL;
        arg3 = (void **)&temp3;
    }
    if ((argc < 7) || (argc > 8))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg4 = NUM2LONG(argv[1]);
    arg5 = StringValuePtr(argv[2]);
    arg6 = RTEST(argv[3]);
    arg7 = RTEST(argv[4]);
    arg8 = StringValuePtr(argv[5]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[6],
        svn_swig_rb_svn_delta_editor()))) {
            arg9 = svn_swig_rb_to_swig_type(argv[6],
            "svn_delta_editor_t *",
            _global_pool);
            arg10 = svn_swig_rb_to_swig_type(rb_funcall(argv[6], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg9, &arg10, argv[6], _global_pool);
        }
    }
    if (argc > 7) {
        
    }
    {
        result = (svn_error_t *)svn_ra_do_diff(arg1,(struct svn_ra_reporter2_t const **)arg2,arg3,arg4,(char const *)arg5,arg6,arg7,(char const *)arg8,(struct svn_delta_editor_t const *)arg9,arg10,arg11);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_svn_ra_reporter2_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg3, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_log(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    apr_array_header_t *arg2 = (apr_array_header_t *) 0 ;
    svn_revnum_t arg3 ;
    svn_revnum_t arg4 ;
    int arg5 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_log_message_receiver_t arg8 = (svn_log_message_receiver_t) 0 ;
    void *arg9 = (void *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 8) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_strings_to_apr_array(argv[1], _global_pool);
    }
    arg3 = NUM2LONG(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    arg5 = NUM2INT(argv[4]);
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    {
        arg8 = svn_swig_rb_log_receiver;
        arg9 = (void *)svn_swig_rb_make_baton(argv[7], _global_svn_swig_rb_pool);
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_log(arg1,(apr_array_header_t const *)arg2,arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_check_path(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_revnum_t arg3 ;
    svn_node_kind_t *arg4 = (svn_node_kind_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_node_kind_t temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg4 = &temp4;
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    arg3 = NUM2LONG(argv[2]);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_ra_check_path(arg1,(char const *)arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg4));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_stat(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_revnum_t arg3 ;
    svn_dirent_t **arg4 = (svn_dirent_t **) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_dirent_t *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp4 = NULL;
        arg4 = (svn_dirent_t **)&temp4;
    }
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    arg3 = NUM2LONG(argv[2]);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_ra_stat(arg1,(char const *)arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg4, SWIGTYPE_p_svn_dirent_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_uuid(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    char **arg2 = (char **) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    char const *temp2 = NULL ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg2 = (char **)&temp2;
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_uuid(arg1,(char const **)arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg2) {
            vresult = output_helper(vresult, rb_str_new2(*arg2));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_repos_root(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    char **arg2 = (char **) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    char const *temp2 = NULL ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg2 = (char **)&temp2;
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_repos_root(arg1,(char const **)arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg2) {
            vresult = output_helper(vresult, rb_str_new2(*arg2));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_locations(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    apr_hash_t **arg2 = (apr_hash_t **) 0 ;
    char *arg3 = (char *) 0 ;
    svn_revnum_t arg4 ;
    apr_array_header_t *arg5 = (apr_array_header_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    apr_hash_t *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg2 = &temp2;
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg3 = StringValuePtr(argv[1]);
    arg4 = NUM2LONG(argv[2]);
    {
        arg5 = svn_swig_rb_array_to_apr_array_revnum(argv[3], _global_pool);
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_locations(arg1,arg2,(char const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = svn_swig_rb_apr_revnum_key_hash_to_hash_string(*arg2);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_file_revs(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_revnum_t arg3 ;
    svn_revnum_t arg4 ;
    svn_ra_file_rev_handler_t arg5 = (svn_ra_file_rev_handler_t) 0 ;
    void *arg6 = (void *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg2 = StringValuePtr(argv[1]);
    arg3 = NUM2LONG(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    {
        arg5 = svn_swig_rb_ra_file_rev_handler;
        arg6 = (void *)svn_swig_rb_make_baton(argv[4], _global_svn_swig_rb_pool);
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_file_revs(arg1,(char const *)arg2,arg3,arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_lock(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    apr_hash_t *arg2 = (apr_hash_t *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_boolean_t arg4 ;
    svn_ra_lock_callback_t arg5 = (svn_ra_lock_callback_t) 0 ;
    void *arg6 = (void *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_hash_to_apr_hash_revnum(argv[1], _global_pool);
    }
    {
        if (NIL_P(argv[2])) {
            arg3 = NULL;
        } else {
            arg3 = StringValuePtr(argv[2]);
        }
    }
    arg4 = RTEST(argv[3]);
    {
        arg5 = svn_swig_rb_ra_lock_callback;
        arg6 = (void *)svn_swig_rb_make_baton(argv[4], _global_svn_swig_rb_pool);
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_lock(arg1,arg2,(char const *)arg3,arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_unlock(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    apr_hash_t *arg2 = (apr_hash_t *) 0 ;
    svn_boolean_t arg3 ;
    svn_ra_lock_callback_t arg4 = (svn_ra_lock_callback_t) 0 ;
    void *arg5 = (void *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    {
        arg2 = svn_swig_rb_hash_to_apr_hash_string(argv[1], _global_pool);
    }
    arg3 = RTEST(argv[2]);
    {
        arg4 = svn_swig_rb_ra_lock_callback;
        arg5 = (void *)svn_swig_rb_make_baton(argv[3], _global_svn_swig_rb_pool);
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_ra_unlock(arg1,arg2,arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_lock(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_lock_t **arg2 = (svn_lock_t **) 0 ;
    char *arg3 = (char *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_lock_t *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (svn_lock_t **)&temp2;
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg3 = StringValuePtr(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_lock(arg1,arg2,(char const *)arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_svn_lock_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_locks(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    apr_hash_t **arg2 = (apr_hash_t **) 0 ;
    char *arg3 = (char *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    apr_hash_t *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg2 = &temp2;
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg3 = StringValuePtr(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_locks(arg1,arg2,(char const *)arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_swig_type
        (*arg2, "svn_lock_t *"));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_replay(int argc, VALUE *argv, VALUE self) {
    svn_ra_session_t *arg1 = (svn_ra_session_t *) 0 ;
    svn_revnum_t arg2 ;
    svn_revnum_t arg3 ;
    svn_boolean_t arg4 ;
    svn_delta_editor_t *arg5 = (svn_delta_editor_t *) 0 ;
    void *arg6 = (void *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_session_t, 1);
        
        
        
        arg1 = (svn_ra_session_t *)temp1;
    }
    arg2 = NUM2LONG(argv[1]);
    arg3 = NUM2LONG(argv[2]);
    arg4 = RTEST(argv[3]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[4],
        svn_swig_rb_svn_delta_editor()))) {
            arg5 = svn_swig_rb_to_swig_type(argv[4],
            "svn_delta_editor_t *",
            _global_pool);
            arg6 = svn_swig_rb_to_swig_type(rb_funcall(argv[4], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg5, &arg6, argv[4], _global_pool);
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_replay(arg1,arg2,arg3,arg4,(struct svn_delta_editor_t const *)arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_print_modules(int argc, VALUE *argv, VALUE self) {
    svn_stringbuf_t *arg1 = (svn_stringbuf_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        if (NIL_P(argv[0])) {
            arg1 = NULL;
        } else {
            arg1 = svn_stringbuf_ncreate(StringValuePtr(argv[0]),
            RSTRING(argv[0])->len,
            _global_pool);
        }
    }
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_ra_print_modules(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = rb_str_new(arg1->data, arg1->len);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_print_ra_libraries(int argc, VALUE *argv, VALUE self) {
    svn_stringbuf_t **arg1 = (svn_stringbuf_t **) 0 ;
    void *arg2 = (void *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_stringbuf_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        arg1 = &temp1;
    }
    if ((argc < 1) || (argc > 2))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    SWIG_ConvertPtr(argv[0], (void **) &arg2, 0, 1);
    if (argc > 1) {
        
    }
    {
        result = (svn_error_t *)svn_ra_print_ra_libraries(arg1,arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg1) {
            vresult = output_helper(vresult, rb_str_new((*arg1)->data, (*arg1)->len));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


swig_class cSvn_ra_plugin_t;

static VALUE
_wrap_svn_ra_plugin_t_name_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->name) free((char *)arg1->name);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->name = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_name_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (char *) ((arg1)->name);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_description_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *temp1 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    arg2 = StringValuePtr(argv[0]);
    {
        apr_size_t len = strlen(arg2) + 1;
        char *copied;
        if (arg1->description) free((char *)arg1->description);
        copied = malloc(len);
        memcpy(copied, arg2, len);
        arg1->description = copied;
    }
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_description_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    char *result;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (char *) ((arg1)->description);
    
    {
        if (result) {
            vresult = rb_str_new2(result);
        } else {
            vresult = Qnil;
        }
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_open_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *) = (svn_error_t *(*)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->open = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_open_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *)) ((arg1)->open);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_get_latest_revnum_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_revnum_t *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_revnum_t *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,svn_revnum_t *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->get_latest_revnum = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_get_latest_revnum_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,svn_revnum_t *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,svn_revnum_t *,apr_pool_t *)) ((arg1)->get_latest_revnum);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_get_dated_revision_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *) = (svn_error_t *(*)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->get_dated_revision = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_get_dated_revision_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *)) ((arg1)->get_dated_revision);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_change_rev_prop_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->change_rev_prop = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_change_rev_prop_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *)) ((arg1)->change_rev_prop);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_rev_proplist_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *) = (svn_error_t *(*)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->rev_proplist = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_rev_proplist_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *)) ((arg1)->rev_proplist);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_rev_prop_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *) = (svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->rev_prop = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_rev_prop_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *)) ((arg1)->rev_prop);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_get_commit_editor_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->get_commit_editor = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_get_commit_editor_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *)) ((arg1)->get_commit_editor);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_get_file_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->get_file = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_get_file_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *)) ((arg1)->get_file);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_get_dir_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->get_dir = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_get_dir_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *)) ((arg1)->get_dir);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_do_update_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->do_update = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_do_update_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)) ((arg1)->do_update);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_do_switch_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->do_switch = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_do_switch_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)) ((arg1)->do_switch);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_do_status_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->do_status = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_do_status_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)) ((arg1)->do_status);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_do_diff_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *) = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->do_diff = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_do_diff_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)) ((arg1)->do_diff);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_get_log_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->get_log = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_get_log_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *)) ((arg1)->get_log);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_check_path_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->check_path = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_check_path_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *)) ((arg1)->check_path);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_get_uuid_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const **,apr_pool_t *) = (svn_error_t *(*)(void *,char const **,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const **,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->get_uuid = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_get_uuid_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,char const **,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const **,apr_pool_t *)) ((arg1)->get_uuid);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_get_repos_root_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const **,apr_pool_t *) = (svn_error_t *(*)(void *,char const **,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const **,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->get_repos_root = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_get_repos_root_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,char const **,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const **,apr_pool_t *)) ((arg1)->get_repos_root);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_get_locations_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->get_locations = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_get_locations_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *)) ((arg1)->get_locations);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_get_file_revs_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t, 1);
        
        
        
        arg2 = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *))temp2;
    }
    if (arg1) (arg1)->get_file_revs = arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_get_file_revs_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *)) ((arg1)->get_file_revs);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t,0);
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_t_get_version_set(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_version_t *(*arg2)(void) = (svn_version_t *(*)(void)) 0 ;
    void *temp1 ;
    void *temp2 ;
    
    if ((argc < 1) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 1)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    {
        SWIG_ConvertPtr(argv[0], &temp2, SWIGTYPE_p_f_void__p_svn_version_t, 1);
        
        
        
        arg2 = (svn_version_t *(*)(void))temp2;
    }
    if (arg1) (arg1)->get_version = (svn_version_t const *(*)(void))arg2;
    
    return Qnil;
}


static VALUE
_wrap_svn_ra_plugin_t_get_version_get(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    svn_version_t *(*result)(void);
    void *temp1 ;
    VALUE vresult = Qnil;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        SWIG_ConvertPtr(self, &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    result = (svn_version_t *(*)(void)) ((arg1)->get_version);
    
    vresult = SWIG_NewPointerObj((void *) result, SWIGTYPE_p_f_void__p_svn_version_t,0);
    return vresult;
}


#ifdef HAVE_RB_DEFINE_ALLOC_FUNC
static VALUE
_wrap_svn_ra_plugin_t_allocate(VALUE self) {
#else
    static VALUE
    _wrap_svn_ra_plugin_t_allocate(int argc, VALUE *argv, VALUE self) {
#endif
        
        
        VALUE vresult = SWIG_NewClassInstance(self, SWIGTYPE_p_svn_ra_plugin_t);
#ifndef HAVE_RB_DEFINE_ALLOC_FUNC
        rb_obj_call_init(vresult, argc, argv);
#endif
        return vresult;
    }
    

static VALUE
_wrap_new_svn_ra_plugin_t(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *result;
    
    if ((argc < 0) || (argc > 0))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    {
        result = (svn_ra_plugin_t *)(svn_ra_plugin_t *) calloc(1, sizeof(svn_ra_plugin_t));
        DATA_PTR(self) = result;
        
        
        
    }
    return self;
}


static void
free_svn_ra_plugin_t(svn_ra_plugin_t *arg1) {
    free((char *) arg1);
}
static VALUE
_wrap_svn_ra_init_ra_libs(int argc, VALUE *argv, VALUE self) {
    void **arg1 = (void **) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg2);
        _global_pool = arg2;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (void **)&temp1;
    }
    if ((argc < 0) || (argc > 1))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 0)",argc);
    if (argc > 0) {
        
    }
    {
        result = (svn_error_t *)svn_ra_init_ra_libs(arg1,arg2);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_get_ra_library(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t **arg1 = (svn_ra_plugin_t **) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    svn_ra_plugin_t *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp1 = NULL;
        arg1 = (svn_ra_plugin_t **)&temp1;
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    SWIG_ConvertPtr(argv[0], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[1]);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_get_ra_library(arg1,arg2,(char const *)arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg1, SWIGTYPE_p_svn_ra_plugin_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter2_invoke_set_path(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_revnum_t arg4 ;
    svn_boolean_t arg5 ;
    char *arg6 = (char *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    arg5 = RTEST(argv[4]);
    {
        if (NIL_P(argv[5])) {
            arg6 = NULL;
        } else {
            arg6 = StringValuePtr(argv[5]);
        }
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_ra_reporter2_invoke_set_path(arg1,arg2,(char const *)arg3,arg4,arg5,(char const *)arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter2_invoke_delete_path(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_ra_reporter2_invoke_delete_path(arg1,arg2,(char const *)arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter2_invoke_link_path(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_revnum_t arg5 ;
    svn_boolean_t arg6 ;
    char *arg7 = (char *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 7) || (argc > 8))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    arg4 = StringValuePtr(argv[3]);
    arg5 = NUM2LONG(argv[4]);
    arg6 = RTEST(argv[5]);
    {
        if (NIL_P(argv[6])) {
            arg7 = NULL;
        } else {
            arg7 = StringValuePtr(argv[6]);
        }
    }
    if (argc > 7) {
        
    }
    {
        result = (svn_error_t *)svn_ra_reporter2_invoke_link_path(arg1,arg2,(char const *)arg3,(char const *)arg4,arg5,arg6,(char const *)arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter2_invoke_finish_report(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_reporter2_invoke_finish_report(arg1,arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter2_invoke_abort_report(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter2_t *arg1 = (svn_ra_reporter2_t *) 0 ;
    void *arg2 = (void *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_reporter2_t, 1);
        
        
        
        arg1 = (svn_ra_reporter2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_reporter2_invoke_abort_report(arg1,arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter_invoke_set_path(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_revnum_t arg4 ;
    svn_boolean_t arg5 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    arg5 = RTEST(argv[4]);
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_reporter_invoke_set_path(arg1,arg2,(char const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter_invoke_delete_path(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_ra_reporter_invoke_delete_path(arg1,arg2,(char const *)arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter_invoke_link_path(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_revnum_t arg5 ;
    svn_boolean_t arg6 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    arg4 = StringValuePtr(argv[3]);
    arg5 = NUM2LONG(argv[4]);
    arg6 = RTEST(argv[5]);
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_ra_reporter_invoke_link_path(arg1,arg2,(char const *)arg3,(char const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter_invoke_finish_report(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    void *arg2 = (void *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_reporter_invoke_finish_report(arg1,arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_reporter_invoke_abort_report(int argc, VALUE *argv, VALUE self) {
    svn_ra_reporter_t *arg1 = (svn_ra_reporter_t *) 0 ;
    void *arg2 = (void *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg3);
        _global_pool = arg3;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_reporter_t, 1);
        
        
        
        arg1 = (svn_ra_reporter_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_reporter_invoke_abort_report(arg1,arg2,arg3);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks2_invoke_open_tmp_file(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks2_t *arg1 = (svn_ra_callbacks2_t *) 0 ;
    apr_file_t **arg2 = (apr_file_t **) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    apr_file_t *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg2 = &temp2;
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_callbacks2_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks2_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg3, 0, 1);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_callbacks2_invoke_open_tmp_file(arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        SWIG_NewPointerObj((void *)*arg2, SWIGTYPE_p_apr_file_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_callbacks_invoke_open_tmp_file(int argc, VALUE *argv, VALUE self) {
    svn_ra_callbacks_t *arg1 = (svn_ra_callbacks_t *) 0 ;
    apr_file_t **arg2 = (apr_file_t **) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    apr_file_t *temp2 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg2 = &temp2;
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg1 = (svn_ra_callbacks_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg3, 0, 1);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_callbacks_invoke_open_tmp_file(arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        SWIG_NewPointerObj((void *)*arg2, SWIGTYPE_p_apr_file_t, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_open(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void **arg2 = (void **) 0 ;
    char *arg3 = (char *) 0 ;
    svn_ra_callbacks_t *arg4 = (svn_ra_callbacks_t *) 0 ;
    void *arg5 = (void *) 0 ;
    apr_hash_t *arg6 = (apr_hash_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    void *temp2 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp2 = NULL;
        arg2 = (void **)&temp2;
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    arg3 = StringValuePtr(argv[1]);
    {
        SWIG_ConvertPtr(argv[2], &temp4, SWIGTYPE_p_svn_ra_callbacks_t, 1);
        
        
        
        arg4 = (svn_ra_callbacks_t *)temp4;
    }
    SWIG_ConvertPtr(argv[3], (void **) &arg5, 0, 1);
    {
        if (NIL_P(argv[4])) {
            arg6 = NULL;
        } else {
            arg6 = svn_swig_rb_hash_to_apr_hash_swig_type(argv[4], "svn_config_t *", _global_pool);
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_open(arg1,arg2,(char const *)arg3,(struct svn_ra_callbacks_t const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg2, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_get_latest_revnum(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_revnum_t *arg3 = (svn_revnum_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_revnum_t temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg3 = &temp3;
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_get_latest_revnum(arg1,arg2,arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg3));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_get_dated_revision(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_revnum_t *arg3 = (svn_revnum_t *) 0 ;
    apr_time_t arg4 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_revnum_t temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg3 = &temp3;
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg4 = (apr_time_t) NUM2LL(argv[2]);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_get_dated_revision(arg1,arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg3));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_change_rev_prop(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_revnum_t arg3 ;
    char *arg4 = (char *) 0 ;
    svn_string_t *arg5 = (svn_string_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_string_t value5 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = NUM2LONG(argv[2]);
    arg4 = StringValuePtr(argv[3]);
    {
        if (NIL_P(argv[4])) {
            arg5 = NULL;
        } else {
            value5.data = StringValuePtr(argv[4]);
            value5.len = RSTRING(argv[4])->len;
            arg5 = &value5;
        }
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_change_rev_prop(arg1,arg2,arg3,(char const *)arg4,(struct svn_string_t const *)arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_rev_proplist(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_revnum_t arg3 ;
    apr_hash_t **arg4 = (apr_hash_t **) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    apr_hash_t *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg5);
        _global_pool = arg5;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg4 = &temp4;
    if ((argc < 3) || (argc > 4))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 3)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = NUM2LONG(argv[2]);
    if (argc > 3) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_rev_proplist(arg1,arg2,arg3,arg4,arg5);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_svn_string(*arg4));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_rev_prop(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_revnum_t arg3 ;
    char *arg4 = (char *) 0 ;
    svn_string_t **arg5 = (svn_string_t **) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_string_t *temp5 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        arg5 = &temp5;
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = NUM2LONG(argv[2]);
    arg4 = StringValuePtr(argv[3]);
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_rev_prop(arg1,arg2,arg3,(char const *)arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg5) {
            vresult = output_helper(vresult, rb_str_new((*arg5)->data, (*arg5)->len));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_get_commit_editor(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_delta_editor_t **arg3 = (svn_delta_editor_t **) 0 ;
    void **arg4 = (void **) 0 ;
    char *arg5 = (char *) 0 ;
    svn_commit_callback_t arg6 = (svn_commit_callback_t) 0 ;
    void *arg7 = (void *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_delta_editor_t const *temp3 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp3 = NULL;
        arg3 = (svn_delta_editor_t **)&temp3;
    }
    {
        temp4 = NULL;
        arg4 = (void **)&temp4;
    }
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg5 = StringValuePtr(argv[2]);
    {
        arg6 = svn_swig_rb_commit_callback;
        arg7 = (void *)svn_swig_rb_make_baton(argv[3], _global_svn_swig_rb_pool);
    }
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_get_commit_editor(arg1,arg2,(struct svn_delta_editor_t const **)arg3,arg4,(char const *)arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg3, SWIGTYPE_p_svn_delta_editor_t, 0));
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg4, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_baton(vresult, (VALUE)arg7);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_get_file(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_revnum_t arg4 ;
    svn_stream_t *arg5 = (svn_stream_t *) 0 ;
    svn_revnum_t *arg6 = (svn_revnum_t *) 0 ;
    apr_hash_t **arg7 = (apr_hash_t **) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_revnum_t temp6 ;
    apr_hash_t *temp7 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg6 = &temp6;
    arg7 = &temp7;
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    {
        arg5 = svn_swig_rb_make_stream(argv[4]);
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_get_file(arg1,arg2,(char const *)arg3,arg4,arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg6));
        vresult = output_helper(vresult, o);
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_svn_string(*arg7));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_get_dir(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_revnum_t arg4 ;
    apr_hash_t **arg5 = (apr_hash_t **) 0 ;
    svn_revnum_t *arg6 = (svn_revnum_t *) 0 ;
    apr_hash_t **arg7 = (apr_hash_t **) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    apr_hash_t *temp5 ;
    svn_revnum_t temp6 ;
    apr_hash_t *temp7 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg5 = &temp5;
    arg6 = &temp6;
    arg7 = &temp7;
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_get_dir(arg1,arg2,(char const *)arg3,arg4,arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_swig_type
        (*arg5, "svn_dirent_t *"));
    }
    {
        VALUE o = INT2NUM((long) (*arg6));
        vresult = output_helper(vresult, o);
    }
    {
        vresult = output_helper(vresult,
        svn_swig_rb_apr_hash_to_hash_svn_string(*arg7));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_do_update(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_ra_reporter_t **arg3 = (svn_ra_reporter_t **) 0 ;
    void **arg4 = (void **) 0 ;
    svn_revnum_t arg5 ;
    char *arg6 = (char *) 0 ;
    svn_boolean_t arg7 ;
    svn_delta_editor_t *arg8 = (svn_delta_editor_t *) 0 ;
    void *arg9 = (void *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    void *temp3 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp4 = NULL;
        arg4 = (void **)&temp4;
    }
    if ((argc < 7) || (argc > 8))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    {
        SWIG_ConvertPtr(argv[2], &temp3, SWIGTYPE_p_p_svn_ra_reporter_t, 1);
        
        
        
        arg3 = (svn_ra_reporter_t **)temp3;
    }
    arg5 = NUM2LONG(argv[3]);
    arg6 = StringValuePtr(argv[4]);
    arg7 = RTEST(argv[5]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[6],
        svn_swig_rb_svn_delta_editor()))) {
            arg8 = svn_swig_rb_to_swig_type(argv[6],
            "svn_delta_editor_t *",
            _global_pool);
            arg9 = svn_swig_rb_to_swig_type(rb_funcall(argv[6], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg8, &arg9, argv[6], _global_pool);
        }
    }
    if (argc > 7) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_do_update(arg1,arg2,(struct svn_ra_reporter_t const **)arg3,arg4,arg5,(char const *)arg6,arg7,(struct svn_delta_editor_t const *)arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg4, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_do_switch(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_ra_reporter_t **arg3 = (svn_ra_reporter_t **) 0 ;
    void **arg4 = (void **) 0 ;
    svn_revnum_t arg5 ;
    char *arg6 = (char *) 0 ;
    svn_boolean_t arg7 ;
    char *arg8 = (char *) 0 ;
    svn_delta_editor_t *arg9 = (svn_delta_editor_t *) 0 ;
    void *arg10 = (void *) 0 ;
    apr_pool_t *arg11 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    void *temp3 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg11);
        _global_pool = arg11;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp4 = NULL;
        arg4 = (void **)&temp4;
    }
    if ((argc < 8) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    {
        SWIG_ConvertPtr(argv[2], &temp3, SWIGTYPE_p_p_svn_ra_reporter_t, 1);
        
        
        
        arg3 = (svn_ra_reporter_t **)temp3;
    }
    arg5 = NUM2LONG(argv[3]);
    arg6 = StringValuePtr(argv[4]);
    arg7 = RTEST(argv[5]);
    arg8 = StringValuePtr(argv[6]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[7],
        svn_swig_rb_svn_delta_editor()))) {
            arg9 = svn_swig_rb_to_swig_type(argv[7],
            "svn_delta_editor_t *",
            _global_pool);
            arg10 = svn_swig_rb_to_swig_type(rb_funcall(argv[7], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg9, &arg10, argv[7], _global_pool);
        }
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_do_switch(arg1,arg2,(struct svn_ra_reporter_t const **)arg3,arg4,arg5,(char const *)arg6,arg7,(char const *)arg8,(struct svn_delta_editor_t const *)arg9,arg10,arg11);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg4, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_do_status(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_ra_reporter_t **arg3 = (svn_ra_reporter_t **) 0 ;
    void **arg4 = (void **) 0 ;
    char *arg5 = (char *) 0 ;
    svn_revnum_t arg6 ;
    svn_boolean_t arg7 ;
    svn_delta_editor_t *arg8 = (svn_delta_editor_t *) 0 ;
    void *arg9 = (void *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    void *temp3 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp4 = NULL;
        arg4 = (void **)&temp4;
    }
    if ((argc < 7) || (argc > 8))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 7)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    {
        SWIG_ConvertPtr(argv[2], &temp3, SWIGTYPE_p_p_svn_ra_reporter_t, 1);
        
        
        
        arg3 = (svn_ra_reporter_t **)temp3;
    }
    arg5 = StringValuePtr(argv[3]);
    arg6 = NUM2LONG(argv[4]);
    arg7 = RTEST(argv[5]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[6],
        svn_swig_rb_svn_delta_editor()))) {
            arg8 = svn_swig_rb_to_swig_type(argv[6],
            "svn_delta_editor_t *",
            _global_pool);
            arg9 = svn_swig_rb_to_swig_type(rb_funcall(argv[6], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg8, &arg9, argv[6], _global_pool);
        }
    }
    if (argc > 7) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_do_status(arg1,arg2,(struct svn_ra_reporter_t const **)arg3,arg4,(char const *)arg5,arg6,arg7,(struct svn_delta_editor_t const *)arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg4, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_do_diff(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_ra_reporter_t **arg3 = (svn_ra_reporter_t **) 0 ;
    void **arg4 = (void **) 0 ;
    svn_revnum_t arg5 ;
    char *arg6 = (char *) 0 ;
    svn_boolean_t arg7 ;
    svn_boolean_t arg8 ;
    char *arg9 = (char *) 0 ;
    svn_delta_editor_t *arg10 = (svn_delta_editor_t *) 0 ;
    void *arg11 = (void *) 0 ;
    apr_pool_t *arg12 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    void *temp3 ;
    void *temp4 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg12);
        _global_pool = arg12;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    {
        temp4 = NULL;
        arg4 = (void **)&temp4;
    }
    if ((argc < 9) || (argc > 10))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 9)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    {
        SWIG_ConvertPtr(argv[2], &temp3, SWIGTYPE_p_p_svn_ra_reporter_t, 1);
        
        
        
        arg3 = (svn_ra_reporter_t **)temp3;
    }
    arg5 = NUM2LONG(argv[3]);
    arg6 = StringValuePtr(argv[4]);
    arg7 = RTEST(argv[5]);
    arg8 = RTEST(argv[6]);
    arg9 = StringValuePtr(argv[7]);
    {
        if (RTEST(rb_obj_is_kind_of(argv[8],
        svn_swig_rb_svn_delta_editor()))) {
            arg10 = svn_swig_rb_to_swig_type(argv[8],
            "svn_delta_editor_t *",
            _global_pool);
            arg11 = svn_swig_rb_to_swig_type(rb_funcall(argv[8], rb_intern("baton"), 0),
            "void *", _global_pool);
        } else {
            svn_swig_rb_make_delta_editor(&arg10, &arg11, argv[8], _global_pool);
        }
    }
    if (argc > 9) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_do_diff(arg1,arg2,(struct svn_ra_reporter_t const **)arg3,arg4,arg5,(char const *)arg6,arg7,arg8,(char const *)arg9,(struct svn_delta_editor_t const *)arg10,arg11,arg12);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = output_helper(vresult, SWIG_NewPointerObj(*arg4, SWIGTYPE_p_void, 0));
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_get_log(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    apr_array_header_t *arg3 = (apr_array_header_t *) 0 ;
    svn_revnum_t arg4 ;
    svn_revnum_t arg5 ;
    svn_boolean_t arg6 ;
    svn_boolean_t arg7 ;
    svn_log_message_receiver_t arg8 = (svn_log_message_receiver_t) 0 ;
    void *arg9 = (void *) 0 ;
    apr_pool_t *arg10 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg10);
        _global_pool = arg10;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 8) || (argc > 9))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 8)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    {
        arg3 = svn_swig_rb_strings_to_apr_array(argv[2], _global_pool);
    }
    arg4 = NUM2LONG(argv[3]);
    arg5 = NUM2LONG(argv[4]);
    arg6 = RTEST(argv[5]);
    arg7 = RTEST(argv[6]);
    {
        arg8 = svn_swig_rb_log_receiver;
        arg9 = (void *)svn_swig_rb_make_baton(argv[7], _global_svn_swig_rb_pool);
    }
    if (argc > 8) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_get_log(arg1,arg2,(apr_array_header_t const *)arg3,arg4,arg5,arg6,arg7,arg8,arg9,arg10);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_check_path(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_revnum_t arg4 ;
    svn_node_kind_t *arg5 = (svn_node_kind_t *) 0 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    svn_node_kind_t temp5 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg6);
        _global_pool = arg6;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg5 = &temp5;
    if ((argc < 4) || (argc > 5))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 4)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    if (argc > 4) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_check_path(arg1,arg2,(char const *)arg3,arg4,arg5,arg6);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        VALUE o = INT2NUM((long) (*arg5));
        vresult = output_helper(vresult, o);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_get_uuid(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char **arg3 = (char **) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    char const *temp3 = NULL ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg3 = (char **)&temp3;
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_get_uuid(arg1,arg2,(char const **)arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg3) {
            vresult = output_helper(vresult, rb_str_new2(*arg3));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_get_repos_root(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char **arg3 = (char **) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    char const *temp3 = NULL ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg4);
        _global_pool = arg4;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg3 = (char **)&temp3;
    if ((argc < 2) || (argc > 3))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 2)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    if (argc > 2) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_get_repos_root(arg1,arg2,(char const **)arg3,arg4);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        if (*arg3) {
            vresult = output_helper(vresult, rb_str_new2(*arg3));
        } else {
            vresult = output_helper(vresult, Qnil);
        }
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_get_locations(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    apr_hash_t **arg3 = (apr_hash_t **) 0 ;
    char *arg4 = (char *) 0 ;
    svn_revnum_t arg5 ;
    apr_array_header_t *arg6 = (apr_array_header_t *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    apr_hash_t *temp3 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg7);
        _global_pool = arg7;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    arg3 = &temp3;
    if ((argc < 5) || (argc > 6))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 5)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg4 = StringValuePtr(argv[2]);
    arg5 = NUM2LONG(argv[3]);
    {
        arg6 = svn_swig_rb_array_to_apr_array_revnum(argv[4], _global_pool);
    }
    if (argc > 5) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_get_locations(arg1,arg2,arg3,(char const *)arg4,arg5,arg6,arg7);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        vresult = svn_swig_rb_apr_revnum_key_hash_to_hash_string(*arg3);
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}


static VALUE
_wrap_svn_ra_plugin_invoke_get_file_revs(int argc, VALUE *argv, VALUE self) {
    svn_ra_plugin_t *arg1 = (svn_ra_plugin_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_revnum_t arg4 ;
    svn_revnum_t arg5 ;
    svn_ra_file_rev_handler_t arg6 = (svn_ra_file_rev_handler_t) 0 ;
    void *arg7 = (void *) 0 ;
    apr_pool_t *arg8 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    VALUE _global_svn_swig_rb_pool ;
    apr_pool_t *_global_pool ;
    void *temp1 ;
    VALUE vresult = Qnil;
    
    {
        svn_swig_rb_get_pool(argc, argv, self, &_global_svn_swig_rb_pool, &arg8);
        _global_pool = arg8;
        svn_swig_rb_push_pool(_global_svn_swig_rb_pool);
    }
    if ((argc < 6) || (argc > 7))
    rb_raise(rb_eArgError, "wrong # of arguments(%d for 6)",argc);
    {
        SWIG_ConvertPtr(argv[0], &temp1, SWIGTYPE_p_svn_ra_plugin_t, 1);
        
        
        
        arg1 = (svn_ra_plugin_t *)temp1;
    }
    SWIG_ConvertPtr(argv[1], (void **) &arg2, 0, 1);
    arg3 = StringValuePtr(argv[2]);
    arg4 = NUM2LONG(argv[3]);
    arg5 = NUM2LONG(argv[4]);
    {
        arg6 = svn_swig_rb_ra_file_rev_handler;
        arg7 = (void *)svn_swig_rb_make_baton(argv[5], _global_svn_swig_rb_pool);
    }
    if (argc > 6) {
        
    }
    {
        result = (svn_error_t *)svn_ra_plugin_invoke_get_file_revs(arg1,arg2,(char const *)arg3,arg4,arg5,arg6,arg7,arg8);
        
        
        
        
    }
    {
        if (result) {
            svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
            svn_swig_rb_handle_svn_error(result);
        }
        vresult = Qnil;
    }
    {
        svn_swig_rb_set_pool(vresult, _global_svn_swig_rb_pool);
        svn_swig_rb_pop_pool(_global_svn_swig_rb_pool);
    }
    return vresult;
}



/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (BEGIN) -------- */

static swig_type_info _swigt__p_apr_array_header_t = {"_p_apr_array_header_t", "apr_array_header_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_file_t = {"_p_apr_file_t", "apr_file_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_hash_t = {"_p_apr_hash_t", "apr_hash_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int32_t = {"_p_apr_int32_t", "apr_int32_t *|time_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int64_t = {"_p_apr_int64_t", "apr_int64_t *|svn_filesize_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_pool_t = {"_p_apr_pool_t", "apr_pool_t *", 0, 0, 0};
static swig_type_info _swigt__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void = {"_p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void", "void (*)(apr_off_t,apr_off_t,void *,apr_pool_t *)|svn_ra_progress_notify_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(apr_getopt_t *,void *,apr_pool_t *)|svn_opt_subcommand_t *", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)|svn_error_t *(*)(apr_file_t **,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *)|svn_error_t *(*)(void **,char const *,svn_ra_callbacks_t const *,void *,apr_hash_t *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_commit_info_t const *,void *,apr_pool_t *)|svn_commit_callback2_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_hash_t *,svn_revnum_t,char const *,char const *,char const *,apr_pool_t *)|svn_log_message_receiver_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_pool_t *)|svn_error_t *(*)(void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *)|svn_error_t *(*)(void *,apr_hash_t **,char const *,svn_revnum_t,apr_array_header_t *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const **,apr_pool_t *)|svn_error_t *(*)(void *,char const **,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *)|svn_error_t *(*)(void *,svn_delta_editor_t const **,void **,char const *,svn_commit_callback_t,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)|svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,char const *,svn_revnum_t,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)|svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)|svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_delta_editor_t const *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)|svn_error_t *(*)(void *,svn_ra_reporter_t const **,void **,svn_revnum_t,char const *,svn_boolean_t,svn_boolean_t,char const *,svn_delta_editor_t const *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *)|svn_error_t *(*)(void *,apr_array_header_t const *,svn_revnum_t,svn_revnum_t,svn_boolean_t,svn_boolean_t,svn_log_message_receiver_t,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,char const *,apr_pool_t *)|svn_ra_invalidate_wc_props_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,char const *,svn_string_t const **,apr_pool_t *)|svn_ra_get_wc_prop_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,char const *,svn_string_t const *,apr_pool_t *)|svn_ra_push_wc_prop_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)|svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_boolean_t,svn_lock_t const *,svn_error_t *,apr_pool_t *)|svn_ra_lock_callback_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t *,svn_txdelta_window_handler_t *,void **,apr_array_header_t *,apr_pool_t *)|svn_ra_file_rev_handler_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,apr_hash_t **,svn_revnum_t *,apr_hash_t **,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_node_kind_t *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_stream_t *,svn_revnum_t *,apr_hash_t **,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_boolean_t,char const *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_revnum_t,svn_revnum_t,svn_ra_file_rev_handler_t,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *)|svn_error_t *(*)(void *,svn_revnum_t *,apr_time_t,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t *,apr_pool_t *)|svn_error_t *(*)(void *,svn_revnum_t *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *)|svn_error_t *(*)(void *,svn_revnum_t,apr_hash_t **,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *)|svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t **,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *)|svn_error_t *(*)(void *,svn_revnum_t,char const *,svn_string_t const *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t = {"_p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t", "struct svn_error_t *(*)(svn_revnum_t,char const *,char const *,void *)|svn_commit_callback_t", 0, 0, 0};
static swig_type_info _swigt__p_f_void__p_svn_version_t = {"_p_f_void__p_svn_version_t", "struct svn_version_t *(*)(void)|svn_version_t *(*)(void)", 0, 0, 0};
static swig_type_info _swigt__p_int = {"_p_int", "int *|svn_boolean_t *", 0, 0, 0};
static swig_type_info _swigt__p_long = {"_p_long", "long *|svn_revnum_t *", 0, 0, 0};
static swig_type_info _swigt__p_p_apr_file_t = {"_p_p_apr_file_t", "apr_file_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_apr_hash_t = {"_p_p_apr_hash_t", "apr_hash_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_char = {"_p_p_char", "char **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_delta_editor_t = {"_p_p_svn_delta_editor_t", "struct svn_delta_editor_t **|svn_delta_editor_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_dirent_t = {"_p_p_svn_dirent_t", "struct svn_dirent_t **|svn_dirent_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_lock_t = {"_p_p_svn_lock_t", "struct svn_lock_t **|svn_lock_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_ra_callbacks2_t = {"_p_p_svn_ra_callbacks2_t", "struct svn_ra_callbacks2_t **|svn_ra_callbacks2_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_ra_plugin_t = {"_p_p_svn_ra_plugin_t", "struct svn_ra_plugin_t **|svn_ra_plugin_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_ra_reporter2_t = {"_p_p_svn_ra_reporter2_t", "struct svn_ra_reporter2_t **|svn_ra_reporter2_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_ra_reporter_t = {"_p_p_svn_ra_reporter_t", "struct svn_ra_reporter_t **|svn_ra_reporter_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_ra_session_t = {"_p_p_svn_ra_session_t", "struct svn_ra_session_t **|svn_ra_session_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_string_t = {"_p_p_svn_string_t", "struct svn_string_t **|svn_string_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_stringbuf_t = {"_p_p_svn_stringbuf_t", "struct svn_stringbuf_t **|svn_stringbuf_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_void = {"_p_p_void", "void **", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_baton_t = {"_p_svn_auth_baton_t", "struct svn_auth_baton_t *|svn_auth_baton_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_simple_t = {"_p_svn_auth_cred_simple_t", "struct svn_auth_cred_simple_t *|svn_auth_cred_simple_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_pw_t = {"_p_svn_auth_cred_ssl_client_cert_pw_t", "struct svn_auth_cred_ssl_client_cert_pw_t *|svn_auth_cred_ssl_client_cert_pw_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_t = {"_p_svn_auth_cred_ssl_client_cert_t", "struct svn_auth_cred_ssl_client_cert_t *|svn_auth_cred_ssl_client_cert_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_server_trust_t = {"_p_svn_auth_cred_ssl_server_trust_t", "struct svn_auth_cred_ssl_server_trust_t *|svn_auth_cred_ssl_server_trust_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_username_t = {"_p_svn_auth_cred_username_t", "struct svn_auth_cred_username_t *|svn_auth_cred_username_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_iterstate_t = {"_p_svn_auth_iterstate_t", "struct svn_auth_iterstate_t *|svn_auth_iterstate_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_object_t = {"_p_svn_auth_provider_object_t", "struct svn_auth_provider_object_t *|svn_auth_provider_object_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_t = {"_p_svn_auth_provider_t", "struct svn_auth_provider_t *|svn_auth_provider_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_ssl_server_cert_info_t = {"_p_svn_auth_ssl_server_cert_info_t", "struct svn_auth_ssl_server_cert_info_t *|svn_auth_ssl_server_cert_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_commit_info_t = {"_p_svn_commit_info_t", "struct svn_commit_info_t *|svn_commit_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_config_t = {"_p_svn_config_t", "struct svn_config_t *|svn_config_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_delta_editor_t = {"_p_svn_delta_editor_t", "struct svn_delta_editor_t *|svn_delta_editor_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_datasource_e = {"_p_svn_diff_datasource_e", "enum svn_diff_datasource_e *|svn_diff_datasource_e *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_file_ignore_space_t = {"_p_svn_diff_file_ignore_space_t", "enum svn_diff_file_ignore_space_t *|svn_diff_file_ignore_space_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_file_options_t = {"_p_svn_diff_file_options_t", "struct svn_diff_file_options_t *|svn_diff_file_options_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_fns_t = {"_p_svn_diff_fns_t", "struct svn_diff_fns_t *|svn_diff_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_output_fns_t = {"_p_svn_diff_output_fns_t", "struct svn_diff_output_fns_t *|svn_diff_output_fns_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_diff_t = {"_p_svn_diff_t", "struct svn_diff_t *|svn_diff_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_dirent_t = {"_p_svn_dirent_t", "struct svn_dirent_t *|svn_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_errno_t = {"_p_svn_errno_t", "enum svn_errno_t *|svn_errno_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_error_t = {"_p_svn_error_t", "struct svn_error_t *|svn_error_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_dirent_t = {"_p_svn_io_dirent_t", "struct svn_io_dirent_t *|svn_io_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_file_del_t = {"_p_svn_io_file_del_t", "enum svn_io_file_del_t *|svn_io_file_del_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_lock_t = {"_p_svn_lock_t", "struct svn_lock_t *|svn_lock_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_log_changed_path_t = {"_p_svn_log_changed_path_t", "struct svn_log_changed_path_t *|svn_log_changed_path_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_node_kind_t = {"_p_svn_node_kind_t", "enum svn_node_kind_t *|svn_node_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_t = {"_p_svn_opt_revision_t", "struct svn_opt_revision_t *|svn_opt_revision_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_value_t = {"_p_svn_opt_revision_value_t", "union svn_opt_revision_value_t *|svn_opt_revision_value_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc2_t = {"_p_svn_opt_subcommand_desc2_t", "struct svn_opt_subcommand_desc2_t *|svn_opt_subcommand_desc2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc_t = {"_p_svn_opt_subcommand_desc_t", "struct svn_opt_subcommand_desc_t *|svn_opt_subcommand_desc_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_prop_kind = {"_p_svn_prop_kind", "enum svn_prop_kind *|svn_prop_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_prop_t = {"_p_svn_prop_t", "struct svn_prop_t *|svn_prop_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_callbacks2_t = {"_p_svn_ra_callbacks2_t", "struct svn_ra_callbacks2_t *|svn_ra_callbacks2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_callbacks_t = {"_p_svn_ra_callbacks_t", "struct svn_ra_callbacks_t *|svn_ra_callbacks_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_plugin_t = {"_p_svn_ra_plugin_t", "struct svn_ra_plugin_t *|svn_ra_plugin_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_reporter2_t = {"_p_svn_ra_reporter2_t", "struct svn_ra_reporter2_t *|svn_ra_reporter2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_reporter_t = {"_p_svn_ra_reporter_t", "struct svn_ra_reporter_t *|svn_ra_reporter_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_ra_session_t = {"_p_svn_ra_session_t", "struct svn_ra_session_t *|svn_ra_session_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stream_t = {"_p_svn_stream_t", "struct svn_stream_t *|svn_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_string_t = {"_p_svn_string_t", "struct svn_string_t *|svn_string_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stringbuf_t = {"_p_svn_stringbuf_t", "struct svn_stringbuf_t *|svn_stringbuf_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_op_t = {"_p_svn_txdelta_op_t", "struct svn_txdelta_op_t *|svn_txdelta_op_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_stream_t = {"_p_svn_txdelta_stream_t", "struct svn_txdelta_stream_t *|svn_txdelta_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_window_t = {"_p_svn_txdelta_window_t", "struct svn_txdelta_window_t *|svn_txdelta_window_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_checklist_t = {"_p_svn_version_checklist_t", "struct svn_version_checklist_t *|svn_version_checklist_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_t = {"_p_svn_version_t", "struct svn_version_t *|svn_version_t *", 0, 0, 0};
static swig_type_info _swigt__p_unsigned_long = {"_p_unsigned_long", "unsigned long *|VALUE *", 0, 0, 0};
static swig_type_info _swigt__p_void = {"_p_void", "void *", 0, 0, 0};

static swig_type_info *swig_type_initial[] = {
  &_swigt__p_apr_array_header_t,
  &_swigt__p_apr_file_t,
  &_swigt__p_apr_hash_t,
  &_swigt__p_apr_int32_t,
  &_swigt__p_apr_int64_t,
  &_swigt__p_apr_pool_t,
  &_swigt__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void,
  &_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t,
  &_swigt__p_f_void__p_svn_version_t,
  &_swigt__p_int,
  &_swigt__p_long,
  &_swigt__p_p_apr_file_t,
  &_swigt__p_p_apr_hash_t,
  &_swigt__p_p_char,
  &_swigt__p_p_svn_delta_editor_t,
  &_swigt__p_p_svn_dirent_t,
  &_swigt__p_p_svn_lock_t,
  &_swigt__p_p_svn_ra_callbacks2_t,
  &_swigt__p_p_svn_ra_plugin_t,
  &_swigt__p_p_svn_ra_reporter2_t,
  &_swigt__p_p_svn_ra_reporter_t,
  &_swigt__p_p_svn_ra_session_t,
  &_swigt__p_p_svn_string_t,
  &_swigt__p_p_svn_stringbuf_t,
  &_swigt__p_p_void,
  &_swigt__p_svn_auth_baton_t,
  &_swigt__p_svn_auth_cred_simple_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_pw_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_t,
  &_swigt__p_svn_auth_cred_ssl_server_trust_t,
  &_swigt__p_svn_auth_cred_username_t,
  &_swigt__p_svn_auth_iterstate_t,
  &_swigt__p_svn_auth_provider_object_t,
  &_swigt__p_svn_auth_provider_t,
  &_swigt__p_svn_auth_ssl_server_cert_info_t,
  &_swigt__p_svn_commit_info_t,
  &_swigt__p_svn_config_t,
  &_swigt__p_svn_delta_editor_t,
  &_swigt__p_svn_diff_datasource_e,
  &_swigt__p_svn_diff_file_ignore_space_t,
  &_swigt__p_svn_diff_file_options_t,
  &_swigt__p_svn_diff_fns_t,
  &_swigt__p_svn_diff_output_fns_t,
  &_swigt__p_svn_diff_t,
  &_swigt__p_svn_dirent_t,
  &_swigt__p_svn_errno_t,
  &_swigt__p_svn_error_t,
  &_swigt__p_svn_io_dirent_t,
  &_swigt__p_svn_io_file_del_t,
  &_swigt__p_svn_lock_t,
  &_swigt__p_svn_log_changed_path_t,
  &_swigt__p_svn_node_kind_t,
  &_swigt__p_svn_opt_revision_t,
  &_swigt__p_svn_opt_revision_value_t,
  &_swigt__p_svn_opt_subcommand_desc2_t,
  &_swigt__p_svn_opt_subcommand_desc_t,
  &_swigt__p_svn_prop_kind,
  &_swigt__p_svn_prop_t,
  &_swigt__p_svn_ra_callbacks2_t,
  &_swigt__p_svn_ra_callbacks_t,
  &_swigt__p_svn_ra_plugin_t,
  &_swigt__p_svn_ra_reporter2_t,
  &_swigt__p_svn_ra_reporter_t,
  &_swigt__p_svn_ra_session_t,
  &_swigt__p_svn_stream_t,
  &_swigt__p_svn_string_t,
  &_swigt__p_svn_stringbuf_t,
  &_swigt__p_svn_txdelta_op_t,
  &_swigt__p_svn_txdelta_stream_t,
  &_swigt__p_svn_txdelta_window_t,
  &_swigt__p_svn_version_checklist_t,
  &_swigt__p_svn_version_t,
  &_swigt__p_unsigned_long,
  &_swigt__p_void,
};

static swig_cast_info _swigc__p_apr_array_header_t[] = {  {&_swigt__p_apr_array_header_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_file_t[] = {  {&_swigt__p_apr_file_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_hash_t[] = {  {&_swigt__p_apr_hash_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int32_t[] = {  {&_swigt__p_apr_int32_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int64_t[] = {  {&_swigt__p_apr_int64_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_pool_t[] = {  {&_swigt__p_apr_pool_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void[] = {  {&_swigt__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t[] = {  {&_swigt__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_void__p_svn_version_t[] = {  {&_swigt__p_f_void__p_svn_version_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_int[] = {  {&_swigt__p_int, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_long[] = {  {&_swigt__p_long, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_apr_file_t[] = {  {&_swigt__p_p_apr_file_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_apr_hash_t[] = {  {&_swigt__p_p_apr_hash_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_char[] = {  {&_swigt__p_p_char, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_delta_editor_t[] = {  {&_swigt__p_p_svn_delta_editor_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_dirent_t[] = {  {&_swigt__p_p_svn_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_lock_t[] = {  {&_swigt__p_p_svn_lock_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_ra_callbacks2_t[] = {  {&_swigt__p_p_svn_ra_callbacks2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_ra_plugin_t[] = {  {&_swigt__p_p_svn_ra_plugin_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_ra_reporter2_t[] = {  {&_swigt__p_p_svn_ra_reporter2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_ra_reporter_t[] = {  {&_swigt__p_p_svn_ra_reporter_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_ra_session_t[] = {  {&_swigt__p_p_svn_ra_session_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_string_t[] = {  {&_swigt__p_p_svn_string_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_stringbuf_t[] = {  {&_swigt__p_p_svn_stringbuf_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_void[] = {  {&_swigt__p_p_void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_baton_t[] = {  {&_swigt__p_svn_auth_baton_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_simple_t[] = {  {&_swigt__p_svn_auth_cred_simple_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_pw_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_pw_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_server_trust_t[] = {  {&_swigt__p_svn_auth_cred_ssl_server_trust_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_username_t[] = {  {&_swigt__p_svn_auth_cred_username_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_iterstate_t[] = {  {&_swigt__p_svn_auth_iterstate_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_object_t[] = {  {&_swigt__p_svn_auth_provider_object_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_t[] = {  {&_swigt__p_svn_auth_provider_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_ssl_server_cert_info_t[] = {  {&_swigt__p_svn_auth_ssl_server_cert_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_commit_info_t[] = {  {&_swigt__p_svn_commit_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_config_t[] = {  {&_swigt__p_svn_config_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_delta_editor_t[] = {  {&_swigt__p_svn_delta_editor_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_datasource_e[] = {  {&_swigt__p_svn_diff_datasource_e, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_file_ignore_space_t[] = {  {&_swigt__p_svn_diff_file_ignore_space_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_file_options_t[] = {  {&_swigt__p_svn_diff_file_options_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_fns_t[] = {  {&_swigt__p_svn_diff_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_output_fns_t[] = {  {&_swigt__p_svn_diff_output_fns_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_diff_t[] = {  {&_swigt__p_svn_diff_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_dirent_t[] = {  {&_swigt__p_svn_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_errno_t[] = {  {&_swigt__p_svn_errno_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_error_t[] = {  {&_swigt__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_dirent_t[] = {  {&_swigt__p_svn_io_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_file_del_t[] = {  {&_swigt__p_svn_io_file_del_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_lock_t[] = {  {&_swigt__p_svn_lock_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_log_changed_path_t[] = {  {&_swigt__p_svn_log_changed_path_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_node_kind_t[] = {  {&_swigt__p_svn_node_kind_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_t[] = {  {&_swigt__p_svn_opt_revision_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_value_t[] = {  {&_swigt__p_svn_opt_revision_value_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc2_t[] = {  {&_swigt__p_svn_opt_subcommand_desc2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc_t[] = {  {&_swigt__p_svn_opt_subcommand_desc_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_prop_kind[] = {  {&_swigt__p_svn_prop_kind, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_prop_t[] = {  {&_swigt__p_svn_prop_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_callbacks2_t[] = {  {&_swigt__p_svn_ra_callbacks2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_callbacks_t[] = {  {&_swigt__p_svn_ra_callbacks_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_plugin_t[] = {  {&_swigt__p_svn_ra_plugin_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_reporter2_t[] = {  {&_swigt__p_svn_ra_reporter2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_reporter_t[] = {  {&_swigt__p_svn_ra_reporter_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_ra_session_t[] = {  {&_swigt__p_svn_ra_session_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stream_t[] = {  {&_swigt__p_svn_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_string_t[] = {  {&_swigt__p_svn_string_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stringbuf_t[] = {  {&_swigt__p_svn_stringbuf_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_op_t[] = {  {&_swigt__p_svn_txdelta_op_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_stream_t[] = {  {&_swigt__p_svn_txdelta_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_window_t[] = {  {&_swigt__p_svn_txdelta_window_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_checklist_t[] = {  {&_swigt__p_svn_version_checklist_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_t[] = {  {&_swigt__p_svn_version_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_unsigned_long[] = {  {&_swigt__p_unsigned_long, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_void[] = {  {&_swigt__p_void, 0, 0, 0},{0, 0, 0, 0}};

static swig_cast_info *swig_cast_initial[] = {
  _swigc__p_apr_array_header_t,
  _swigc__p_apr_file_t,
  _swigc__p_apr_hash_t,
  _swigc__p_apr_int32_t,
  _swigc__p_apr_int64_t,
  _swigc__p_apr_pool_t,
  _swigc__p_f_apr_off_t_apr_off_t_p_void_p_apr_pool_t__void,
  _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_apr_file_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_void_p_q_const__char_p_q_const__svn_ra_callbacks_t_p_void_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_q_const__svn_commit_info_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_apr_hash_t_svn_revnum_t_p_q_const__char_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_apr_hash_t_p_q_const__char_svn_revnum_t_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__svn_delta_editor_t_p_p_void_p_q_const__char_svn_commit_callback_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_p_q_const__svn_ra_reporter_t_p_p_void_svn_revnum_t_p_q_const__char_svn_boolean_t_svn_boolean_t_p_q_const__char_p_q_const__svn_delta_editor_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__apr_array_header_t_svn_revnum_t_svn_revnum_t_svn_boolean_t_svn_boolean_t_svn_log_message_receiver_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_boolean_t_p_q_const__svn_lock_t_p_svn_error_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_apr_hash_t_p_svn_txdelta_window_handler_t_p_p_void_p_apr_array_header_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_p_apr_hash_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_node_kind_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_p_svn_stream_t_p_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_boolean_t_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_svn_revnum_t_svn_revnum_t_svn_ra_file_rev_handler_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_svn_revnum_t_apr_time_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_svn_revnum_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_svn_revnum_t_p_p_apr_hash_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_svn_revnum_t_p_q_const__char_p_p_svn_string_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_svn_revnum_t_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_svn_revnum_t_p_q_const__char_p_q_const__char_p_void__p_svn_error_t,
  _swigc__p_f_void__p_svn_version_t,
  _swigc__p_int,
  _swigc__p_long,
  _swigc__p_p_apr_file_t,
  _swigc__p_p_apr_hash_t,
  _swigc__p_p_char,
  _swigc__p_p_svn_delta_editor_t,
  _swigc__p_p_svn_dirent_t,
  _swigc__p_p_svn_lock_t,
  _swigc__p_p_svn_ra_callbacks2_t,
  _swigc__p_p_svn_ra_plugin_t,
  _swigc__p_p_svn_ra_reporter2_t,
  _swigc__p_p_svn_ra_reporter_t,
  _swigc__p_p_svn_ra_session_t,
  _swigc__p_p_svn_string_t,
  _swigc__p_p_svn_stringbuf_t,
  _swigc__p_p_void,
  _swigc__p_svn_auth_baton_t,
  _swigc__p_svn_auth_cred_simple_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_pw_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_t,
  _swigc__p_svn_auth_cred_ssl_server_trust_t,
  _swigc__p_svn_auth_cred_username_t,
  _swigc__p_svn_auth_iterstate_t,
  _swigc__p_svn_auth_provider_object_t,
  _swigc__p_svn_auth_provider_t,
  _swigc__p_svn_auth_ssl_server_cert_info_t,
  _swigc__p_svn_commit_info_t,
  _swigc__p_svn_config_t,
  _swigc__p_svn_delta_editor_t,
  _swigc__p_svn_diff_datasource_e,
  _swigc__p_svn_diff_file_ignore_space_t,
  _swigc__p_svn_diff_file_options_t,
  _swigc__p_svn_diff_fns_t,
  _swigc__p_svn_diff_output_fns_t,
  _swigc__p_svn_diff_t,
  _swigc__p_svn_dirent_t,
  _swigc__p_svn_errno_t,
  _swigc__p_svn_error_t,
  _swigc__p_svn_io_dirent_t,
  _swigc__p_svn_io_file_del_t,
  _swigc__p_svn_lock_t,
  _swigc__p_svn_log_changed_path_t,
  _swigc__p_svn_node_kind_t,
  _swigc__p_svn_opt_revision_t,
  _swigc__p_svn_opt_revision_value_t,
  _swigc__p_svn_opt_subcommand_desc2_t,
  _swigc__p_svn_opt_subcommand_desc_t,
  _swigc__p_svn_prop_kind,
  _swigc__p_svn_prop_t,
  _swigc__p_svn_ra_callbacks2_t,
  _swigc__p_svn_ra_callbacks_t,
  _swigc__p_svn_ra_plugin_t,
  _swigc__p_svn_ra_reporter2_t,
  _swigc__p_svn_ra_reporter_t,
  _swigc__p_svn_ra_session_t,
  _swigc__p_svn_stream_t,
  _swigc__p_svn_string_t,
  _swigc__p_svn_stringbuf_t,
  _swigc__p_svn_txdelta_op_t,
  _swigc__p_svn_txdelta_stream_t,
  _swigc__p_svn_txdelta_window_t,
  _swigc__p_svn_version_checklist_t,
  _swigc__p_svn_version_t,
  _swigc__p_unsigned_long,
  _swigc__p_void,
};


/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (END) -------- */

/*************************************************************************
 * Type initialization:
 * This problem is tough by the requirement that no dynamic 
 * memory is used. Also, since swig_type_info structures store pointers to 
 * swig_cast_info structures and swig_cast_info structures store pointers back
 * to swig_type_info structures, we need some lookup code at initialization. 
 * The idea is that swig generates all the structures that are needed. 
 * The runtime then collects these partially filled structures. 
 * The SWIG_InitializeModule function takes these initial arrays out of 
 * swig_module, and does all the lookup, filling in the swig_module.types
 * array with the correct data and linking the correct swig_cast_info
 * structures together.

 * The generated swig_type_info structures are assigned staticly to an initial 
 * array. We just loop though that array, and handle each type individually.
 * First we lookup if this type has been already loaded, and if so, use the
 * loaded structure instead of the generated one. Then we have to fill in the
 * cast linked list. The cast data is initially stored in something like a
 * two-dimensional array. Each row corresponds to a type (there are the same
 * number of rows as there are in the swig_type_initial array). Each entry in
 * a column is one of the swig_cast_info structures for that type.
 * The cast_initial array is actually an array of arrays, because each row has
 * a variable number of columns. So to actually build the cast linked list,
 * we find the array of casts associated with the type, and loop through it 
 * adding the casts to the list. The one last trick we need to do is making
 * sure the type pointer in the swig_cast_info struct is correct.

 * First off, we lookup the cast->type name to see if it is already loaded. 
 * There are three cases to handle:
 *  1) If the cast->type has already been loaded AND the type we are adding
 *     casting info to has not been loaded (it is in this module), THEN we
 *     replace the cast->type pointer with the type pointer that has already
 *     been loaded.
 *  2) If BOTH types (the one we are adding casting info to, and the 
 *     cast->type) are loaded, THEN the cast info has already been loaded by
 *     the previous module so we just ignore it.
 *  3) Finally, if cast->type has not already been loaded, then we add that
 *     swig_cast_info to the linked list (because the cast->type) pointer will
 *     be correct.
**/

#ifdef __cplusplus
extern "C" {
#endif

SWIGRUNTIME void
SWIG_InitializeModule(void *clientdata) {
  swig_type_info *type, *ret;
  swig_cast_info *cast;
  size_t i;
  swig_module_info *module_head;
  static int init_run = 0;

  clientdata = clientdata;

  if (init_run) return;
  init_run = 1;

  /* Initialize the swig_module */
  swig_module.type_initial = swig_type_initial;
  swig_module.cast_initial = swig_cast_initial;

  /* Try and load any already created modules */
  module_head = SWIG_GetModule(clientdata);
  if (module_head) {
    swig_module.next = module_head->next;
    module_head->next = &swig_module;
  } else {
    /* This is the first module loaded */
    swig_module.next = &swig_module;
    SWIG_SetModule(clientdata, &swig_module);
  }
		 
  /* Now work on filling in swig_module.types */
  for (i = 0; i < swig_module.size; ++i) {
    type = 0;

    /* if there is another module already loaded */
    if (swig_module.next != &swig_module) {
      type = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, swig_module.type_initial[i]->name);
    }
    if (type) {
      /* Overwrite clientdata field */
      if (swig_module.type_initial[i]->clientdata) type->clientdata = swig_module.type_initial[i]->clientdata;
    } else {
      type = swig_module.type_initial[i];
    }

    /* Insert casting types */
    cast = swig_module.cast_initial[i];
    while (cast->type) {
    
      /* Don't need to add information already in the list */
      ret = 0;
      if (swig_module.next != &swig_module) {
        ret = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, cast->type->name);
      }
      if (ret && type == swig_module.type_initial[i]) {
        cast->type = ret;
        ret = 0;
      }
      
      if (!ret) {
        if (type->cast) {
          type->cast->prev = cast;
          cast->next = type->cast;
        }
        type->cast = cast;
      }

      cast++;
    }

    /* Set entry in modules->types array equal to the type */
    swig_module.types[i] = type;
  }
}

/* This function will propagate the clientdata field of type to
* any new swig_type_info structures that have been added into the list
* of equivalent types.  It is like calling
* SWIG_TypeClientData(type, clientdata) a second time.
*/
SWIGRUNTIME void
SWIG_PropagateClientData(void) {
  size_t i;
  swig_cast_info *equiv;
  static int init_run = 0;

  if (init_run) return;
  init_run = 1;

  for (i = 0; i < swig_module.size; i++) {
    if (swig_module.types[i]->clientdata) {
      equiv = swig_module.types[i]->cast;
      while (equiv) {
        if (!equiv->converter) {
          if (equiv->type && !equiv->type->clientdata)
            SWIG_TypeClientData(equiv->type, swig_module.types[i]->clientdata);
        }
        equiv = equiv->next;
      }
    }
  }
}

#ifdef __cplusplus
}
#endif


#ifdef __cplusplus
extern "C"
#endif
SWIGEXPORT void Init_ra(void) {
    int i;
    
    SWIG_InitRuntime();
    mRa = rb_define_module("Svn");
    mRa = rb_define_module_under(mRa, "Ext");
    mRa = rb_define_module_under(mRa, "Ra");
    
    SWIG_InitializeModule(0);
    for (i = 0; i < swig_module.size; i++) {
        SWIG_define_class(swig_module.types[i]);
    }
    
    rb_require("svn/ext/core");
    rb_require("svn/ext/delta");
    rb_define_module_function(mRa, "svn_ra_version", _wrap_svn_ra_version, -1);
    
    cSvn_ra_reporter2_t.klass = rb_define_class_under(mRa, "Svn_ra_reporter2_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_ra_reporter2_t, (void *) &cSvn_ra_reporter2_t);
    rb_define_alloc_func(cSvn_ra_reporter2_t.klass, _wrap_svn_ra_reporter2_t_allocate);
    rb_define_method(cSvn_ra_reporter2_t.klass, "initialize", _wrap_new_svn_ra_reporter2_t, -1);
    rb_define_method(cSvn_ra_reporter2_t.klass, "set_path=", _wrap_svn_ra_reporter2_t_set_path_set, -1);
    rb_define_method(cSvn_ra_reporter2_t.klass, "set_path", _wrap_svn_ra_reporter2_t_set_path_get, -1);
    rb_define_method(cSvn_ra_reporter2_t.klass, "delete_path=", _wrap_svn_ra_reporter2_t_delete_path_set, -1);
    rb_define_method(cSvn_ra_reporter2_t.klass, "delete_path", _wrap_svn_ra_reporter2_t_delete_path_get, -1);
    rb_define_method(cSvn_ra_reporter2_t.klass, "link_path=", _wrap_svn_ra_reporter2_t_link_path_set, -1);
    rb_define_method(cSvn_ra_reporter2_t.klass, "link_path", _wrap_svn_ra_reporter2_t_link_path_get, -1);
    rb_define_method(cSvn_ra_reporter2_t.klass, "finish_report=", _wrap_svn_ra_reporter2_t_finish_report_set, -1);
    rb_define_method(cSvn_ra_reporter2_t.klass, "finish_report", _wrap_svn_ra_reporter2_t_finish_report_get, -1);
    rb_define_method(cSvn_ra_reporter2_t.klass, "abort_report=", _wrap_svn_ra_reporter2_t_abort_report_set, -1);
    rb_define_method(cSvn_ra_reporter2_t.klass, "abort_report", _wrap_svn_ra_reporter2_t_abort_report_get, -1);
    cSvn_ra_reporter2_t.mark = 0;
    cSvn_ra_reporter2_t.destroy = (void (*)(void *)) free_svn_ra_reporter2_t;
    
    cSvn_ra_reporter_t.klass = rb_define_class_under(mRa, "Svn_ra_reporter_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_ra_reporter_t, (void *) &cSvn_ra_reporter_t);
    rb_define_alloc_func(cSvn_ra_reporter_t.klass, _wrap_svn_ra_reporter_t_allocate);
    rb_define_method(cSvn_ra_reporter_t.klass, "initialize", _wrap_new_svn_ra_reporter_t, -1);
    rb_define_method(cSvn_ra_reporter_t.klass, "set_path=", _wrap_svn_ra_reporter_t_set_path_set, -1);
    rb_define_method(cSvn_ra_reporter_t.klass, "set_path", _wrap_svn_ra_reporter_t_set_path_get, -1);
    rb_define_method(cSvn_ra_reporter_t.klass, "delete_path=", _wrap_svn_ra_reporter_t_delete_path_set, -1);
    rb_define_method(cSvn_ra_reporter_t.klass, "delete_path", _wrap_svn_ra_reporter_t_delete_path_get, -1);
    rb_define_method(cSvn_ra_reporter_t.klass, "link_path=", _wrap_svn_ra_reporter_t_link_path_set, -1);
    rb_define_method(cSvn_ra_reporter_t.klass, "link_path", _wrap_svn_ra_reporter_t_link_path_get, -1);
    rb_define_method(cSvn_ra_reporter_t.klass, "finish_report=", _wrap_svn_ra_reporter_t_finish_report_set, -1);
    rb_define_method(cSvn_ra_reporter_t.klass, "finish_report", _wrap_svn_ra_reporter_t_finish_report_get, -1);
    rb_define_method(cSvn_ra_reporter_t.klass, "abort_report=", _wrap_svn_ra_reporter_t_abort_report_set, -1);
    rb_define_method(cSvn_ra_reporter_t.klass, "abort_report", _wrap_svn_ra_reporter_t_abort_report_get, -1);
    cSvn_ra_reporter_t.mark = 0;
    cSvn_ra_reporter_t.destroy = (void (*)(void *)) free_svn_ra_reporter_t;
    
    cSvn_ra_callbacks2_t.klass = rb_define_class_under(mRa, "Svn_ra_callbacks2_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_ra_callbacks2_t, (void *) &cSvn_ra_callbacks2_t);
    rb_define_alloc_func(cSvn_ra_callbacks2_t.klass, _wrap_svn_ra_callbacks2_t_allocate);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "initialize", _wrap_new_svn_ra_callbacks2_t, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "open_tmp_file=", _wrap_svn_ra_callbacks2_t_open_tmp_file_set, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "open_tmp_file", _wrap_svn_ra_callbacks2_t_open_tmp_file_get, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "auth_baton=", _wrap_svn_ra_callbacks2_t_auth_baton_set, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "auth_baton", _wrap_svn_ra_callbacks2_t_auth_baton_get, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "get_wc_prop=", _wrap_svn_ra_callbacks2_t_get_wc_prop_set, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "get_wc_prop", _wrap_svn_ra_callbacks2_t_get_wc_prop_get, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "set_wc_prop=", _wrap_svn_ra_callbacks2_t_set_wc_prop_set, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "set_wc_prop", _wrap_svn_ra_callbacks2_t_set_wc_prop_get, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "push_wc_prop=", _wrap_svn_ra_callbacks2_t_push_wc_prop_set, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "push_wc_prop", _wrap_svn_ra_callbacks2_t_push_wc_prop_get, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "invalidate_wc_props=", _wrap_svn_ra_callbacks2_t_invalidate_wc_props_set, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "invalidate_wc_props", _wrap_svn_ra_callbacks2_t_invalidate_wc_props_get, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "progress_func=", _wrap_svn_ra_callbacks2_t_progress_func_set, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "progress_func", _wrap_svn_ra_callbacks2_t_progress_func_get, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "progress_baton=", _wrap_svn_ra_callbacks2_t_progress_baton_set, -1);
    rb_define_method(cSvn_ra_callbacks2_t.klass, "progress_baton", _wrap_svn_ra_callbacks2_t_progress_baton_get, -1);
    cSvn_ra_callbacks2_t.mark = 0;
    cSvn_ra_callbacks2_t.destroy = (void (*)(void *)) free_svn_ra_callbacks2_t;
    
    cSvn_ra_callbacks_t.klass = rb_define_class_under(mRa, "Svn_ra_callbacks_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_ra_callbacks_t, (void *) &cSvn_ra_callbacks_t);
    rb_define_alloc_func(cSvn_ra_callbacks_t.klass, _wrap_svn_ra_callbacks_t_allocate);
    rb_define_method(cSvn_ra_callbacks_t.klass, "initialize", _wrap_new_svn_ra_callbacks_t, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "open_tmp_file=", _wrap_svn_ra_callbacks_t_open_tmp_file_set, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "open_tmp_file", _wrap_svn_ra_callbacks_t_open_tmp_file_get, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "auth_baton=", _wrap_svn_ra_callbacks_t_auth_baton_set, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "auth_baton", _wrap_svn_ra_callbacks_t_auth_baton_get, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "get_wc_prop=", _wrap_svn_ra_callbacks_t_get_wc_prop_set, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "get_wc_prop", _wrap_svn_ra_callbacks_t_get_wc_prop_get, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "set_wc_prop=", _wrap_svn_ra_callbacks_t_set_wc_prop_set, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "set_wc_prop", _wrap_svn_ra_callbacks_t_set_wc_prop_get, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "push_wc_prop=", _wrap_svn_ra_callbacks_t_push_wc_prop_set, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "push_wc_prop", _wrap_svn_ra_callbacks_t_push_wc_prop_get, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "invalidate_wc_props=", _wrap_svn_ra_callbacks_t_invalidate_wc_props_set, -1);
    rb_define_method(cSvn_ra_callbacks_t.klass, "invalidate_wc_props", _wrap_svn_ra_callbacks_t_invalidate_wc_props_get, -1);
    cSvn_ra_callbacks_t.mark = 0;
    cSvn_ra_callbacks_t.destroy = (void (*)(void *)) free_svn_ra_callbacks_t;
    rb_define_module_function(mRa, "svn_ra_initialize", _wrap_svn_ra_initialize, -1);
    rb_define_module_function(mRa, "svn_ra_create_callbacks", _wrap_svn_ra_create_callbacks, -1);
    rb_define_module_function(mRa, "svn_ra_open2", _wrap_svn_ra_open2, -1);
    rb_define_module_function(mRa, "svn_ra_open", _wrap_svn_ra_open, -1);
    rb_define_module_function(mRa, "svn_ra_reparent", _wrap_svn_ra_reparent, -1);
    rb_define_module_function(mRa, "svn_ra_get_latest_revnum", _wrap_svn_ra_get_latest_revnum, -1);
    rb_define_module_function(mRa, "svn_ra_get_dated_revision", _wrap_svn_ra_get_dated_revision, -1);
    rb_define_module_function(mRa, "svn_ra_change_rev_prop", _wrap_svn_ra_change_rev_prop, -1);
    rb_define_module_function(mRa, "svn_ra_rev_proplist", _wrap_svn_ra_rev_proplist, -1);
    rb_define_module_function(mRa, "svn_ra_rev_prop", _wrap_svn_ra_rev_prop, -1);
    rb_define_module_function(mRa, "svn_ra_get_commit_editor2", _wrap_svn_ra_get_commit_editor2, -1);
    rb_define_module_function(mRa, "svn_ra_get_commit_editor", _wrap_svn_ra_get_commit_editor, -1);
    rb_define_module_function(mRa, "svn_ra_get_file", _wrap_svn_ra_get_file, -1);
    rb_define_module_function(mRa, "svn_ra_get_dir2", _wrap_svn_ra_get_dir2, -1);
    rb_define_module_function(mRa, "svn_ra_get_dir", _wrap_svn_ra_get_dir, -1);
    rb_define_module_function(mRa, "svn_ra_do_update", _wrap_svn_ra_do_update, -1);
    rb_define_module_function(mRa, "svn_ra_do_switch", _wrap_svn_ra_do_switch, -1);
    rb_define_module_function(mRa, "svn_ra_do_status", _wrap_svn_ra_do_status, -1);
    rb_define_module_function(mRa, "svn_ra_do_diff2", _wrap_svn_ra_do_diff2, -1);
    rb_define_module_function(mRa, "svn_ra_do_diff", _wrap_svn_ra_do_diff, -1);
    rb_define_module_function(mRa, "svn_ra_get_log", _wrap_svn_ra_get_log, -1);
    rb_define_module_function(mRa, "svn_ra_check_path", _wrap_svn_ra_check_path, -1);
    rb_define_module_function(mRa, "svn_ra_stat", _wrap_svn_ra_stat, -1);
    rb_define_module_function(mRa, "svn_ra_get_uuid", _wrap_svn_ra_get_uuid, -1);
    rb_define_module_function(mRa, "svn_ra_get_repos_root", _wrap_svn_ra_get_repos_root, -1);
    rb_define_module_function(mRa, "svn_ra_get_locations", _wrap_svn_ra_get_locations, -1);
    rb_define_module_function(mRa, "svn_ra_get_file_revs", _wrap_svn_ra_get_file_revs, -1);
    rb_define_module_function(mRa, "svn_ra_lock", _wrap_svn_ra_lock, -1);
    rb_define_module_function(mRa, "svn_ra_unlock", _wrap_svn_ra_unlock, -1);
    rb_define_module_function(mRa, "svn_ra_get_lock", _wrap_svn_ra_get_lock, -1);
    rb_define_module_function(mRa, "svn_ra_get_locks", _wrap_svn_ra_get_locks, -1);
    rb_define_module_function(mRa, "svn_ra_replay", _wrap_svn_ra_replay, -1);
    rb_define_module_function(mRa, "svn_ra_print_modules", _wrap_svn_ra_print_modules, -1);
    rb_define_module_function(mRa, "svn_ra_print_ra_libraries", _wrap_svn_ra_print_ra_libraries, -1);
    
    cSvn_ra_plugin_t.klass = rb_define_class_under(mRa, "Svn_ra_plugin_t", rb_cObject);
    SWIG_TypeClientData(SWIGTYPE_p_svn_ra_plugin_t, (void *) &cSvn_ra_plugin_t);
    rb_define_alloc_func(cSvn_ra_plugin_t.klass, _wrap_svn_ra_plugin_t_allocate);
    rb_define_method(cSvn_ra_plugin_t.klass, "initialize", _wrap_new_svn_ra_plugin_t, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "name=", _wrap_svn_ra_plugin_t_name_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "name", _wrap_svn_ra_plugin_t_name_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "description=", _wrap_svn_ra_plugin_t_description_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "description", _wrap_svn_ra_plugin_t_description_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "open=", _wrap_svn_ra_plugin_t_open_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "open", _wrap_svn_ra_plugin_t_open_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_latest_revnum=", _wrap_svn_ra_plugin_t_get_latest_revnum_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_latest_revnum", _wrap_svn_ra_plugin_t_get_latest_revnum_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_dated_revision=", _wrap_svn_ra_plugin_t_get_dated_revision_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_dated_revision", _wrap_svn_ra_plugin_t_get_dated_revision_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "change_rev_prop=", _wrap_svn_ra_plugin_t_change_rev_prop_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "change_rev_prop", _wrap_svn_ra_plugin_t_change_rev_prop_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "rev_proplist=", _wrap_svn_ra_plugin_t_rev_proplist_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "rev_proplist", _wrap_svn_ra_plugin_t_rev_proplist_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "rev_prop=", _wrap_svn_ra_plugin_t_rev_prop_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "rev_prop", _wrap_svn_ra_plugin_t_rev_prop_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_commit_editor=", _wrap_svn_ra_plugin_t_get_commit_editor_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_commit_editor", _wrap_svn_ra_plugin_t_get_commit_editor_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_file=", _wrap_svn_ra_plugin_t_get_file_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_file", _wrap_svn_ra_plugin_t_get_file_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_dir=", _wrap_svn_ra_plugin_t_get_dir_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_dir", _wrap_svn_ra_plugin_t_get_dir_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "do_update=", _wrap_svn_ra_plugin_t_do_update_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "do_update", _wrap_svn_ra_plugin_t_do_update_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "do_switch=", _wrap_svn_ra_plugin_t_do_switch_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "do_switch", _wrap_svn_ra_plugin_t_do_switch_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "do_status=", _wrap_svn_ra_plugin_t_do_status_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "do_status", _wrap_svn_ra_plugin_t_do_status_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "do_diff=", _wrap_svn_ra_plugin_t_do_diff_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "do_diff", _wrap_svn_ra_plugin_t_do_diff_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_log=", _wrap_svn_ra_plugin_t_get_log_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_log", _wrap_svn_ra_plugin_t_get_log_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "check_path=", _wrap_svn_ra_plugin_t_check_path_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "check_path", _wrap_svn_ra_plugin_t_check_path_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_uuid=", _wrap_svn_ra_plugin_t_get_uuid_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_uuid", _wrap_svn_ra_plugin_t_get_uuid_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_repos_root=", _wrap_svn_ra_plugin_t_get_repos_root_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_repos_root", _wrap_svn_ra_plugin_t_get_repos_root_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_locations=", _wrap_svn_ra_plugin_t_get_locations_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_locations", _wrap_svn_ra_plugin_t_get_locations_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_file_revs=", _wrap_svn_ra_plugin_t_get_file_revs_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_file_revs", _wrap_svn_ra_plugin_t_get_file_revs_get, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_version=", _wrap_svn_ra_plugin_t_get_version_set, -1);
    rb_define_method(cSvn_ra_plugin_t.klass, "get_version", _wrap_svn_ra_plugin_t_get_version_get, -1);
    cSvn_ra_plugin_t.mark = 0;
    cSvn_ra_plugin_t.destroy = (void (*)(void *)) free_svn_ra_plugin_t;
    rb_define_const(mRa,"SVN_RA_ABI_VERSION", INT2NUM(2));
    rb_define_module_function(mRa, "svn_ra_init_ra_libs", _wrap_svn_ra_init_ra_libs, -1);
    rb_define_module_function(mRa, "svn_ra_get_ra_library", _wrap_svn_ra_get_ra_library, -1);
    rb_define_module_function(mRa, "svn_ra_reporter2_invoke_set_path", _wrap_svn_ra_reporter2_invoke_set_path, -1);
    rb_define_module_function(mRa, "svn_ra_reporter2_invoke_delete_path", _wrap_svn_ra_reporter2_invoke_delete_path, -1);
    rb_define_module_function(mRa, "svn_ra_reporter2_invoke_link_path", _wrap_svn_ra_reporter2_invoke_link_path, -1);
    rb_define_module_function(mRa, "svn_ra_reporter2_invoke_finish_report", _wrap_svn_ra_reporter2_invoke_finish_report, -1);
    rb_define_module_function(mRa, "svn_ra_reporter2_invoke_abort_report", _wrap_svn_ra_reporter2_invoke_abort_report, -1);
    rb_define_module_function(mRa, "svn_ra_reporter_invoke_set_path", _wrap_svn_ra_reporter_invoke_set_path, -1);
    rb_define_module_function(mRa, "svn_ra_reporter_invoke_delete_path", _wrap_svn_ra_reporter_invoke_delete_path, -1);
    rb_define_module_function(mRa, "svn_ra_reporter_invoke_link_path", _wrap_svn_ra_reporter_invoke_link_path, -1);
    rb_define_module_function(mRa, "svn_ra_reporter_invoke_finish_report", _wrap_svn_ra_reporter_invoke_finish_report, -1);
    rb_define_module_function(mRa, "svn_ra_reporter_invoke_abort_report", _wrap_svn_ra_reporter_invoke_abort_report, -1);
    rb_define_module_function(mRa, "svn_ra_callbacks2_invoke_open_tmp_file", _wrap_svn_ra_callbacks2_invoke_open_tmp_file, -1);
    rb_define_module_function(mRa, "svn_ra_callbacks_invoke_open_tmp_file", _wrap_svn_ra_callbacks_invoke_open_tmp_file, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_open", _wrap_svn_ra_plugin_invoke_open, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_get_latest_revnum", _wrap_svn_ra_plugin_invoke_get_latest_revnum, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_get_dated_revision", _wrap_svn_ra_plugin_invoke_get_dated_revision, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_change_rev_prop", _wrap_svn_ra_plugin_invoke_change_rev_prop, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_rev_proplist", _wrap_svn_ra_plugin_invoke_rev_proplist, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_rev_prop", _wrap_svn_ra_plugin_invoke_rev_prop, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_get_commit_editor", _wrap_svn_ra_plugin_invoke_get_commit_editor, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_get_file", _wrap_svn_ra_plugin_invoke_get_file, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_get_dir", _wrap_svn_ra_plugin_invoke_get_dir, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_do_update", _wrap_svn_ra_plugin_invoke_do_update, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_do_switch", _wrap_svn_ra_plugin_invoke_do_switch, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_do_status", _wrap_svn_ra_plugin_invoke_do_status, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_do_diff", _wrap_svn_ra_plugin_invoke_do_diff, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_get_log", _wrap_svn_ra_plugin_invoke_get_log, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_check_path", _wrap_svn_ra_plugin_invoke_check_path, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_get_uuid", _wrap_svn_ra_plugin_invoke_get_uuid, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_get_repos_root", _wrap_svn_ra_plugin_invoke_get_repos_root, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_get_locations", _wrap_svn_ra_plugin_invoke_get_locations, -1);
    rb_define_module_function(mRa, "svn_ra_plugin_invoke_get_file_revs", _wrap_svn_ra_plugin_invoke_get_file_revs, -1);
}

