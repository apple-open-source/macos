/* ----------------------------------------------------------------------------
 * This file was automatically generated by SWIG (http://www.swig.org).
 * Version 1.3.25
 * 
 * This file is not intended to be easily readable and contains a number of 
 * coding conventions designed to improve portability and efficiency. Do not make
 * changes to this file unless you know what you are doing--modify the SWIG 
 * interface file instead. 
 * ----------------------------------------------------------------------------- */

#define SWIGPYTHON
/***********************************************************************
 *
 *  This section contains generic SWIG labels for method/variable
 *  declarations/attributes, and other compiler dependent labels.
 *
 ************************************************************************/

/* template workaround for compilers that cannot correctly implement the C++ standard */
#ifndef SWIGTEMPLATEDISAMBIGUATOR
#  if defined(__SUNPRO_CC) && (__SUNPRO_CC <= 0x560)
#    define SWIGTEMPLATEDISAMBIGUATOR template
#  else
#    define SWIGTEMPLATEDISAMBIGUATOR 
#  endif
#endif

/* inline attribute */
#ifndef SWIGINLINE
# if defined(__cplusplus) || (defined(__GNUC__) && !defined(__STRICT_ANSI__))
#   define SWIGINLINE inline
# else
#   define SWIGINLINE
# endif
#endif

/* attribute recognised by some compilers to avoid 'unused' warnings */
#ifndef SWIGUNUSED
# if defined(__GNUC__) || defined(__ICC)
#   define SWIGUNUSED __attribute__ ((unused)) 
# else
#   define SWIGUNUSED 
# endif
#endif

/* internal SWIG method */
#ifndef SWIGINTERN
# define SWIGINTERN static SWIGUNUSED
#endif

/* internal inline SWIG method */
#ifndef SWIGINTERNINLINE
# define SWIGINTERNINLINE SWIGINTERN SWIGINLINE
#endif

/* exporting methods for Windows DLLs */
#ifndef SWIGEXPORT
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   if defined(STATIC_LINKED)
#     define SWIGEXPORT
#   else
#     define SWIGEXPORT __declspec(dllexport)
#   endif
# else
#   define SWIGEXPORT
# endif
#endif

/* calling conventions for Windows */
#ifndef SWIGSTDCALL
# if defined(_WIN32) || defined(__WIN32__) || defined(__CYGWIN__)
#   define SWIGSTDCALL __stdcall
# else
#   define SWIGSTDCALL
# endif 
#endif



#include <Python.h>

/***********************************************************************
 * swigrun.swg
 *
 *     This file contains generic CAPI SWIG runtime support for pointer
 *     type checking.
 *
 ************************************************************************/

/* This should only be incremented when either the layout of swig_type_info changes,
   or for whatever reason, the runtime changes incompatibly */
#define SWIG_RUNTIME_VERSION "2"

/* define SWIG_TYPE_TABLE_NAME as "SWIG_TYPE_TABLE" */
#ifdef SWIG_TYPE_TABLE
# define SWIG_QUOTE_STRING(x) #x
# define SWIG_EXPAND_AND_QUOTE_STRING(x) SWIG_QUOTE_STRING(x)
# define SWIG_TYPE_TABLE_NAME SWIG_EXPAND_AND_QUOTE_STRING(SWIG_TYPE_TABLE)
#else
# define SWIG_TYPE_TABLE_NAME
#endif

/*
  You can use the SWIGRUNTIME and SWIGRUNTIMEINLINE macros for
  creating a static or dynamic library from the swig runtime code.
  In 99.9% of the cases, swig just needs to declare them as 'static'.
  
  But only do this if is strictly necessary, ie, if you have problems
  with your compiler or so.
*/

#ifndef SWIGRUNTIME
# define SWIGRUNTIME SWIGINTERN
#endif

#ifndef SWIGRUNTIMEINLINE
# define SWIGRUNTIMEINLINE SWIGRUNTIME SWIGINLINE
#endif

#include <string.h>

#ifdef __cplusplus
extern "C" {
#endif

typedef void *(*swig_converter_func)(void *);
typedef struct swig_type_info *(*swig_dycast_func)(void **);

/* Structure to store inforomation on one type */
typedef struct swig_type_info {
  const char             *name;			/* mangled name of this type */
  const char             *str;			/* human readable name of this type */
  swig_dycast_func        dcast;		/* dynamic cast function down a hierarchy */
  struct swig_cast_info  *cast;			/* linked list of types that can cast into this type */
  void                   *clientdata;		/* language specific type data */
} swig_type_info;

/* Structure to store a type and conversion function used for casting */
typedef struct swig_cast_info {
  swig_type_info         *type;			/* pointer to type that is equivalent to this type */
  swig_converter_func     converter;		/* function to cast the void pointers */
  struct swig_cast_info  *next;			/* pointer to next cast in linked list */
  struct swig_cast_info  *prev;			/* pointer to the previous cast */
} swig_cast_info;

/* Structure used to store module information
 * Each module generates one structure like this, and the runtime collects
 * all of these structures and stores them in a circularly linked list.*/
typedef struct swig_module_info {
  swig_type_info         **types;		/* Array of pointers to swig_type_info structures that are in this module */
  size_t                 size;		        /* Number of types in this module */
  struct swig_module_info *next;		/* Pointer to next element in circularly linked list */
  swig_type_info         **type_initial;	/* Array of initially generated type structures */
  swig_cast_info         **cast_initial;	/* Array of initially generated casting structures */
  void                    *clientdata;		/* Language specific module data */
} swig_module_info;


/* 
  Compare two type names skipping the space characters, therefore
  "char*" == "char *" and "Class<int>" == "Class<int >", etc.

  Return 0 when the two name types are equivalent, as in
  strncmp, but skipping ' '.
*/
SWIGRUNTIME int
SWIG_TypeNameComp(const char *f1, const char *l1,
		  const char *f2, const char *l2) {
  for (;(f1 != l1) && (f2 != l2); ++f1, ++f2) {
    while ((*f1 == ' ') && (f1 != l1)) ++f1;
    while ((*f2 == ' ') && (f2 != l2)) ++f2;
    if (*f1 != *f2) return (int)(*f1 - *f2);
  }
  return (l1 - f1) - (l2 - f2);
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if not equal, 1 if equal
*/
SWIGRUNTIME int
SWIG_TypeEquiv(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}

/*
  Check type equivalence in a name list like <name1>|<name2>|...
  Return 0 if equal, -1 if nb < tb, 1 if nb > tb
*/
SWIGRUNTIME int
SWIG_TypeCompare(const char *nb, const char *tb) {
  int equiv = 0;
  const char* te = tb + strlen(tb);
  const char* ne = nb;
  while (!equiv && *ne) {
    for (nb = ne; *ne; ++ne) {
      if (*ne == '|') break;
    }
    equiv = (SWIG_TypeNameComp(nb, ne, tb, te) == 0) ? 1 : 0;
    if (*ne) ++ne;
  }
  return equiv;
}


/* think of this as a c++ template<> or a scheme macro */
#define SWIG_TypeCheck_Template(comparison, ty)         \
  if (ty) {                                             \
    swig_cast_info *iter = ty->cast;                    \
    while (iter) {                                      \
      if (comparison) {                                 \
        if (iter == ty->cast) return iter;              \
        /* Move iter to the top of the linked list */   \
        iter->prev->next = iter->next;                  \
        if (iter->next)                                 \
          iter->next->prev = iter->prev;                \
        iter->next = ty->cast;                          \
        iter->prev = 0;                                 \
        if (ty->cast) ty->cast->prev = iter;            \
        ty->cast = iter;                                \
        return iter;                                    \
      }                                                 \
      iter = iter->next;                                \
    }                                                   \
  }                                                     \
  return 0

/*
  Check the typename
*/
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheck(const char *c, swig_type_info *ty) {
  SWIG_TypeCheck_Template(strcmp(iter->type->name, c) == 0, ty);
}

/* Same as previous function, except strcmp is replaced with a pointer comparison */
SWIGRUNTIME swig_cast_info *
SWIG_TypeCheckStruct(swig_type_info *from, swig_type_info *into) {
  SWIG_TypeCheck_Template(iter->type == from, into);
}

/*
  Cast a pointer up an inheritance hierarchy
*/
SWIGRUNTIMEINLINE void *
SWIG_TypeCast(swig_cast_info *ty, void *ptr) {
  return ((!ty) || (!ty->converter)) ? ptr : (*ty->converter)(ptr);
}

/* 
   Dynamic pointer casting. Down an inheritance hierarchy
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeDynamicCast(swig_type_info *ty, void **ptr) {
  swig_type_info *lastty = ty;
  if (!ty || !ty->dcast) return ty;
  while (ty && (ty->dcast)) {
    ty = (*ty->dcast)(ptr);
    if (ty) lastty = ty;
  }
  return lastty;
}

/*
  Return the name associated with this type
*/
SWIGRUNTIMEINLINE const char *
SWIG_TypeName(const swig_type_info *ty) {
  return ty->name;
}

/*
  Return the pretty name associated with this type,
  that is an unmangled type name in a form presentable to the user.
*/
SWIGRUNTIME const char *
SWIG_TypePrettyName(const swig_type_info *type) {
  /* The "str" field contains the equivalent pretty names of the
     type, separated by vertical-bar characters.  We choose
     to print the last name, as it is often (?) the most
     specific. */
  if (type->str != NULL) {
    const char *last_name = type->str;
    const char *s;
    for (s = type->str; *s; s++)
      if (*s == '|') last_name = s+1;
    return last_name;
  }
  else
    return type->name;
}

/* 
   Set the clientdata field for a type
*/
SWIGRUNTIME void
SWIG_TypeClientData(swig_type_info *ti, void *clientdata) {
  if (!ti->clientdata) {
    swig_cast_info *cast = ti->cast;
    /* if (ti->clientdata == clientdata) return; */
    ti->clientdata = clientdata;
    
    while (cast) {
      if (!cast->converter)
	SWIG_TypeClientData(cast->type, clientdata);
      cast = cast->next;
    }
  }
}

/*
  Search for a swig_type_info structure only by mangled name
  Search is a O(log #types)
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_MangledTypeQueryModule(swig_module_info *start, 
                            swig_module_info *end, 
		            const char *name) {
  swig_module_info *iter = start;
  do {
    if (iter->size) {
      register size_t l = 0;
      register size_t r = iter->size - 1;
      do {
	/* since l+r >= 0, we can (>> 1) instead (/ 2) */
	register size_t i = (l + r) >> 1; 
	const char *iname = iter->types[i]->name;
	if (iname) {
	  register int compare = strcmp(name, iname);
	  if (compare == 0) {	    
	    return iter->types[i];
	  } else if (compare < 0) {
	    if (i) {
	      r = i - 1;
	    } else {
	      break;
	    }
	  } else if (compare > 0) {
	    l = i + 1;
	  }
	} else {
	  break; /* should never happen */
	}
      } while (l <= r);
    }
    iter = iter->next;
  } while (iter != end);
  return 0;
}

/*
  Search for a swig_type_info structure for either a mangled name or a human readable name.
  It first searches the mangled names of the types, which is a O(log #types)
  If a type is not found it then searches the human readable names, which is O(#types).
  
  We start searching at module start, and finish searching when start == end.  
  Note: if start == end at the beginning of the function, we go all the way around
  the circular list.
*/
SWIGRUNTIME swig_type_info *
SWIG_TypeQueryModule(swig_module_info *start, 
                     swig_module_info *end, 
		     const char *name) {
  /* STEP 1: Search the name field using binary search */
  swig_type_info *ret = SWIG_MangledTypeQueryModule(start, end, name);
  if (ret) {
    return ret;
  } else {
    /* STEP 2: If the type hasn't been found, do a complete search
       of the str field (the human readable name) */
    swig_module_info *iter = start;
    do {
      register size_t i = 0;
      for (; i < iter->size; ++i) {
	if (iter->types[i]->str && (SWIG_TypeEquiv(iter->types[i]->str, name)))
	  return iter->types[i];
      }
      iter = iter->next;
    } while (iter != end);
  }
  
  /* neither found a match */
  return 0;
}


/* 
   Pack binary data into a string
*/
SWIGRUNTIME char *
SWIG_PackData(char *c, void *ptr, size_t sz) {
  static const char hex[17] = "0123456789abcdef";
  register const unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu =  u + sz;
  for (; u != eu; ++u) {
    register unsigned char uu = *u;
    *(c++) = hex[(uu & 0xf0) >> 4];
    *(c++) = hex[uu & 0xf];
  }
  return c;
}

/* 
   Unpack binary data from a string
*/
SWIGRUNTIME const char *
SWIG_UnpackData(const char *c, void *ptr, size_t sz) {
  register unsigned char *u = (unsigned char *) ptr;
  register const unsigned char *eu = u + sz;
  for (; u != eu; ++u) {
    register char d = *(c++);
    register unsigned char uu = 0;
    if ((d >= '0') && (d <= '9'))
      uu = ((d - '0') << 4);
    else if ((d >= 'a') && (d <= 'f'))
      uu = ((d - ('a'-10)) << 4);
    else 
      return (char *) 0;
    d = *(c++);
    if ((d >= '0') && (d <= '9'))
      uu |= (d - '0');
    else if ((d >= 'a') && (d <= 'f'))
      uu |= (d - ('a'-10));
    else 
      return (char *) 0;
    *u = uu;
  }
  return c;
}

/* 
   Pack 'void *' into a string buffer.
*/
SWIGRUNTIME char *
SWIG_PackVoidPtr(char *buff, void *ptr, const char *name, size_t bsz) {
  char *r = buff;
  if ((2*sizeof(void *) + 2) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,&ptr,sizeof(void *));
  if (strlen(name) + 1 > (bsz - (r - buff))) return 0;
  strcpy(r,name);
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackVoidPtr(const char *c, void **ptr, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      *ptr = (void *) 0;
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sizeof(void *));
}

SWIGRUNTIME char *
SWIG_PackDataName(char *buff, void *ptr, size_t sz, const char *name, size_t bsz) {
  char *r = buff;
  size_t lname = (name ? strlen(name) : 0);
  if ((2*sz + 2 + lname) > bsz) return 0;
  *(r++) = '_';
  r = SWIG_PackData(r,ptr,sz);
  if (lname) {
    strncpy(r,name,lname+1);
  } else {
    *r = 0;
  }
  return buff;
}

SWIGRUNTIME const char *
SWIG_UnpackDataName(const char *c, void *ptr, size_t sz, const char *name) {
  if (*c != '_') {
    if (strcmp(c,"NULL") == 0) {
      memset(ptr,0,sz);
      return name;
    } else {
      return 0;
    }
  }
  return SWIG_UnpackData(++c,ptr,sz);
}

#ifdef __cplusplus
}
#endif


/* -----------------------------------------------------------------------------
 * SWIG API. Portion that goes into the runtime
 * ----------------------------------------------------------------------------- */

#ifdef __cplusplus
extern "C" {
#endif

/* -----------------------------------------------------------------------------
 * for internal method declarations
 * ----------------------------------------------------------------------------- */

#ifndef SWIGINTERN
#  define SWIGINTERN static SWIGUNUSED
#endif

#ifndef SWIGINTERNINLINE
#  define SWIGINTERNINLINE SWIGINTERN SWIGINLINE
#endif

/*
  Exception handling in wrappers
*/
#define SWIG_fail                goto fail
#define SWIG_arg_fail(arg)       SWIG_Python_ArgFail(arg)
#define SWIG_append_errmsg(msg)   SWIG_Python_AddErrMesg(msg,0)
#define SWIG_preppend_errmsg(msg) SWIG_Python_AddErrMesg(msg,1)
#define SWIG_type_error(type,obj) SWIG_Python_TypeError(type,obj)
#define SWIG_null_ref(type)       SWIG_Python_NullRef(type)

/*
  Contract support
*/
#define SWIG_contract_assert(expr, msg) \
 if (!(expr)) { PyErr_SetString(PyExc_RuntimeError, (char *) msg ); goto fail; } else

/* -----------------------------------------------------------------------------
 * Constant declarations
 * ----------------------------------------------------------------------------- */

/* Constant Types */
#define SWIG_PY_INT     1
#define SWIG_PY_FLOAT   2
#define SWIG_PY_STRING  3
#define SWIG_PY_POINTER 4
#define SWIG_PY_BINARY  5

/* Constant information structure */
typedef struct swig_const_info {
    int type;
    char *name;
    long lvalue;
    double dvalue;
    void   *pvalue;
    swig_type_info **ptype;
} swig_const_info;


/* -----------------------------------------------------------------------------
 * Alloc. memory flags
 * ----------------------------------------------------------------------------- */
#define SWIG_OLDOBJ  1
#define SWIG_NEWOBJ  SWIG_OLDOBJ + 1
#define SWIG_PYSTR   SWIG_NEWOBJ + 1

#ifdef __cplusplus
}
#endif


/***********************************************************************
 * pyrun.swg
 *
 *     This file contains the runtime support for Python modules
 *     and includes code for managing global variables and pointer
 *     type checking.
 *
 * Author : David Beazley (beazley@cs.uchicago.edu)
 ************************************************************************/

/* Common SWIG API */
#define SWIG_ConvertPtr(obj, pp, type, flags)    SWIG_Python_ConvertPtr(obj, pp, type, flags)
#define SWIG_NewPointerObj(p, type, flags)       SWIG_Python_NewPointerObj(p, type, flags)
#define SWIG_MustGetPtr(p, type, argnum, flags)  SWIG_Python_MustGetPtr(p, type, argnum, flags)
 

/* Python-specific SWIG API */
#define SWIG_ConvertPacked(obj, ptr, sz, ty, flags)   SWIG_Python_ConvertPacked(obj, ptr, sz, ty, flags)
#define SWIG_NewPackedObj(ptr, sz, type)              SWIG_Python_NewPackedObj(ptr, sz, type)

/* Runtime API */
#define SWIG_GetModule(clientdata) SWIG_Python_GetModule()
#define SWIG_SetModule(clientdata, pointer) SWIG_Python_SetModule(pointer)

/* -----------------------------------------------------------------------------
 * Pointer declarations
 * ----------------------------------------------------------------------------- */
/*
  Use SWIG_NO_COBJECT_TYPES to force the use of strings to represent
  C/C++ pointers in the python side. Very useful for debugging, but
  not always safe.
*/
#if !defined(SWIG_NO_COBJECT_TYPES) && !defined(SWIG_COBJECT_TYPES)
#  define SWIG_COBJECT_TYPES
#endif

/* Flags for pointer conversion */
#define SWIG_POINTER_EXCEPTION     0x1
#define SWIG_POINTER_DISOWN        0x2


/* Add PyOS_snprintf for old Pythons */
#if PY_VERSION_HEX < 0x02020000
#define PyOS_snprintf snprintf
#endif

#ifdef __cplusplus
extern "C" {
#endif

/* -----------------------------------------------------------------------------
 * Create a new pointer string 
 * ----------------------------------------------------------------------------- */
#ifndef SWIG_BUFFER_SIZE
#define SWIG_BUFFER_SIZE 1024
#endif

#if defined(SWIG_COBJECT_TYPES)
#if !defined(SWIG_COBJECT_PYTHON)
/* -----------------------------------------------------------------------------
 * Implements a simple Swig Object type, and use it instead of PyCObject
 * ----------------------------------------------------------------------------- */

typedef struct {
  PyObject_HEAD
  void *ptr;
  const char *desc;
} PySwigObject;

/* Declarations for objects of type PySwigObject */

SWIGRUNTIME int
PySwigObject_print(PySwigObject *v, FILE *fp, int flags)
{
  char result[SWIG_BUFFER_SIZE];
  flags = flags;
  if (SWIG_PackVoidPtr(result, v->ptr, v->desc, sizeof(result))) {
    fputs("<Swig Object at ", fp); fputs(result, fp); fputs(">", fp);
    return 0; 
  } else {
    return 1; 
  }
}
  
SWIGRUNTIME PyObject *
PySwigObject_repr(PySwigObject *v)
{
  char result[SWIG_BUFFER_SIZE];
  return SWIG_PackVoidPtr(result, v->ptr, v->desc, sizeof(result)) ?
    PyString_FromFormat("<Swig Object at %s>", result) : 0;
}

SWIGRUNTIME PyObject *
PySwigObject_str(PySwigObject *v)
{
  char result[SWIG_BUFFER_SIZE];
  return SWIG_PackVoidPtr(result, v->ptr, v->desc, sizeof(result)) ?
    PyString_FromString(result) : 0;
}

SWIGRUNTIME PyObject *
PySwigObject_long(PySwigObject *v)
{
  return PyLong_FromVoidPtr(v->ptr);
}

SWIGRUNTIME PyObject *
PySwigObject_format(const char* fmt, PySwigObject *v)
{
  PyObject *res = NULL;
  PyObject *args = PyTuple_New(1);
  if (args && (PyTuple_SetItem(args, 0, PySwigObject_long(v)) == 0)) {
    PyObject *ofmt = PyString_FromString(fmt);
    if (ofmt) {
      res = PyString_Format(ofmt,args);
      Py_DECREF(ofmt);
    }
    Py_DECREF(args);
  }  
  return res;
}

SWIGRUNTIME PyObject *
PySwigObject_oct(PySwigObject *v)
{
  return PySwigObject_format("%o",v);
}

SWIGRUNTIME PyObject *
PySwigObject_hex(PySwigObject *v)
{
  return PySwigObject_format("%x",v);
}

SWIGRUNTIME int
PySwigObject_compare(PySwigObject *v, PySwigObject *w)
{
  int c = strcmp(v->desc, w->desc);
  if (c) {
    return (c > 0) ? 1 : -1;
  } else {
    void *i = v->ptr;
    void *j = w->ptr;
    return (i < j) ? -1 : ((i > j) ? 1 : 0);
  }
}

SWIGRUNTIME void
PySwigObject_dealloc(PySwigObject *self)
{
  PyObject_DEL(self);
}

SWIGRUNTIME PyTypeObject*
PySwigObject_type(void) {
  static char pyswigobject_type__doc__[] = 
    "Swig object carries a C/C++ instance pointer";
  
  static PyNumberMethods PySwigObject_as_number = {
    (binaryfunc)0, /*nb_add*/
    (binaryfunc)0, /*nb_subtract*/
    (binaryfunc)0, /*nb_multiply*/
    (binaryfunc)0, /*nb_divide*/
    (binaryfunc)0, /*nb_remainder*/
    (binaryfunc)0, /*nb_divmod*/
    (ternaryfunc)0,/*nb_power*/
    (unaryfunc)0,  /*nb_negative*/
    (unaryfunc)0,  /*nb_positive*/
    (unaryfunc)0,  /*nb_absolute*/
    (inquiry)0,    /*nb_nonzero*/
    0,		   /*nb_invert*/
    0,		   /*nb_lshift*/
    0,		   /*nb_rshift*/
    0,		   /*nb_and*/
    0,		   /*nb_xor*/
    0,		   /*nb_or*/
    (coercion)0,   /*nb_coerce*/
    (unaryfunc)PySwigObject_long, /*nb_int*/
    (unaryfunc)PySwigObject_long, /*nb_long*/
    (unaryfunc)0,                 /*nb_float*/
    (unaryfunc)PySwigObject_oct,  /*nb_oct*/
    (unaryfunc)PySwigObject_hex,  /*nb_hex*/
#if PY_VERSION_HEX >= 0x02000000
    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 /* nb_inplace_add -> nb_inplace_true_divide */ 
#endif
  };

  static PyTypeObject pyswigobject_type
#if !defined(__cplusplus)
  ;  
  static int type_init = 0;
  if (!type_init) {
    PyTypeObject tmp
#endif
    = {
    PyObject_HEAD_INIT(&PyType_Type)
    0,					/*ob_size*/
    (char *)"PySwigObject",		/*tp_name*/
    sizeof(PySwigObject),		/*tp_basicsize*/
    0,					/*tp_itemsize*/
    /* methods */
    (destructor)PySwigObject_dealloc,	/*tp_dealloc*/
    (printfunc)PySwigObject_print,	/*tp_print*/
    (getattrfunc)0,			/*tp_getattr*/
    (setattrfunc)0,			/*tp_setattr*/
    (cmpfunc)PySwigObject_compare,	/*tp_compare*/
    (reprfunc)PySwigObject_repr,	/*tp_repr*/
    &PySwigObject_as_number,	        /*tp_as_number*/
    0,					/*tp_as_sequence*/
    0,					/*tp_as_mapping*/
    (hashfunc)0,			/*tp_hash*/
    (ternaryfunc)0,			/*tp_call*/
    (reprfunc)PySwigObject_str,		/*tp_str*/
    /* Space for future expansion */
    0,0,0,0,
    pyswigobject_type__doc__, 	        /* Documentation string */
#if PY_VERSION_HEX >= 0x02000000
    0,                                  /* tp_traverse */
    0,                                  /* tp_clear */
#endif
#if PY_VERSION_HEX >= 0x02010000
    0,                                  /* tp_richcompare */
    0,                                  /* tp_weaklistoffset */
#endif
#if PY_VERSION_HEX >= 0x02020000
    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0, /* tp_iter -> tp_weaklist */
#endif
#if PY_VERSION_HEX >= 0x02030000
    0,                                  /* tp_del */
#endif
#ifdef COUNT_ALLOCS
    0,0,0,0                             /* tp_alloc -> tp_next */
#endif
    };
#if !defined(__cplusplus)
    pyswigobject_type = tmp;
    type_init = 1;
  }
#endif
  return &pyswigobject_type;
}

SWIGRUNTIME PyObject *
PySwigObject_FromVoidPtrAndDesc(void *ptr, const char *desc)
{
  PySwigObject *self = PyObject_NEW(PySwigObject, PySwigObject_type());
  if (self) {
    self->ptr = ptr;
    self->desc = desc;
  }
  return (PyObject *)self;
}

SWIGRUNTIMEINLINE void *
PySwigObject_AsVoidPtr(PyObject *self)
{
  return ((PySwigObject *)self)->ptr;
}

SWIGRUNTIMEINLINE const char *
PySwigObject_GetDesc(PyObject *self)
{
  return ((PySwigObject *)self)->desc;
}

SWIGRUNTIMEINLINE int
PySwigObject_Check(PyObject *op) {
  return ((op)->ob_type == PySwigObject_type()) 
    || (strcmp((op)->ob_type->tp_name,"PySwigObject") == 0);
}

/* -----------------------------------------------------------------------------
 * Implements a simple Swig Packed type, and use it instead of string
 * ----------------------------------------------------------------------------- */

typedef struct {
  PyObject_HEAD
  void *pack;
  const char *desc;
  size_t size;
} PySwigPacked;

SWIGRUNTIME int
PySwigPacked_print(PySwigPacked *v, FILE *fp, int flags)
{
  char result[SWIG_BUFFER_SIZE];
  flags = flags;
  fputs("<Swig Packed ", fp); 
  if (SWIG_PackDataName(result, v->pack, v->size, 0, sizeof(result))) {
    fputs("at ", fp); 
    fputs(result, fp); 
  }
  fputs(v->desc,fp); 
  fputs(">", fp);
  return 0; 
}
  
SWIGRUNTIME PyObject *
PySwigPacked_repr(PySwigPacked *v)
{
  char result[SWIG_BUFFER_SIZE];
  if (SWIG_PackDataName(result, v->pack, v->size, 0, sizeof(result))) {
    return PyString_FromFormat("<Swig Packed at %s%s>", result, v->desc);
  } else {
    return PyString_FromFormat("<Swig Packed %s>", v->desc);
  }  
}

SWIGRUNTIME PyObject *
PySwigPacked_str(PySwigPacked *v)
{
  char result[SWIG_BUFFER_SIZE];
  if (SWIG_PackDataName(result, v->pack, v->size, 0, sizeof(result))){
    return PyString_FromFormat("%s%s", result, v->desc);
  } else {
    return PyString_FromFormat("%s", v->desc);
  }  
}

SWIGRUNTIME int
PySwigPacked_compare(PySwigPacked *v, PySwigPacked *w)
{
  int c = strcmp(v->desc, w->desc);
  if (c) {
    return (c > 0) ? 1 : -1;
  } else {
    size_t i = v->size;
    size_t j = w->size;
    int s = (i < j) ? -1 : ((i > j) ? 1 : 0);
    return s ? s : strncmp((char *)v->pack, (char *)w->pack, 2*v->size);
  }
}

SWIGRUNTIME void
PySwigPacked_dealloc(PySwigPacked *self)
{
  free(self->pack);
  PyObject_DEL(self);
}

SWIGRUNTIME PyTypeObject*
PySwigPacked_type(void) {
  static char pyswigpacked_type__doc__[] = 
    "Swig object carries a C/C++ instance pointer";
  static PyTypeObject pyswigpacked_type
#if !defined(__cplusplus)
  ;
  static int type_init = 0;  
  if (!type_init) {
    PyTypeObject tmp
#endif
    = {
    PyObject_HEAD_INIT(&PyType_Type)
    0,					/*ob_size*/
    (char *)"PySwigPacked",		/*tp_name*/
    sizeof(PySwigPacked),		/*tp_basicsize*/
    0,					/*tp_itemsize*/
    /* methods */
    (destructor)PySwigPacked_dealloc,	/*tp_dealloc*/
    (printfunc)PySwigPacked_print,	/*tp_print*/
    (getattrfunc)0,			/*tp_getattr*/
    (setattrfunc)0,			/*tp_setattr*/
    (cmpfunc)PySwigPacked_compare,	/*tp_compare*/
    (reprfunc)PySwigPacked_repr,	/*tp_repr*/
    0,	                                /*tp_as_number*/
    0,					/*tp_as_sequence*/
    0,					/*tp_as_mapping*/
    (hashfunc)0,			/*tp_hash*/
    (ternaryfunc)0,			/*tp_call*/
    (reprfunc)PySwigPacked_str,		/*tp_str*/
    /* Space for future expansion */
    0,0,0,0,
    pyswigpacked_type__doc__, 	        /* Documentation string */
#if PY_VERSION_HEX >= 0x02000000
    0,                                  /* tp_traverse */
    0,                                  /* tp_clear */
#endif
#if PY_VERSION_HEX >= 0x02010000
    0,                                  /* tp_richcompare */
    0,                                  /* tp_weaklistoffset */
#endif
#if PY_VERSION_HEX >= 0x02020000         
    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0, /* tp_iter -> tp_weaklist */
#endif
#if PY_VERSION_HEX >= 0x02030000
    0,                                  /* tp_del */
#endif
#ifdef COUNT_ALLOCS
    0,0,0,0                             /* tp_alloc -> tp_next */
#endif
    };
#if !defined(__cplusplus)
    pyswigpacked_type = tmp;
    type_init = 1;
  }
#endif
  return &pyswigpacked_type;
}

SWIGRUNTIME PyObject *
PySwigPacked_FromDataAndDesc(void *ptr, size_t size, const char *desc)
{
  PySwigPacked *self = PyObject_NEW(PySwigPacked, PySwigPacked_type());
  if (self == NULL) {
    return NULL;
  } else {
    void *pack = malloc(size);
    if (pack) {
      memcpy(pack, ptr, size);
      self->pack = pack;
      self->desc = desc;
      self->size = size;
      return (PyObject *) self;
    }
    return NULL;
  }
}

SWIGRUNTIMEINLINE const char *
PySwigPacked_UnpackData(PyObject *obj, void *ptr, size_t size)
{
  PySwigPacked *self = (PySwigPacked *)obj;
  if (self->size != size) return 0;
  memcpy(ptr, self->pack, size);
  return self->desc;
}

SWIGRUNTIMEINLINE const char *
PySwigPacked_GetDesc(PyObject *self)
{
  return ((PySwigPacked *)self)->desc;
}

SWIGRUNTIMEINLINE int
PySwigPacked_Check(PyObject *op) {
  return ((op)->ob_type == PySwigPacked_type()) 
    || (strcmp((op)->ob_type->tp_name,"PySwigPacked") == 0);
}

#else
/* -----------------------------------------------------------------------------
 * Use the old Python PyCObject instead of PySwigObject
 * ----------------------------------------------------------------------------- */

#define PySwigObject_GetDesc(obj)	           PyCObject_GetDesc(obj)
#define PySwigObject_Check(obj)	           PyCObject_Check(obj)
#define PySwigObject_AsVoidPtr(obj)	   PyCObject_AsVoidPtr(obj)
#define PySwigObject_FromVoidPtrAndDesc(p, d)  PyCObject_FromVoidPtrAndDesc(p, d, NULL)

#endif

#endif

/* -----------------------------------------------------------------------------
 * errors manipulation
 * ----------------------------------------------------------------------------- */

SWIGRUNTIME void
SWIG_Python_TypeError(const char *type, PyObject *obj)
{
  if (type) {
#if defined(SWIG_COBJECT_TYPES)
    if (obj && PySwigObject_Check(obj)) {
      const char *otype = (const char *) PySwigObject_GetDesc(obj);
      if (otype) {
	PyErr_Format(PyExc_TypeError, "a '%s' is expected, 'PySwigObject(%s)' is received",
		     type, otype);
	return;
      }
    } else 
#endif      
    {
      const char *otype = (obj ? obj->ob_type->tp_name : 0); 
      if (otype) {
	PyObject *str = PyObject_Str(obj);
	const char *cstr = str ? PyString_AsString(str) : 0;
	if (cstr) {
	  PyErr_Format(PyExc_TypeError, "a '%s' is expected, '%s(%s)' is received",
		       type, otype, cstr);
	} else {
	  PyErr_Format(PyExc_TypeError, "a '%s' is expected, '%s' is received",
		       type, otype);
	}
	Py_XDECREF(str);
	return;
      }
    }   
    PyErr_Format(PyExc_TypeError, "a '%s' is expected", type);
  } else {
    PyErr_Format(PyExc_TypeError, "unexpected type is received");
  }
}

SWIGRUNTIMEINLINE void
SWIG_Python_NullRef(const char *type)
{
  if (type) {
    PyErr_Format(PyExc_TypeError, "null reference of type '%s' was received",type);
  } else {
    PyErr_Format(PyExc_TypeError, "null reference was received");
  }
}

SWIGRUNTIME int
SWIG_Python_AddErrMesg(const char* mesg, int infront)
{
  if (PyErr_Occurred()) {
    PyObject *type = 0;
    PyObject *value = 0;
    PyObject *traceback = 0;
    PyErr_Fetch(&type, &value, &traceback);
    if (value) {
      PyObject *old_str = PyObject_Str(value);
      Py_XINCREF(type);
      PyErr_Clear();
      if (infront) {
	PyErr_Format(type, "%s %s", mesg, PyString_AsString(old_str));
      } else {
	PyErr_Format(type, "%s %s", PyString_AsString(old_str), mesg);
      }
      Py_DECREF(old_str);
    }
    return 1;
  } else {
    return 0;
  }
}

SWIGRUNTIME int
SWIG_Python_ArgFail(int argnum)
{
  if (PyErr_Occurred()) {
    /* add information about failing argument */
    char mesg[256];
    PyOS_snprintf(mesg, sizeof(mesg), "argument number %d:", argnum);
    return SWIG_Python_AddErrMesg(mesg, 1);
  } else {
    return 0;
  }
}


/* -----------------------------------------------------------------------------
 * pointers/data manipulation
 * ----------------------------------------------------------------------------- */

/* Convert a pointer value */
SWIGRUNTIME int
SWIG_Python_ConvertPtr(PyObject *obj, void **ptr, swig_type_info *ty, int flags) {
  swig_cast_info *tc;
  const char *c = 0;
  static PyObject *SWIG_this = 0;
  int    newref = 0;
  PyObject  *pyobj = 0;
  void *vptr;
  
  if (!obj) return 0;
  if (obj == Py_None) {
    *ptr = 0;
    return 0;
  }

#ifdef SWIG_COBJECT_TYPES
  if (!(PySwigObject_Check(obj))) {
    if (!SWIG_this)
      SWIG_this = PyString_FromString("this");
    pyobj = obj;
    obj = PyObject_GetAttr(obj,SWIG_this);
    newref = 1;
    if (!obj) goto type_error;
    if (!PySwigObject_Check(obj)) {
      Py_DECREF(obj);
      goto type_error;
    }
  }  
  vptr = PySwigObject_AsVoidPtr(obj);
  c = (const char *) PySwigObject_GetDesc(obj);
  if (newref) { Py_DECREF(obj); }
  goto type_check;
#else
  if (!(PyString_Check(obj))) {
    if (!SWIG_this)
      SWIG_this = PyString_FromString("this");
    pyobj = obj;
    obj = PyObject_GetAttr(obj,SWIG_this);
    newref = 1;
    if (!obj) goto type_error;
    if (!PyString_Check(obj)) {
      Py_DECREF(obj);
      goto type_error;
    }
  } 
  c = PyString_AS_STRING(obj);
  /* Pointer values must start with leading underscore */
  c = SWIG_UnpackVoidPtr(c, &vptr, ty->name);
  if (newref) { Py_DECREF(obj); }
  if (!c) goto type_error;
#endif

type_check:
  if (ty) {
    tc = SWIG_TypeCheck(c,ty);
    if (!tc) goto type_error;
    *ptr = SWIG_TypeCast(tc,vptr);
  } else {
    *ptr = vptr;
  }
  if ((pyobj) && (flags & SWIG_POINTER_DISOWN)) {
    PyObject_SetAttrString(pyobj,(char*)"thisown",Py_False);
  }
  return 0;

type_error:
  PyErr_Clear();
  if (pyobj && !obj) {    
    obj = pyobj;
    if (PyCFunction_Check(obj)) {
      /* here we get the method pointer for callbacks */
      char *doc = (((PyCFunctionObject *)obj) -> m_ml -> ml_doc);
      c = doc ? strstr(doc, "swig_ptr: ") : 0;
      if (c) {
	c = ty ? SWIG_UnpackVoidPtr(c + 10, &vptr, ty->name) : 0;
	if (!c) goto type_error;
	goto type_check;
      }
    }
  }
  if (flags & SWIG_POINTER_EXCEPTION) {
    if (ty) {
      SWIG_Python_TypeError(SWIG_TypePrettyName(ty), obj);
    } else {
      SWIG_Python_TypeError("C/C++ pointer", obj);
    }
  }
  return -1;
}

/* Convert a pointer value, signal an exception on a type mismatch */
SWIGRUNTIME void *
SWIG_Python_MustGetPtr(PyObject *obj, swig_type_info *ty, int argnum, int flags) {
  void *result;
  if (SWIG_Python_ConvertPtr(obj, &result, ty, flags) == -1) {
    PyErr_Clear();
    if (flags & SWIG_POINTER_EXCEPTION) {
      SWIG_Python_TypeError(SWIG_TypePrettyName(ty), obj);
      SWIG_Python_ArgFail(argnum);
    }
  }
  return result;
}

/* Convert a packed value value */
SWIGRUNTIME int
SWIG_Python_ConvertPacked(PyObject *obj, void *ptr, size_t sz, swig_type_info *ty, int flags) {
  swig_cast_info *tc;
  const char *c = 0;

#if defined(SWIG_COBJECT_TYPES) && !defined(SWIG_COBJECT_PYTHON)
  c = PySwigPacked_UnpackData(obj, ptr, sz);
#else
  if ((!obj) || (!PyString_Check(obj))) goto type_error;
  c = PyString_AS_STRING(obj);
  /* Pointer values must start with leading underscore */
  c = SWIG_UnpackDataName(c, ptr, sz, ty->name);
#endif
  if (!c) goto type_error;
  if (ty) {
    tc = SWIG_TypeCheck(c,ty);
    if (!tc) goto type_error;
  }
  return 0;

type_error:
  PyErr_Clear();
  if (flags & SWIG_POINTER_EXCEPTION) {
    if (ty) {
      SWIG_Python_TypeError(SWIG_TypePrettyName(ty), obj);
    } else {
      SWIG_Python_TypeError("C/C++ packed data", obj);
    }
  }
  return -1;
}  

/* Create a new array object */
SWIGRUNTIME PyObject *
SWIG_Python_NewPointerObj(void *ptr, swig_type_info *type, int own) {
  PyObject *robj = 0;
  if (!type) {
    if (!PyErr_Occurred()) {
      PyErr_Format(PyExc_TypeError, "Swig: null type passed to NewPointerObj");
    }
    return robj;
  }
  if (!ptr) {
    Py_INCREF(Py_None);
    return Py_None;
  }
#ifdef SWIG_COBJECT_TYPES
  robj = PySwigObject_FromVoidPtrAndDesc((void *) ptr, (char *)type->name);
#else
  {
    char result[SWIG_BUFFER_SIZE];
    robj = SWIG_PackVoidPtr(result, ptr, type->name, sizeof(result)) ?
      PyString_FromString(result) : 0;
  }
#endif
  if (!robj || (robj == Py_None)) return robj;
  if (type->clientdata) {
    PyObject *inst;
    PyObject *args = Py_BuildValue((char*)"(O)", robj);
    Py_DECREF(robj);
    inst = PyObject_CallObject((PyObject *) type->clientdata, args);
    Py_DECREF(args);
    if (inst) {
      if (own) {
        PyObject_SetAttrString(inst,(char*)"thisown",Py_True);
      }
      robj = inst;
    }
  }
  return robj;
}

SWIGRUNTIME PyObject *
SWIG_Python_NewPackedObj(void *ptr, size_t sz, swig_type_info *type) {
  PyObject *robj = 0;
  if (!ptr) {
    Py_INCREF(Py_None);
    return Py_None;
  }
#if defined(SWIG_COBJECT_TYPES) && !defined(SWIG_COBJECT_PYTHON)
  robj = PySwigPacked_FromDataAndDesc((void *) ptr, sz, (char *)type->name);
#else
  {
    char result[SWIG_BUFFER_SIZE];
    robj = SWIG_PackDataName(result, ptr, sz, type->name, sizeof(result)) ?
      PyString_FromString(result) : 0;
  }
#endif
  return robj;
}

/* -----------------------------------------------------------------------------*
 *  Get type list 
 * -----------------------------------------------------------------------------*/

#ifdef SWIG_LINK_RUNTIME
void *SWIG_ReturnGlobalTypeList(void *);
#endif

SWIGRUNTIME swig_module_info *
SWIG_Python_GetModule(void) {
  static void *type_pointer = (void *)0;
  /* first check if module already created */
  if (!type_pointer) {
#ifdef SWIG_LINK_RUNTIME
    type_pointer = SWIG_ReturnGlobalTypeList((void *)0);
#else
    type_pointer = PyCObject_Import((char*)"swig_runtime_data" SWIG_RUNTIME_VERSION,
				    (char*)"type_pointer" SWIG_TYPE_TABLE_NAME);
    if (PyErr_Occurred()) {
      PyErr_Clear();
      type_pointer = (void *)0;
    }
  }
#endif
  return (swig_module_info *) type_pointer;
}

SWIGRUNTIME void
SWIG_Python_SetModule(swig_module_info *swig_module) {
  static PyMethodDef swig_empty_runtime_method_table[] = { {NULL, NULL, 0, NULL} };/* Sentinel */

  PyObject *module = Py_InitModule((char*)"swig_runtime_data" SWIG_RUNTIME_VERSION,
				   swig_empty_runtime_method_table);
  PyObject *pointer = PyCObject_FromVoidPtr((void *) swig_module, NULL);
  if (pointer && module) {
    PyModule_AddObject(module, (char*)"type_pointer" SWIG_TYPE_TABLE_NAME, pointer);
  }
}

#ifdef __cplusplus
}
#endif



/* -------- TYPES TABLE (BEGIN) -------- */

#define SWIGTYPE_p_apr_array_header_t swig_types[0]
#define SWIGTYPE_p_apr_file_t swig_types[1]
#define SWIGTYPE_p_apr_hash_t swig_types[2]
#define SWIGTYPE_p_apr_int32_t swig_types[3]
#define SWIGTYPE_p_apr_int64_t swig_types[4]
#define SWIGTYPE_p_apr_pool_t swig_types[5]
#define SWIGTYPE_p_apr_size_t swig_types[6]
#define SWIGTYPE_p_char swig_types[7]
#define SWIGTYPE_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[8]
#define SWIGTYPE_p_f_p_p_svn_txdelta_window_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[9]
#define SWIGTYPE_p_f_p_p_void_p_void_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[10]
#define SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t swig_types[11]
#define SWIGTYPE_p_f_p_q_const__char_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t swig_types[12]
#define SWIGTYPE_p_f_p_q_const__char_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t swig_types[13]
#define SWIGTYPE_p_f_p_q_const__char_svn_revnum_t_p_void_p_apr_pool_t__p_svn_error_t swig_types[14]
#define SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t swig_types[15]
#define SWIGTYPE_p_f_p_void__p_svn_error_t swig_types[16]
#define SWIGTYPE_p_f_p_void__p_unsigned_char swig_types[17]
#define SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t swig_types[18]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t swig_types[19]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t_p_svn_txdelta_window_handler_t_p_p_void__p_svn_error_t swig_types[20]
#define SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t swig_types[21]
#define SWIGTYPE_p_f_p_void_svn_revnum_t_p_apr_pool_t__p_svn_error_t swig_types[22]
#define SWIGTYPE_p_f_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t swig_types[23]
#define SWIGTYPE_p_int swig_types[24]
#define SWIGTYPE_p_long swig_types[25]
#define SWIGTYPE_p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t swig_types[26]
#define SWIGTYPE_p_p_svn_delta_editor_t swig_types[27]
#define SWIGTYPE_p_p_svn_txdelta_stream_t swig_types[28]
#define SWIGTYPE_p_p_svn_txdelta_window_t swig_types[29]
#define SWIGTYPE_p_p_void swig_types[30]
#define SWIGTYPE_p_svn_auth_baton_t swig_types[31]
#define SWIGTYPE_p_svn_auth_cred_simple_t swig_types[32]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_pw_t swig_types[33]
#define SWIGTYPE_p_svn_auth_cred_ssl_client_cert_t swig_types[34]
#define SWIGTYPE_p_svn_auth_cred_ssl_server_trust_t swig_types[35]
#define SWIGTYPE_p_svn_auth_cred_username_t swig_types[36]
#define SWIGTYPE_p_svn_auth_iterstate_t swig_types[37]
#define SWIGTYPE_p_svn_auth_provider_object_t swig_types[38]
#define SWIGTYPE_p_svn_auth_provider_t swig_types[39]
#define SWIGTYPE_p_svn_auth_ssl_server_cert_info_t swig_types[40]
#define SWIGTYPE_p_svn_commit_info_t swig_types[41]
#define SWIGTYPE_p_svn_config_t swig_types[42]
#define SWIGTYPE_p_svn_delta_editor_t swig_types[43]
#define SWIGTYPE_p_svn_dirent_t swig_types[44]
#define SWIGTYPE_p_svn_errno_t swig_types[45]
#define SWIGTYPE_p_svn_error_t swig_types[46]
#define SWIGTYPE_p_svn_io_dirent_t swig_types[47]
#define SWIGTYPE_p_svn_io_file_del_t swig_types[48]
#define SWIGTYPE_p_svn_lock_t swig_types[49]
#define SWIGTYPE_p_svn_log_changed_path_t swig_types[50]
#define SWIGTYPE_p_svn_node_kind_t swig_types[51]
#define SWIGTYPE_p_svn_opt_revision_t swig_types[52]
#define SWIGTYPE_p_svn_opt_revision_value_t swig_types[53]
#define SWIGTYPE_p_svn_opt_subcommand_desc2_t swig_types[54]
#define SWIGTYPE_p_svn_opt_subcommand_desc_t swig_types[55]
#define SWIGTYPE_p_svn_prop_kind swig_types[56]
#define SWIGTYPE_p_svn_stream_t swig_types[57]
#define SWIGTYPE_p_svn_string_t swig_types[58]
#define SWIGTYPE_p_svn_stringbuf_t swig_types[59]
#define SWIGTYPE_p_svn_txdelta_op_t swig_types[60]
#define SWIGTYPE_p_svn_txdelta_stream_t swig_types[61]
#define SWIGTYPE_p_svn_txdelta_window_t swig_types[62]
#define SWIGTYPE_p_svn_version_checklist_t swig_types[63]
#define SWIGTYPE_p_svn_version_t swig_types[64]
#define SWIGTYPE_p_unsigned_char swig_types[65]
#define SWIGTYPE_p_void swig_types[66]
#define SWIGTYPE_ptrdiff_t swig_types[67]
#define SWIGTYPE_size_t swig_types[68]
static swig_type_info *swig_types[69];
static swig_module_info swig_module = {swig_types, 69, 0, 0, 0, 0};
#define SWIG_TypeQuery(name) SWIG_TypeQueryModule(&swig_module, &swig_module, name)
#define SWIG_MangledTypeQuery(name) SWIG_MangledTypeQueryModule(&swig_module, &swig_module, name)

/* -------- TYPES TABLE (END) -------- */


/*-----------------------------------------------
              @(target):= _delta.so
  ------------------------------------------------*/
#define SWIG_init    init_delta

#define SWIG_name    "_delta"

static PyObject * _global_svn_swig_py_pool = NULL;


#define svn_argnum_obj0 1
#define svn_argnum_obj1 2
#define svn_argnum_obj2 3
#define svn_argnum_obj3 4
#define svn_argnum_obj4 5
#define svn_argnum_obj5 6
#define svn_argnum_obj6 7
#define svn_argnum_obj7 8
#define svn_argnum_obj8 9
#define svn_argnum_obj9 10
#define svn_argnum_obj10 11
#define svn_argnum_obj11 12
#define svn_argnum_obj12 13
#define svn_argnum_obj13 14
#define svn_argnum_obj14 15
#define svn_argnum_obj15 16
#define svn_argnum_obj16 17
#define svn_argnum_obj17 18
#define svn_argnum_obj18 19
#define svn_argnum_obj19 20


#include "svn_time.h"
#include "svn_pools.h"


SWIGINTERN PyObject*
t_output_helper(PyObject* target, PyObject* o) {
  if (!target) {
    target = o;
  } else if (target == Py_None) {  
    Py_DECREF(target);
    target = o;
  } else {
    if (!PyList_Check(target)) {
      PyObject *o2 = target;
      target = PyList_New(1);
      PyList_SetItem(target, 0, o2);
    }
    PyList_Append(target,o);
    Py_DECREF(o);
    }
  return target;
}


#include "svn_md5.h"

#ifdef SWIGPYTHON
#include "swigutil_py.h"
#endif

#ifdef SWIGPERL
#include "swigutil_pl.h"
#endif

#ifdef SWIGRUBY
#include "swigutil_rb.h"
#endif


#include "svn_delta.h"


  /*@/home/dave/svn/env/build/share/swig/1.3.25/python/pymacros.swg,66,SWIG_define@*/
#define SWIG_From_long PyInt_FromLong
/*@@*/


SWIGINTERN int
  SWIG_AsVal_long(PyObject * obj, long* val)
{
  if (PyInt_Check(obj)) {
    if (val) *val = PyInt_AS_LONG(obj);
    return 1;
  }
  if (PyLong_Check(obj)) {
    long v = PyLong_AsLong(obj);
    if (!PyErr_Occurred()) {
      if (val) *val = v;
      return 1;
    } else {
      if (!val) PyErr_Clear();
      return 0;
    }
  }
  if (val) {
    SWIG_type_error("long", obj);
  }
  return 0;
 }


SWIGINTERNINLINE long
SWIG_As_long(PyObject* obj)
{
  long v;
  if (!SWIG_AsVal_long(obj, &v)) {
    /*
      this is needed to make valgrind/purify happier. 
     */
    memset((void*)&v, 0, sizeof(long));
  }
  return v;
}

  
SWIGINTERNINLINE int
SWIG_Check_long(PyObject* obj)
{
  return SWIG_AsVal_long(obj, (long*)0);
}


SWIGINTERN int
  SWIG_AsVal_unsigned_SS_long(PyObject *obj, unsigned long *val) 
{
  if (PyInt_Check(obj)) {
    long v = PyInt_AS_LONG(obj);
    if (v >= 0) {
      if (val) *val = v;
      return 1;
    }   
  }
  if (PyLong_Check(obj)) {
    unsigned long v = PyLong_AsUnsignedLong(obj);
    if (!PyErr_Occurred()) {
      if (val) *val = v;
      return 1;
    } else {
      if (!val) PyErr_Clear();
      return 0;
    }
  } 
  if (val) {
    SWIG_type_error("unsigned long", obj);
  }
  return 0;
}


SWIGINTERNINLINE unsigned long
SWIG_As_unsigned_SS_long(PyObject* obj)
{
  unsigned long v;
  if (!SWIG_AsVal_unsigned_SS_long(obj, &v)) {
    /*
      this is needed to make valgrind/purify happier. 
     */
    memset((void*)&v, 0, sizeof(unsigned long));
  }
  return v;
}

  
SWIGINTERNINLINE int
SWIG_Check_unsigned_SS_long(PyObject* obj)
{
  return SWIG_AsVal_unsigned_SS_long(obj, (unsigned long*)0);
}


SWIGINTERNINLINE PyObject* 
  SWIG_From_unsigned_SS_long(unsigned long value)
{
  return (value > LONG_MAX) ?
    PyLong_FromUnsignedLong(value) 
    : PyInt_FromLong((long)(value)); 
}


      

/* returns SWIG_OLDOBJ if the input is a raw char*, SWIG_PYSTR if is a PyString */
SWIGINTERN int
SWIG_AsCharPtrAndSize(PyObject *obj, char** cptr, size_t* psize)
{
  static swig_type_info* pchar_info = 0;
  char* vptr = 0;
  if (!pchar_info) pchar_info = SWIG_TypeQuery("char *");
  if (SWIG_ConvertPtr(obj, (void**)&vptr, pchar_info, 0) != -1) {
    if (cptr) *cptr = vptr;
    if (psize) *psize = vptr ? (strlen(vptr) + 1) : 0;
    return SWIG_OLDOBJ;
  } else {
    PyErr_Clear();
    if (PyString_Check(obj)) {
      if (cptr) {
	*cptr = PyString_AS_STRING(obj);
	if (psize) {
	  *psize = PyString_GET_SIZE(obj) + 1;
	}
      }
      return SWIG_PYSTR;
    }
  }
  if (cptr) {
    SWIG_type_error("char *", obj);
  }
  return 0;
}


SWIGINTERNINLINE int
SWIG_AsCharPtr(PyObject *obj, char **val)
{
  if (SWIG_AsCharPtrAndSize(obj, val, (size_t*)(0))) {
    return 1;
  }
  if (val) {
    PyErr_Clear();
    SWIG_type_error("char *", obj);
  }
  return 0;
}



static svn_error_t *svn_delta_editor_invoke_set_target_revision(
  svn_delta_editor_t *_obj, void *edit_baton, svn_revnum_t target_revision, apr_pool_t *pool) {
  return _obj->set_target_revision(edit_baton, target_revision, pool);
}

static svn_error_t *svn_delta_editor_invoke_open_root(
  svn_delta_editor_t *_obj, void *edit_baton, svn_revnum_t base_revision, apr_pool_t *dir_pool, void **root_baton) {
  return _obj->open_root(edit_baton, base_revision, dir_pool, root_baton);
}

static svn_error_t *svn_delta_editor_invoke_delete_entry(
  svn_delta_editor_t *_obj, const char *path, svn_revnum_t revision, void *parent_baton, apr_pool_t *pool) {
  return _obj->delete_entry(path, revision, parent_baton, pool);
}

static svn_error_t *svn_delta_editor_invoke_add_directory(
  svn_delta_editor_t *_obj, const char *path, void *parent_baton, const char *copyfrom_path, svn_revnum_t copyfrom_revision, apr_pool_t *dir_pool, void **child_baton) {
  return _obj->add_directory(path, parent_baton, copyfrom_path, copyfrom_revision, dir_pool, child_baton);
}

static svn_error_t *svn_delta_editor_invoke_open_directory(
  svn_delta_editor_t *_obj, const char *path, void *parent_baton, svn_revnum_t base_revision, apr_pool_t *dir_pool, void **child_baton) {
  return _obj->open_directory(path, parent_baton, base_revision, dir_pool, child_baton);
}

static svn_error_t *svn_delta_editor_invoke_change_dir_prop(
  svn_delta_editor_t *_obj, void *dir_baton, const char *name, const svn_string_t *value, apr_pool_t *pool) {
  return _obj->change_dir_prop(dir_baton, name, value, pool);
}

static svn_error_t *svn_delta_editor_invoke_close_directory(
  svn_delta_editor_t *_obj, void *dir_baton, apr_pool_t *pool) {
  return _obj->close_directory(dir_baton, pool);
}

static svn_error_t *svn_delta_editor_invoke_absent_directory(
  svn_delta_editor_t *_obj, const char *path, void *parent_baton, apr_pool_t *pool) {
  return _obj->absent_directory(path, parent_baton, pool);
}

static svn_error_t *svn_delta_editor_invoke_add_file(
  svn_delta_editor_t *_obj, const char *path, void *parent_baton, const char *copy_path, svn_revnum_t copy_revision, apr_pool_t *file_pool, void **file_baton) {
  return _obj->add_file(path, parent_baton, copy_path, copy_revision, file_pool, file_baton);
}

static svn_error_t *svn_delta_editor_invoke_open_file(
  svn_delta_editor_t *_obj, const char *path, void *parent_baton, svn_revnum_t base_revision, apr_pool_t *file_pool, void **file_baton) {
  return _obj->open_file(path, parent_baton, base_revision, file_pool, file_baton);
}

static svn_error_t *svn_delta_editor_invoke_apply_textdelta(
  svn_delta_editor_t *_obj, void *file_baton, const char *base_checksum, apr_pool_t *pool, svn_txdelta_window_handler_t *handler, void **handler_baton) {
  return _obj->apply_textdelta(file_baton, base_checksum, pool, handler, handler_baton);
}

static svn_error_t *svn_delta_editor_invoke_change_file_prop(
  svn_delta_editor_t *_obj, void *file_baton, const char *name, const svn_string_t *value, apr_pool_t *pool) {
  return _obj->change_file_prop(file_baton, name, value, pool);
}

static svn_error_t *svn_delta_editor_invoke_close_file(
  svn_delta_editor_t *_obj, void *file_baton, const char *text_checksum, apr_pool_t *pool) {
  return _obj->close_file(file_baton, text_checksum, pool);
}

static svn_error_t *svn_delta_editor_invoke_absent_file(
  svn_delta_editor_t *_obj, const char *path, void *parent_baton, apr_pool_t *pool) {
  return _obj->absent_file(path, parent_baton, pool);
}

static svn_error_t *svn_delta_editor_invoke_close_edit(
  svn_delta_editor_t *_obj, void *edit_baton, apr_pool_t *pool) {
  return _obj->close_edit(edit_baton, pool);
}

static svn_error_t *svn_delta_editor_invoke_abort_edit(
  svn_delta_editor_t *_obj, void *edit_baton, apr_pool_t *pool) {
  return _obj->abort_edit(edit_baton, pool);
}


#ifdef __cplusplus
extern "C" {
#endif
static PyObject *_wrap_svn_swig_py_make_editor(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t **arg1 = (svn_delta_editor_t **) 0 ;
    void **arg2 = (void **) 0 ;
    PyObject *arg3 = (PyObject *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    svn_delta_editor_t const *temp1 ;
    void *temp2 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg1 = (svn_delta_editor_t **)&temp1;
    }
    {
        arg2 = (void **)&temp2;
    }
    if(!PyArg_ParseTuple(args,(char *)"O|O:svn_swig_py_make_editor",&obj0,&obj1)) goto fail;
    arg3 = obj0;
    if (obj1) {
        {
            if (obj1 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj1 != NULL && !PyObject_HasAttrString(obj1, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj1);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj1, SWIGTYPE_p_apr_pool_t, svn_argnum_obj1, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj1;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        svn_swig_py_make_editor((struct svn_delta_editor_t const **)arg1,arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    Py_INCREF(Py_None); resultobj = Py_None;
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg1, SWIGTYPE_p_svn_delta_editor_t, _global_svn_swig_py_pool));
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg2, SWIGTYPE_p_void, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_version(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_version_t *result;
    
    if(!PyArg_ParseTuple(args,(char *)":svn_delta_version")) goto fail;
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_version_t *)svn_delta_version();
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_svn_version_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_op_t_action_code_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_op_t *arg1 = (svn_txdelta_op_t *) 0 ;
    enum svn_delta_action arg2 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_txdelta_op_t_action_code_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_txdelta_op_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_op_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (enum svn_delta_action)SWIG_As_long(obj1);
        if (SWIG_arg_fail(svn_argnum_obj1)) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->action_code = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_op_t_action_code_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_op_t *arg1 = (svn_txdelta_op_t *) 0 ;
    enum svn_delta_action result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_txdelta_op_t_action_code_get",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_op_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_op_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (enum svn_delta_action) ((arg1)->action_code);
    
    {
        resultobj = SWIG_From_long((long)(result)); 
    }
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_op_t_offset_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_op_t *arg1 = (svn_txdelta_op_t *) 0 ;
    apr_size_t arg2 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_txdelta_op_t_offset_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_txdelta_op_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_op_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (apr_size_t)SWIG_As_unsigned_SS_long(obj1);
        if (SWIG_arg_fail(svn_argnum_obj1)) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->offset = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_op_t_offset_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_op_t *arg1 = (svn_txdelta_op_t *) 0 ;
    apr_size_t result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_txdelta_op_t_offset_get",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_op_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_op_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result =  ((arg1)->offset);
    
    {
        resultobj = SWIG_From_unsigned_SS_long((unsigned long)(result)); 
    }
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_op_t_length_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_op_t *arg1 = (svn_txdelta_op_t *) 0 ;
    apr_size_t arg2 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_txdelta_op_t_length_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_txdelta_op_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_op_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (apr_size_t)SWIG_As_unsigned_SS_long(obj1);
        if (SWIG_arg_fail(svn_argnum_obj1)) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->length = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_op_t_length_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_op_t *arg1 = (svn_txdelta_op_t *) 0 ;
    apr_size_t result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_txdelta_op_t_length_get",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_op_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_op_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result =  ((arg1)->length);
    
    {
        resultobj = SWIG_From_unsigned_SS_long((unsigned long)(result)); 
    }
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_new_svn_txdelta_op_t(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_op_t *result;
    
    if(!PyArg_ParseTuple(args,(char *)":new_svn_txdelta_op_t")) goto fail;
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_txdelta_op_t *)(svn_txdelta_op_t *) calloc(1, sizeof(svn_txdelta_op_t));
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_svn_txdelta_op_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_delete_svn_txdelta_op_t(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_op_t *arg1 = (svn_txdelta_op_t *) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:delete_svn_txdelta_op_t",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_op_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_op_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        free((char *) arg1);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject * svn_txdelta_op_t_swigregister(PyObject *self, PyObject *args) {
    PyObject *obj;
    if (!PyArg_ParseTuple(args,(char*)"O", &obj)) return NULL;
    SWIG_TypeClientData(SWIGTYPE_p_svn_txdelta_op_t, obj);
    Py_INCREF(obj);
    return Py_BuildValue((char *)"");
}
static PyObject *_wrap_svn_txdelta_window_t_sview_offset_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    svn_filesize_t arg2 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_txdelta_window_t_sview_offset_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    arg2 = (svn_filesize_t) PyLong_AsLongLong(obj1); 
    if (arg1) (arg1)->sview_offset = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_sview_offset_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    svn_filesize_t result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_txdelta_window_t_sview_offset_get",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result =  ((arg1)->sview_offset);
    
    resultobj = PyLong_FromLongLong((apr_int64_t)(result)); 
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_sview_len_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    apr_size_t arg2 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_txdelta_window_t_sview_len_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (apr_size_t)SWIG_As_unsigned_SS_long(obj1);
        if (SWIG_arg_fail(svn_argnum_obj1)) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->sview_len = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_sview_len_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    apr_size_t result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_txdelta_window_t_sview_len_get",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result =  ((arg1)->sview_len);
    
    {
        resultobj = SWIG_From_unsigned_SS_long((unsigned long)(result)); 
    }
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_tview_len_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    apr_size_t arg2 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_txdelta_window_t_tview_len_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (apr_size_t)SWIG_As_unsigned_SS_long(obj1);
        if (SWIG_arg_fail(svn_argnum_obj1)) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->tview_len = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_tview_len_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    apr_size_t result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_txdelta_window_t_tview_len_get",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result =  ((arg1)->tview_len);
    
    {
        resultobj = SWIG_From_unsigned_SS_long((unsigned long)(result)); 
    }
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_num_ops_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    int arg2 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_txdelta_window_t_num_ops_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (int)SWIG_As_long(obj1);
        if (SWIG_arg_fail(svn_argnum_obj1)) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->num_ops = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_num_ops_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    int result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_txdelta_window_t_num_ops_get",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (int) ((arg1)->num_ops);
    
    {
        resultobj = SWIG_From_long((long)(result)); 
    }
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_src_ops_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    int arg2 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_txdelta_window_t_src_ops_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (int)SWIG_As_long(obj1);
        if (SWIG_arg_fail(svn_argnum_obj1)) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->src_ops = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_src_ops_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    int result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_txdelta_window_t_src_ops_get",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (int) ((arg1)->src_ops);
    
    {
        resultobj = SWIG_From_long((long)(result)); 
    }
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_ops_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    svn_txdelta_op_t *arg2 = (svn_txdelta_op_t *) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_txdelta_window_t_ops_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_txdelta_op_t *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_svn_txdelta_op_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->ops = (svn_txdelta_op_t const *)arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_ops_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    svn_txdelta_op_t *result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_txdelta_window_t_ops_get",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_txdelta_op_t *) ((arg1)->ops);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_svn_txdelta_op_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_window_t_new_data_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    svn_string_t *result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_txdelta_window_t_new_data_get",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_string_t *) ((arg1)->new_data);
    
    {
        resultobj = PyString_FromStringAndSize(result->data, result->len);
    }
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_new_svn_txdelta_window_t(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *result;
    
    if(!PyArg_ParseTuple(args,(char *)":new_svn_txdelta_window_t")) goto fail;
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_txdelta_window_t *)(svn_txdelta_window_t *) calloc(1, sizeof(svn_txdelta_window_t));
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_svn_txdelta_window_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_delete_svn_txdelta_window_t(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:delete_svn_txdelta_window_t",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        free((char *) arg1);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject * svn_txdelta_window_t_swigregister(PyObject *self, PyObject *args) {
    PyObject *obj;
    if (!PyArg_ParseTuple(args,(char*)"O", &obj)) return NULL;
    SWIG_TypeClientData(SWIGTYPE_p_svn_txdelta_window_t, obj);
    Py_INCREF(obj);
    return Py_BuildValue((char *)"");
}
static PyObject *_wrap_svn_txdelta_window_dup(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_txdelta_window_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg2 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"O|O:svn_txdelta_window_dup",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj1) {
        {
            if (obj1 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj1 != NULL && !PyObject_HasAttrString(obj1, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj1);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj1, SWIGTYPE_p_apr_pool_t, svn_argnum_obj1, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj1;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg2 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_txdelta_window_t *)svn_txdelta_window_dup((struct svn_txdelta_window_t const *)arg1,arg2);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_svn_txdelta_window_t, 
    _global_svn_swig_py_pool);
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_compose_windows(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    svn_txdelta_window_t *arg2 = (svn_txdelta_window_t *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_txdelta_window_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg3 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OO|O:svn_txdelta_compose_windows",&obj0,&obj1,&obj2)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj2) {
        {
            if (obj2 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj2 != NULL && !PyObject_HasAttrString(obj2, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj2);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj2, SWIGTYPE_p_apr_pool_t, svn_argnum_obj2, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj2;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg3 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_txdelta_window_t *)svn_txdelta_compose_windows((struct svn_txdelta_window_t const *)arg1,(struct svn_txdelta_window_t const *)arg2,arg3);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_svn_txdelta_window_t, 
    _global_svn_swig_py_pool);
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_apply_instructions(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    char *arg2 = (char *) 0 ;
    char *arg3 = (char *) 0 ;
    apr_size_t *arg4 = (apr_size_t *) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    apr_size_t temp4 ;
    int res4 = 0 ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    arg4 = &temp4; res4 = SWIG_NEWOBJ;
    if(!PyArg_ParseTuple(args,(char *)"Oss:svn_txdelta_apply_instructions",&obj0,&arg2,&arg3)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        svn_txdelta_apply_instructions(arg1,(char const *)arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    Py_INCREF(Py_None); resultobj = Py_None;
    resultobj = t_output_helper(resultobj, ((res4 == SWIG_NEWOBJ) ?
    SWIG_From_unsigned_SS_long((*arg4)) : SWIG_NewPointerObj((void*)(arg4), SWIGTYPE_p_apr_size_t, 0)));
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta_stream_create(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    void *arg1 = (void *) 0 ;
    svn_txdelta_next_window_fn_t arg2 = (svn_txdelta_next_window_fn_t) 0 ;
    svn_txdelta_md5_digest_fn_t arg3 = (svn_txdelta_md5_digest_fn_t) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_txdelta_stream_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OOO|O:svn_txdelta_stream_create",&obj0,&obj1,&obj2,&obj3)) goto fail;
    {
        arg1 = (void *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_void, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_txdelta_next_window_fn_t)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_p_svn_txdelta_window_t_p_void_p_apr_pool_t__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (svn_txdelta_md5_digest_fn_t)svn_swig_MustGetPtr(obj2, SWIGTYPE_p_f_p_void__p_unsigned_char, svn_argnum_obj2,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_txdelta_stream_t *)svn_txdelta_stream_create(arg1,arg2,(unsigned char const *(*)(void *))arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_svn_txdelta_stream_t, 
    _global_svn_swig_py_pool);
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_next_window(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t **arg1 = (svn_txdelta_window_t **) 0 ;
    svn_txdelta_stream_t *arg2 = (svn_txdelta_stream_t *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    svn_txdelta_window_t *temp1 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg3 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg1 = (svn_txdelta_window_t **)&temp1;
    }
    if(!PyArg_ParseTuple(args,(char *)"O|O:svn_txdelta_next_window",&obj0,&obj1)) goto fail;
    {
        arg2 = (svn_txdelta_stream_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_stream_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj1) {
        {
            if (obj1 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj1 != NULL && !PyObject_HasAttrString(obj1, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj1);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj1, SWIGTYPE_p_apr_pool_t, svn_argnum_obj1, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj1;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg3 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_txdelta_next_window(arg1,arg2,arg3);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg1, SWIGTYPE_p_svn_txdelta_window_t, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_md5_digest(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_stream_t *arg1 = (svn_txdelta_stream_t *) 0 ;
    unsigned char *result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_txdelta_md5_digest",&obj0)) goto fail;
    {
        arg1 = (svn_txdelta_stream_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_stream_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (unsigned char *)svn_txdelta_md5_digest(arg1);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_unsigned_char, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_txdelta(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_stream_t **arg1 = (svn_txdelta_stream_t **) 0 ;
    svn_stream_t *arg2 = (svn_stream_t *) 0 ;
    svn_stream_t *arg3 = (svn_stream_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    svn_txdelta_stream_t *temp1 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg1 = (svn_txdelta_stream_t **)&temp1;
    }
    if(!PyArg_ParseTuple(args,(char *)"OO|O:svn_txdelta",&obj0,&obj1,&obj2)) goto fail;
    {
        arg2 = svn_swig_py_make_stream (obj0, _global_pool);
    }
    {
        arg3 = svn_swig_py_make_stream (obj1, _global_pool);
    }
    if (obj2) {
        {
            if (obj2 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj2 != NULL && !PyObject_HasAttrString(obj2, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj2);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj2, SWIGTYPE_p_apr_pool_t, svn_argnum_obj2, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj2;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        svn_txdelta(arg1,arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    Py_INCREF(Py_None); resultobj = Py_None;
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg1, SWIGTYPE_p_svn_txdelta_stream_t, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_target_push(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_handler_t arg1 = (svn_txdelta_window_handler_t) 0 ;
    void *arg2 = (void *) 0 ;
    svn_stream_t *arg3 = (svn_stream_t *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_stream_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OOO|O:svn_txdelta_target_push",&obj0,&obj1,&obj2,&obj3)) goto fail;
    {
        arg1 = (svn_txdelta_window_handler_t)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = svn_swig_py_make_stream (obj2, _global_pool);
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_stream_t *)svn_txdelta_target_push(arg1,arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_svn_stream_t, 
    _global_svn_swig_py_pool);
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_send_string(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_string_t *arg1 = (svn_string_t *) 0 ;
    svn_txdelta_window_handler_t arg2 = (svn_txdelta_window_handler_t) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    svn_string_t value1 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OOO|O:svn_txdelta_send_string",&obj0,&obj1,&obj2,&obj3)) goto fail;
    {
        if (obj0 == Py_None)
        arg1 = NULL;
        else {
            if (!PyString_Check(obj0)) {
                PyErr_SetString(PyExc_TypeError, "not a string");
                SWIG_fail;
            }
            value1.data = PyString_AS_STRING(obj0);
            value1.len = PyString_GET_SIZE(obj0);
            arg1 = &value1;
        }
    }
    {
        arg2 = (svn_txdelta_window_handler_t)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (void *)svn_swig_MustGetPtr(obj2, SWIGTYPE_p_void, svn_argnum_obj2,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_txdelta_send_string((struct svn_string_t const *)arg1,arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_send_stream(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_stream_t *arg1 = (svn_stream_t *) 0 ;
    svn_txdelta_window_handler_t arg2 = (svn_txdelta_window_handler_t) 0 ;
    void *arg3 = (void *) 0 ;
    unsigned char *arg4 = (unsigned char *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    unsigned char temp4[APR_MD5_DIGESTSIZE] ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg5 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg4 = (unsigned char *)temp4;
    }
    if(!PyArg_ParseTuple(args,(char *)"OOO|O:svn_txdelta_send_stream",&obj0,&obj1,&obj2,&obj3)) goto fail;
    {
        arg1 = svn_swig_py_make_stream (obj0, _global_pool);
    }
    {
        arg2 = (svn_txdelta_window_handler_t)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (void *)svn_swig_MustGetPtr(obj2, SWIGTYPE_p_void, svn_argnum_obj2,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg5 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_txdelta_send_stream(arg1,arg2,arg3,arg4,arg5);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        resultobj = t_output_helper(resultobj,
        PyString_FromString(svn_md5_digest_to_cstring (arg4, _global_pool)));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_send_txstream(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_stream_t *arg1 = (svn_txdelta_stream_t *) 0 ;
    svn_txdelta_window_handler_t arg2 = (svn_txdelta_window_handler_t) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OOO|O:svn_txdelta_send_txstream",&obj0,&obj1,&obj2,&obj3)) goto fail;
    {
        arg1 = (svn_txdelta_stream_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_stream_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_txdelta_window_handler_t)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (void *)svn_swig_MustGetPtr(obj2, SWIGTYPE_p_void, svn_argnum_obj2,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_txdelta_send_txstream(arg1,arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_apply(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_stream_t *arg1 = (svn_stream_t *) 0 ;
    svn_stream_t *arg2 = (svn_stream_t *) 0 ;
    unsigned char *arg3 = (unsigned char *) 0 ;
    char *arg4 = (char *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_txdelta_window_handler_t *arg6 = (svn_txdelta_window_handler_t *) 0 ;
    void **arg7 = (void **) 0 ;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    unsigned char temp3[APR_MD5_DIGESTSIZE] ;
    svn_txdelta_window_handler_t temp6 ;
    void *temp7 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg5 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg3 = (unsigned char *)temp3;
    }
    {
        arg6 = (svn_txdelta_window_handler_t *)&temp6;
    }
    {
        arg7 = (void **)&temp7;
    }
    if(!PyArg_ParseTuple(args,(char *)"OOz|O:svn_txdelta_apply",&obj0,&obj1,&arg4,&obj3)) goto fail;
    {
        arg1 = svn_swig_py_make_stream (obj0, _global_pool);
    }
    {
        arg2 = svn_swig_py_make_stream (obj1, _global_pool);
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg5 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        svn_txdelta_apply(arg1,arg2,arg3,(char const *)arg4,arg5,arg6,arg7);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    Py_INCREF(Py_None); resultobj = Py_None;
    {
        resultobj = t_output_helper(resultobj,
        PyString_FromString(svn_md5_digest_to_cstring (arg3, _global_pool)));
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg6, SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, _global_svn_swig_py_pool));
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg7, SWIGTYPE_p_void, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_to_svndiff2(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_handler_t *arg1 = (svn_txdelta_window_handler_t *) 0 ;
    void **arg2 = (void **) 0 ;
    svn_stream_t *arg3 = (svn_stream_t *) 0 ;
    int arg4 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    svn_txdelta_window_handler_t temp1 ;
    void *temp2 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg5 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg1 = (svn_txdelta_window_handler_t *)&temp1;
    }
    {
        arg2 = (void **)&temp2;
    }
    if(!PyArg_ParseTuple(args,(char *)"OO|O:svn_txdelta_to_svndiff2",&obj0,&obj1,&obj2)) goto fail;
    {
        arg3 = svn_swig_py_make_stream (obj0, _global_pool);
    }
    {
        arg4 = (int)SWIG_As_long(obj1);
        if (SWIG_arg_fail(svn_argnum_obj1)) {
            SWIG_fail;
        }
    }
    if (obj2) {
        {
            if (obj2 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj2 != NULL && !PyObject_HasAttrString(obj2, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj2);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj2, SWIGTYPE_p_apr_pool_t, svn_argnum_obj2, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj2;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg5 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        svn_txdelta_to_svndiff2(arg1,arg2,arg3,arg4,arg5);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    Py_INCREF(Py_None); resultobj = Py_None;
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg1, SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, _global_svn_swig_py_pool));
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg2, SWIGTYPE_p_void, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_to_svndiff(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_stream_t *arg1 = (svn_stream_t *) 0 ;
    apr_pool_t *arg2 = (apr_pool_t *) 0 ;
    svn_txdelta_window_handler_t *arg3 = (svn_txdelta_window_handler_t *) 0 ;
    void **arg4 = (void **) 0 ;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    svn_txdelta_window_handler_t temp3 ;
    void *temp4 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg2 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg3 = (svn_txdelta_window_handler_t *)&temp3;
    }
    {
        arg4 = (void **)&temp4;
    }
    if(!PyArg_ParseTuple(args,(char *)"O|O:svn_txdelta_to_svndiff",&obj0,&obj1)) goto fail;
    {
        arg1 = svn_swig_py_make_stream (obj0, _global_pool);
    }
    if (obj1) {
        {
            if (obj1 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj1 != NULL && !PyObject_HasAttrString(obj1, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj1);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj1, SWIGTYPE_p_apr_pool_t, svn_argnum_obj1, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj1;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg2 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        svn_txdelta_to_svndiff(arg1,arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    Py_INCREF(Py_None); resultobj = Py_None;
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg3, SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, _global_svn_swig_py_pool));
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg4, SWIGTYPE_p_void, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_parse_svndiff(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_handler_t arg1 = (svn_txdelta_window_handler_t) 0 ;
    void *arg2 = (void *) 0 ;
    svn_boolean_t arg3 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_stream_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OOO|O:svn_txdelta_parse_svndiff",&obj0,&obj1,&obj2,&obj3)) goto fail;
    {
        arg1 = (svn_txdelta_window_handler_t)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (svn_boolean_t)SWIG_As_long(obj2);
        if (SWIG_arg_fail(svn_argnum_obj2)) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_stream_t *)svn_txdelta_parse_svndiff(arg1,arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_svn_stream_t, 
    _global_svn_swig_py_pool);
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_read_svndiff_window(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t **arg1 = (svn_txdelta_window_t **) 0 ;
    svn_stream_t *arg2 = (svn_stream_t *) 0 ;
    int arg3 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    svn_txdelta_window_t *temp1 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg1 = (svn_txdelta_window_t **)&temp1;
    }
    if(!PyArg_ParseTuple(args,(char *)"OO|O:svn_txdelta_read_svndiff_window",&obj0,&obj1,&obj2)) goto fail;
    {
        arg2 = svn_swig_py_make_stream (obj0, _global_pool);
    }
    {
        arg3 = (int)SWIG_As_long(obj1);
        if (SWIG_arg_fail(svn_argnum_obj1)) {
            SWIG_fail;
        }
    }
    if (obj2) {
        {
            if (obj2 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj2 != NULL && !PyObject_HasAttrString(obj2, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj2);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj2, SWIGTYPE_p_apr_pool_t, svn_argnum_obj2, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj2;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_txdelta_read_svndiff_window(arg1,arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg1, SWIGTYPE_p_svn_txdelta_window_t, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_txdelta_skip_svndiff_window(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    apr_file_t *arg1 = (apr_file_t *) 0 ;
    int arg2 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg3 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OO|O:svn_txdelta_skip_svndiff_window",&obj0,&obj1,&obj2)) goto fail;
    {
        arg1 = svn_swig_py_make_file(obj0, _global_pool);
        if (!arg1) SWIG_fail;
    }
    {
        arg2 = (int)SWIG_As_long(obj1);
        if (SWIG_arg_fail(svn_argnum_obj1)) {
            SWIG_fail;
        }
    }
    if (obj2) {
        {
            if (obj2 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj2 != NULL && !PyObject_HasAttrString(obj2, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj2);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj2, SWIGTYPE_p_apr_pool_t, svn_argnum_obj2, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj2;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg3 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_txdelta_skip_svndiff_window(arg1,arg2,arg3);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_set_target_revision_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_revnum_t,apr_pool_t *) = (svn_error_t *(*)(void *,svn_revnum_t,apr_pool_t *)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_set_target_revision_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(void *,svn_revnum_t,apr_pool_t *))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_void_svn_revnum_t_p_apr_pool_t__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->set_target_revision = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_set_target_revision_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(void *,svn_revnum_t,apr_pool_t *);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_set_target_revision_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(void *,svn_revnum_t,apr_pool_t *)) ((arg1)->set_target_revision);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_void_svn_revnum_t_p_apr_pool_t__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_open_root_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(void *,svn_revnum_t,apr_pool_t *,void **) = (svn_error_t *(*)(void *,svn_revnum_t,apr_pool_t *,void **)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_open_root_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(void *,svn_revnum_t,apr_pool_t *,void **))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->open_root = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_open_root_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(void *,svn_revnum_t,apr_pool_t *,void **);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_open_root_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(void *,svn_revnum_t,apr_pool_t *,void **)) ((arg1)->open_root);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_delete_entry_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(char const *,svn_revnum_t,void *,apr_pool_t *) = (svn_error_t *(*)(char const *,svn_revnum_t,void *,apr_pool_t *)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_delete_entry_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(char const *,svn_revnum_t,void *,apr_pool_t *))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_q_const__char_svn_revnum_t_p_void_p_apr_pool_t__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->delete_entry = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_delete_entry_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(char const *,svn_revnum_t,void *,apr_pool_t *);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_delete_entry_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(char const *,svn_revnum_t,void *,apr_pool_t *)) ((arg1)->delete_entry);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_q_const__char_svn_revnum_t_p_void_p_apr_pool_t__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_add_directory_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **) = (svn_error_t *(*)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_add_directory_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_q_const__char_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->add_directory = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_add_directory_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_add_directory_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **)) ((arg1)->add_directory);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_q_const__char_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_open_directory_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(char const *,void *,svn_revnum_t,apr_pool_t *,void **) = (svn_error_t *(*)(char const *,void *,svn_revnum_t,apr_pool_t *,void **)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_open_directory_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(char const *,void *,svn_revnum_t,apr_pool_t *,void **))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_q_const__char_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->open_directory = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_open_directory_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(char const *,void *,svn_revnum_t,apr_pool_t *,void **);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_open_directory_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(char const *,void *,svn_revnum_t,apr_pool_t *,void **)) ((arg1)->open_directory);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_q_const__char_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_change_dir_prop_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_string_t const *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_string_t const *,apr_pool_t *)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_change_dir_prop_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(void *,char const *,svn_string_t const *,apr_pool_t *))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->change_dir_prop = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_change_dir_prop_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_string_t const *,apr_pool_t *);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_change_dir_prop_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(void *,char const *,svn_string_t const *,apr_pool_t *)) ((arg1)->change_dir_prop);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_close_directory_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_pool_t *)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_close_directory_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(void *,apr_pool_t *))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->close_directory = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_close_directory_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(void *,apr_pool_t *);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_close_directory_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(void *,apr_pool_t *)) ((arg1)->close_directory);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_absent_directory_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(char const *,void *,apr_pool_t *) = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_absent_directory_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(char const *,void *,apr_pool_t *))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->absent_directory = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_absent_directory_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(char const *,void *,apr_pool_t *);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_absent_directory_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) ((arg1)->absent_directory);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_add_file_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **) = (svn_error_t *(*)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_add_file_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_q_const__char_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->add_file = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_add_file_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_add_file_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **)) ((arg1)->add_file);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_q_const__char_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_open_file_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(char const *,void *,svn_revnum_t,apr_pool_t *,void **) = (svn_error_t *(*)(char const *,void *,svn_revnum_t,apr_pool_t *,void **)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_open_file_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(char const *,void *,svn_revnum_t,apr_pool_t *,void **))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_q_const__char_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->open_file = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_open_file_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(char const *,void *,svn_revnum_t,apr_pool_t *,void **);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_open_file_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(char const *,void *,svn_revnum_t,apr_pool_t *,void **)) ((arg1)->open_file);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_q_const__char_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_apply_textdelta_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,apr_pool_t *,svn_txdelta_window_handler_t *,void **) = (svn_error_t *(*)(void *,char const *,apr_pool_t *,svn_txdelta_window_handler_t *,void **)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_apply_textdelta_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(void *,char const *,apr_pool_t *,svn_txdelta_window_handler_t *,void **))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t_p_svn_txdelta_window_handler_t_p_p_void__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->apply_textdelta = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_apply_textdelta_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,apr_pool_t *,svn_txdelta_window_handler_t *,void **);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_apply_textdelta_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(void *,char const *,apr_pool_t *,svn_txdelta_window_handler_t *,void **)) ((arg1)->apply_textdelta);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t_p_svn_txdelta_window_handler_t_p_p_void__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_change_file_prop_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,svn_string_t const *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,svn_string_t const *,apr_pool_t *)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_change_file_prop_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(void *,char const *,svn_string_t const *,apr_pool_t *))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->change_file_prop = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_change_file_prop_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,svn_string_t const *,apr_pool_t *);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_change_file_prop_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(void *,char const *,svn_string_t const *,apr_pool_t *)) ((arg1)->change_file_prop);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_void_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_close_file_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(void *,char const *,apr_pool_t *) = (svn_error_t *(*)(void *,char const *,apr_pool_t *)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_close_file_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(void *,char const *,apr_pool_t *))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->close_file = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_close_file_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(void *,char const *,apr_pool_t *);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_close_file_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(void *,char const *,apr_pool_t *)) ((arg1)->close_file);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_absent_file_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(char const *,void *,apr_pool_t *) = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_absent_file_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(char const *,void *,apr_pool_t *))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->absent_file = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_absent_file_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(char const *,void *,apr_pool_t *);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_absent_file_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(char const *,void *,apr_pool_t *)) ((arg1)->absent_file);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_close_edit_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_pool_t *)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_close_edit_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(void *,apr_pool_t *))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->close_edit = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_close_edit_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(void *,apr_pool_t *);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_close_edit_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(void *,apr_pool_t *)) ((arg1)->close_edit);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_abort_edit_set(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*arg2)(void *,apr_pool_t *) = (svn_error_t *(*)(void *,apr_pool_t *)) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_editor_t_abort_edit_set",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (svn_error_t *(*)(void *,apr_pool_t *))svn_swig_MustGetPtr(obj1, SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (arg1) (arg1)->abort_edit = arg2;
    
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_t_abort_edit_get(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    svn_error_t *(*result)(void *,apr_pool_t *);
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:svn_delta_editor_t_abort_edit_get",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    result = (svn_error_t *(*)(void *,apr_pool_t *)) ((arg1)->abort_edit);
    
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_f_p_void_p_apr_pool_t__p_svn_error_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_new_svn_delta_editor_t(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *result;
    
    if(!PyArg_ParseTuple(args,(char *)":new_svn_delta_editor_t")) goto fail;
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_delta_editor_t *)(svn_delta_editor_t *) calloc(1, sizeof(svn_delta_editor_t));
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_svn_delta_editor_t, 
    _global_svn_swig_py_pool);
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_delete_svn_delta_editor_t(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"O:delete_svn_delta_editor_t",&obj0)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        free((char *) arg1);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    Py_INCREF(Py_None); resultobj = Py_None;
    return resultobj;
    fail:
    return NULL;
}


static PyObject * svn_delta_editor_t_swigregister(PyObject *self, PyObject *args) {
    PyObject *obj;
    if (!PyArg_ParseTuple(args,(char*)"O", &obj)) return NULL;
    SWIG_TypeClientData(SWIGTYPE_p_svn_delta_editor_t, obj);
    Py_INCREF(obj);
    return Py_BuildValue((char *)"");
}
static PyObject *_wrap_svn_delta_default_editor(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    apr_pool_t *arg1 = (apr_pool_t *) 0 ;
    svn_delta_editor_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg1 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"|O:svn_delta_default_editor",&obj0)) goto fail;
    if (obj0) {
        {
            if (obj0 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj0 != NULL && !PyObject_HasAttrString(obj0, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj0);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj0, SWIGTYPE_p_apr_pool_t, svn_argnum_obj0, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj0;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg1 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_delta_editor_t *)svn_delta_default_editor(arg1);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    resultobj = svn_swig_NewPointerObj((void*)(result), SWIGTYPE_p_svn_delta_editor_t, 
    _global_svn_swig_py_pool);
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_noop_window_handler(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_txdelta_window_t *arg1 = (svn_txdelta_window_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_error_t *result;
    PyObject *_global_svn_swig_py_pool ;
    apr_pool_t *_global_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    if(!PyArg_ParseTuple(args,(char *)"OO:svn_delta_noop_window_handler",&obj0,&obj1)) goto fail;
    {
        arg1 = (svn_txdelta_window_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_txdelta_window_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_noop_window_handler(arg1,arg2);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    return resultobj;
    fail:
    return NULL;
}


static PyObject *_wrap_svn_delta_get_cancellation_editor(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_cancel_func_t arg1 = (svn_cancel_func_t) 0 ;
    void *arg2 = (void *) 0 ;
    svn_delta_editor_t *arg3 = (svn_delta_editor_t *) 0 ;
    void *arg4 = (void *) 0 ;
    svn_delta_editor_t **arg5 = (svn_delta_editor_t **) 0 ;
    void **arg6 = (void **) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    svn_delta_editor_t const *temp5 ;
    void *temp6 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg7 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg5 = (svn_delta_editor_t **)&temp5;
    }
    {
        arg6 = (void **)&temp6;
    }
    if(!PyArg_ParseTuple(args,(char *)"OOO|O:svn_delta_get_cancellation_editor",&obj0,&obj1,&obj2,&obj3)) goto fail;
    {
        arg1 = svn_swig_py_cancel_func;
        arg2 = obj0; /* our function is the baton. */
    }
    {
        arg3 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg4 = (void *)svn_swig_MustGetPtr(obj2, SWIGTYPE_p_void, svn_argnum_obj2,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg7 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_get_cancellation_editor(arg1,arg2,(struct svn_delta_editor_t const *)arg3,arg4,(struct svn_delta_editor_t const **)arg5,arg6,arg7);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg5, SWIGTYPE_p_svn_delta_editor_t, _global_svn_swig_py_pool));
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg6, SWIGTYPE_p_void, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_path_driver(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_revnum_t arg3 ;
    apr_array_header_t *arg4 = (apr_array_header_t *) 0 ;
    svn_delta_path_driver_cb_func_t arg5 = (svn_delta_path_driver_cb_func_t) 0 ;
    void *arg6 = (void *) 0 ;
    apr_pool_t *arg7 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    PyObject * obj4 = 0 ;
    PyObject * obj5 = 0 ;
    PyObject * obj6 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg7 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OOOOOO|O:svn_delta_path_driver",&obj0,&obj1,&obj2,&obj3,&obj4,&obj5,&obj6)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (svn_revnum_t)SWIG_As_long(obj2);
        if (SWIG_arg_fail(svn_argnum_obj2)) {
            SWIG_fail;
        }
    }
    {
        arg4 = (apr_array_header_t *)svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_array_header_t, svn_argnum_obj3,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg5 = (svn_delta_path_driver_cb_func_t)svn_swig_MustGetPtr(obj4, SWIGTYPE_p_f_p_p_void_p_void_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t, svn_argnum_obj4,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg6 = (void *)svn_swig_MustGetPtr(obj5, SWIGTYPE_p_void, svn_argnum_obj5,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj6) {
        {
            if (obj6 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj6 != NULL && !PyObject_HasAttrString(obj6, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj6);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj6, SWIGTYPE_p_apr_pool_t, svn_argnum_obj6, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj6;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg7 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_path_driver((struct svn_delta_editor_t const *)arg1,arg2,arg3,arg4,arg5,arg6,arg7);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject * svn_txdelta_stream_t_swigregister(PyObject *self, PyObject *args) {
    PyObject *obj;
    if (!PyArg_ParseTuple(args,(char*)"O", &obj)) return NULL;
    SWIG_TypeClientData(SWIGTYPE_p_svn_txdelta_stream_t, obj);
    Py_INCREF(obj);
    return Py_BuildValue((char *)"");
}
static PyObject *_wrap_svn_delta_editor_invoke_set_target_revision(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_revnum_t arg3 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OOO|O:svn_delta_editor_invoke_set_target_revision",&obj0,&obj1,&obj2,&obj3)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (svn_revnum_t)SWIG_As_long(obj2);
        if (SWIG_arg_fail(svn_argnum_obj2)) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_set_target_revision(arg1,arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_open_root(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    void *arg2 = (void *) 0 ;
    svn_revnum_t arg3 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    void **arg5 = (void **) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    void *temp5 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg5 = (void **)&temp5;
    }
    if(!PyArg_ParseTuple(args,(char *)"OOO|O:svn_delta_editor_invoke_open_root",&obj0,&obj1,&obj2,&obj3)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (svn_revnum_t)SWIG_As_long(obj2);
        if (SWIG_arg_fail(svn_argnum_obj2)) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_open_root(arg1,arg2,arg3,arg4,arg5);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg5, SWIGTYPE_p_void, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_delete_entry(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    char *arg2 = (char *) 0 ;
    svn_revnum_t arg3 ;
    void *arg4 = (void *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    PyObject * obj4 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg5 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OsOO|O:svn_delta_editor_invoke_delete_entry",&obj0,&arg2,&obj2,&obj3,&obj4)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (svn_revnum_t)SWIG_As_long(obj2);
        if (SWIG_arg_fail(svn_argnum_obj2)) {
            SWIG_fail;
        }
    }
    {
        arg4 = (void *)svn_swig_MustGetPtr(obj3, SWIGTYPE_p_void, svn_argnum_obj3,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj4) {
        {
            if (obj4 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj4 != NULL && !PyObject_HasAttrString(obj4, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj4);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj4, SWIGTYPE_p_apr_pool_t, svn_argnum_obj4, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj4;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg5 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_delete_entry(arg1,(char const *)arg2,arg3,arg4,arg5);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_add_directory(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *arg3 = (void *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_revnum_t arg5 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    void **arg7 = (void **) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    void *temp7 ;
    PyObject * obj0 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj4 = 0 ;
    PyObject * obj5 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg6 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg7 = (void **)&temp7;
    }
    if(!PyArg_ParseTuple(args,(char *)"OsOzO|O:svn_delta_editor_invoke_add_directory",&obj0,&arg2,&obj2,&arg4,&obj4,&obj5)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (void *)svn_swig_MustGetPtr(obj2, SWIGTYPE_p_void, svn_argnum_obj2,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg5 = (svn_revnum_t)SWIG_As_long(obj4);
        if (SWIG_arg_fail(svn_argnum_obj4)) {
            SWIG_fail;
        }
    }
    if (obj5) {
        {
            if (obj5 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj5 != NULL && !PyObject_HasAttrString(obj5, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj5);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj5, SWIGTYPE_p_apr_pool_t, svn_argnum_obj5, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj5;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg6 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_add_directory(arg1,(char const *)arg2,arg3,(char const *)arg4,arg5,arg6,arg7);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg7, SWIGTYPE_p_void, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_open_directory(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *arg3 = (void *) 0 ;
    svn_revnum_t arg4 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    void **arg6 = (void **) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    void *temp6 ;
    PyObject * obj0 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    PyObject * obj4 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg5 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg6 = (void **)&temp6;
    }
    if(!PyArg_ParseTuple(args,(char *)"OsOO|O:svn_delta_editor_invoke_open_directory",&obj0,&arg2,&obj2,&obj3,&obj4)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (void *)svn_swig_MustGetPtr(obj2, SWIGTYPE_p_void, svn_argnum_obj2,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg4 = (svn_revnum_t)SWIG_As_long(obj3);
        if (SWIG_arg_fail(svn_argnum_obj3)) {
            SWIG_fail;
        }
    }
    if (obj4) {
        {
            if (obj4 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj4 != NULL && !PyObject_HasAttrString(obj4, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj4);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj4, SWIGTYPE_p_apr_pool_t, svn_argnum_obj4, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj4;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg5 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_open_directory(arg1,(char const *)arg2,arg3,arg4,arg5,arg6);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg6, SWIGTYPE_p_void, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_change_dir_prop(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_string_t *arg4 = (svn_string_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    svn_string_t value4 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj3 = 0 ;
    PyObject * obj4 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg5 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OOsO|O:svn_delta_editor_invoke_change_dir_prop",&obj0,&obj1,&arg3,&obj3,&obj4)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        if (obj3 == Py_None)
        arg4 = NULL;
        else {
            if (!PyString_Check(obj3)) {
                PyErr_SetString(PyExc_TypeError, "not a string");
                SWIG_fail;
            }
            value4.data = PyString_AS_STRING(obj3);
            value4.len = PyString_GET_SIZE(obj3);
            arg4 = &value4;
        }
    }
    if (obj4) {
        {
            if (obj4 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj4 != NULL && !PyObject_HasAttrString(obj4, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj4);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj4, SWIGTYPE_p_apr_pool_t, svn_argnum_obj4, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj4;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg5 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_change_dir_prop(arg1,arg2,(char const *)arg3,(struct svn_string_t const *)arg4,arg5);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_close_directory(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    void *arg2 = (void *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg3 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OO|O:svn_delta_editor_invoke_close_directory",&obj0,&obj1,&obj2)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj2) {
        {
            if (obj2 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj2 != NULL && !PyObject_HasAttrString(obj2, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj2);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj2, SWIGTYPE_p_apr_pool_t, svn_argnum_obj2, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj2;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg3 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_close_directory(arg1,arg2,arg3);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_absent_directory(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OsO|O:svn_delta_editor_invoke_absent_directory",&obj0,&arg2,&obj2,&obj3)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (void *)svn_swig_MustGetPtr(obj2, SWIGTYPE_p_void, svn_argnum_obj2,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_absent_directory(arg1,(char const *)arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_add_file(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *arg3 = (void *) 0 ;
    char *arg4 = (char *) 0 ;
    svn_revnum_t arg5 ;
    apr_pool_t *arg6 = (apr_pool_t *) 0 ;
    void **arg7 = (void **) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    void *temp7 ;
    PyObject * obj0 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj4 = 0 ;
    PyObject * obj5 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg6 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg7 = (void **)&temp7;
    }
    if(!PyArg_ParseTuple(args,(char *)"OsOzO|O:svn_delta_editor_invoke_add_file",&obj0,&arg2,&obj2,&arg4,&obj4,&obj5)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (void *)svn_swig_MustGetPtr(obj2, SWIGTYPE_p_void, svn_argnum_obj2,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg5 = (svn_revnum_t)SWIG_As_long(obj4);
        if (SWIG_arg_fail(svn_argnum_obj4)) {
            SWIG_fail;
        }
    }
    if (obj5) {
        {
            if (obj5 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj5 != NULL && !PyObject_HasAttrString(obj5, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj5);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj5, SWIGTYPE_p_apr_pool_t, svn_argnum_obj5, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj5;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg6 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_add_file(arg1,(char const *)arg2,arg3,(char const *)arg4,arg5,arg6,arg7);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg7, SWIGTYPE_p_void, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_open_file(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *arg3 = (void *) 0 ;
    svn_revnum_t arg4 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    void **arg6 = (void **) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    void *temp6 ;
    PyObject * obj0 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    PyObject * obj4 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg5 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg6 = (void **)&temp6;
    }
    if(!PyArg_ParseTuple(args,(char *)"OsOO|O:svn_delta_editor_invoke_open_file",&obj0,&arg2,&obj2,&obj3,&obj4)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (void *)svn_swig_MustGetPtr(obj2, SWIGTYPE_p_void, svn_argnum_obj2,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg4 = (svn_revnum_t)SWIG_As_long(obj3);
        if (SWIG_arg_fail(svn_argnum_obj3)) {
            SWIG_fail;
        }
    }
    if (obj4) {
        {
            if (obj4 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj4 != NULL && !PyObject_HasAttrString(obj4, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj4);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj4, SWIGTYPE_p_apr_pool_t, svn_argnum_obj4, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj4;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg5 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_open_file(arg1,(char const *)arg2,arg3,arg4,arg5,arg6);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg6, SWIGTYPE_p_void, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_apply_textdelta(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_txdelta_window_handler_t *arg5 = (svn_txdelta_window_handler_t *) 0 ;
    void **arg6 = (void **) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    svn_txdelta_window_handler_t temp5 ;
    void *temp6 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    {
        arg5 = (svn_txdelta_window_handler_t *)&temp5;
    }
    {
        arg6 = (void **)&temp6;
    }
    if(!PyArg_ParseTuple(args,(char *)"OOz|O:svn_delta_editor_invoke_apply_textdelta",&obj0,&obj1,&arg3,&obj3)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_apply_textdelta(arg1,arg2,(char const *)arg3,arg4,arg5,arg6);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg5, SWIGTYPE_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, _global_svn_swig_py_pool));
    }
    {
        resultobj = t_output_helper(resultobj,
        svn_swig_NewPointerObj(*arg6, SWIGTYPE_p_void, _global_svn_swig_py_pool));
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_change_file_prop(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    svn_string_t *arg4 = (svn_string_t *) 0 ;
    apr_pool_t *arg5 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    svn_string_t value4 ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj3 = 0 ;
    PyObject * obj4 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg5 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OOsO|O:svn_delta_editor_invoke_change_file_prop",&obj0,&obj1,&arg3,&obj3,&obj4)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        if (obj3 == Py_None)
        arg4 = NULL;
        else {
            if (!PyString_Check(obj3)) {
                PyErr_SetString(PyExc_TypeError, "not a string");
                SWIG_fail;
            }
            value4.data = PyString_AS_STRING(obj3);
            value4.len = PyString_GET_SIZE(obj3);
            arg4 = &value4;
        }
    }
    if (obj4) {
        {
            if (obj4 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj4 != NULL && !PyObject_HasAttrString(obj4, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj4);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj4, SWIGTYPE_p_apr_pool_t, svn_argnum_obj4, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj4;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg5 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_change_file_prop(arg1,arg2,(char const *)arg3,(struct svn_string_t const *)arg4,arg5);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_close_file(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    void *arg2 = (void *) 0 ;
    char *arg3 = (char *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OOs|O:svn_delta_editor_invoke_close_file",&obj0,&obj1,&arg3,&obj3)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_close_file(arg1,arg2,(char const *)arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_absent_file(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    char *arg2 = (char *) 0 ;
    void *arg3 = (void *) 0 ;
    apr_pool_t *arg4 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj2 = 0 ;
    PyObject * obj3 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg4 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OsO|O:svn_delta_editor_invoke_absent_file",&obj0,&arg2,&obj2,&obj3)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg3 = (void *)svn_swig_MustGetPtr(obj2, SWIGTYPE_p_void, svn_argnum_obj2,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj3) {
        {
            if (obj3 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj3 != NULL && !PyObject_HasAttrString(obj3, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj3);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj3, SWIGTYPE_p_apr_pool_t, svn_argnum_obj3, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj3;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg4 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_absent_file(arg1,(char const *)arg2,arg3,arg4);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_close_edit(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    void *arg2 = (void *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg3 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OO|O:svn_delta_editor_invoke_close_edit",&obj0,&obj1,&obj2)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj2) {
        {
            if (obj2 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj2 != NULL && !PyObject_HasAttrString(obj2, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj2);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj2, SWIGTYPE_p_apr_pool_t, svn_argnum_obj2, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj2;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg3 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_close_edit(arg1,arg2,arg3);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyObject *_wrap_svn_delta_editor_invoke_abort_edit(PyObject *self, PyObject *args) {
    PyObject *resultobj = NULL;
    svn_delta_editor_t *arg1 = (svn_delta_editor_t *) 0 ;
    void *arg2 = (void *) 0 ;
    apr_pool_t *arg3 = (apr_pool_t *) 0 ;
    svn_error_t *result;
    apr_pool_t *_global_pool ;
    PyObject *_global_svn_swig_py_pool ;
    int _global_pool_is_default_pool ;
    int _global_pool_is_application_pool ;
    PyObject * obj0 = 0 ;
    PyObject * obj1 = 0 ;
    PyObject * obj2 = 0 ;
    
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        _global_pool_is_application_pool = 1;
        svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
    }
    {
        int argnum = PyTuple_GET_SIZE(args) - 1;
        _global_pool_is_application_pool = 0;
        _global_pool_is_default_pool = 1;
        if (argnum >= 0) {
            PyObject *input = PyTuple_GET_ITEM(args, argnum);
            if (input != Py_None &&
            PyObject_HasAttrString(input, (char *)"_mark_valid")) {
                _global_pool = svn_swig_MustGetPtr(input, SWIGTYPE_p_apr_pool_t, argnum+1, NULL);
                if (PyErr_Occurred()) {
                    _global_svn_swig_py_pool = NULL;
                    SWIG_fail;
                }
                _global_svn_swig_py_pool = input;
                Py_XINCREF(_global_svn_swig_py_pool);
                _global_pool_is_default_pool = 0;
            } else {
                if (PyErr_Occurred()) {
                    PyErr_Clear();
                }
                svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
                if (_global_svn_swig_py_pool != NULL) {
                    _global_pool = svn_pool_create(_global_pool);
                    _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
                }
                /*@@*/;
            }
        } else {
            svn_swig_get_application_pool(&_global_svn_swig_py_pool, &_global_pool); 
            /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,258,svn_swig_py_pool_create_subpool@*/
            if (_global_svn_swig_py_pool != NULL) {
                _global_pool = svn_pool_create(_global_pool);
                _global_svn_swig_py_pool = svn_swig_NewPointerObj(_global_pool, SWIGTYPE_p_apr_pool_t, _global_svn_swig_py_pool);
            }
            /*@@*/;
        }
        arg3 = _global_pool;
        /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
        if (_global_svn_swig_py_pool != NULL && !PyObject_HasAttrString(_global_svn_swig_py_pool, (char *)"_mark_valid"))
        {
            int argnum = PyTuple_GET_SIZE(args);
            SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), _global_svn_swig_py_pool);
            SWIG_arg_fail(argnum);
            SWIG_fail;
        }
        /*@@*/
    }
    if(!PyArg_ParseTuple(args,(char *)"OO|O:svn_delta_editor_invoke_abort_edit",&obj0,&obj1,&obj2)) goto fail;
    {
        arg1 = (svn_delta_editor_t *)svn_swig_MustGetPtr(obj0, SWIGTYPE_p_svn_delta_editor_t, svn_argnum_obj0,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    {
        arg2 = (void *)svn_swig_MustGetPtr(obj1, SWIGTYPE_p_void, svn_argnum_obj1,
        _global_pool_is_application_pool ? &_global_svn_swig_py_pool : NULL);
        if (PyErr_Occurred()) {
            SWIG_fail;
        }
    }
    if (obj2) {
        {
            if (obj2 != Py_None && _global_pool_is_default_pool == 1) {
                /*@/home/dave/svn/env/.dist_sandbox/subversion-1.4.4/subversion/bindings/swig/include/svn_types.swg,246,svn_swig_py_pool_check@*/
                if (obj2 != NULL && !PyObject_HasAttrString(obj2, (char *)"_mark_valid"))
                {
                    int argnum = PyTuple_GET_SIZE(args);
                    SWIG_Python_TypeError(SWIG_TypePrettyName(SWIGTYPE_p_apr_pool_t), obj2);
                    SWIG_arg_fail(argnum);
                    SWIG_fail;
                }
                /*@@*/
                _global_pool = svn_swig_MustGetPtr(obj2, SWIGTYPE_p_apr_pool_t, svn_argnum_obj2, 
                NULL);
                if (PyErr_Occurred()) {
                    SWIG_fail;
                }
                Py_XDECREF(_global_svn_swig_py_pool);
                _global_svn_swig_py_pool = obj2;
                Py_XINCREF(_global_svn_swig_py_pool);
                arg3 = _global_pool;
            }
        }
    }
    {
        svn_swig_py_release_py_lock();
        
        result = (svn_error_t *)svn_delta_editor_invoke_abort_edit(arg1,arg2,arg3);
        
        
        svn_swig_py_acquire_py_lock();
        
    }
    {
        if (result != NULL) {
            if (result->apr_err != SVN_ERR_SWIG_PY_EXCEPTION_SET)
            svn_swig_py_svn_exception(result);
            else
            svn_error_clear(result);
            SWIG_fail;
        }
        Py_INCREF(Py_None);
        resultobj = Py_None;
    }
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return resultobj;
    fail:
    {
        Py_XDECREF(_global_svn_swig_py_pool);
    }
    return NULL;
}


static PyMethodDef SwigMethods[] = {
	 { (char *)"svn_swig_py_make_editor", _wrap_svn_swig_py_make_editor, METH_VARARGS, NULL},
	 { (char *)"svn_delta_version", _wrap_svn_delta_version, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_op_t_action_code_set", _wrap_svn_txdelta_op_t_action_code_set, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_op_t_action_code_get", _wrap_svn_txdelta_op_t_action_code_get, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_op_t_offset_set", _wrap_svn_txdelta_op_t_offset_set, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_op_t_offset_get", _wrap_svn_txdelta_op_t_offset_get, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_op_t_length_set", _wrap_svn_txdelta_op_t_length_set, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_op_t_length_get", _wrap_svn_txdelta_op_t_length_get, METH_VARARGS, NULL},
	 { (char *)"new_svn_txdelta_op_t", _wrap_new_svn_txdelta_op_t, METH_VARARGS, NULL},
	 { (char *)"delete_svn_txdelta_op_t", _wrap_delete_svn_txdelta_op_t, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_op_t_swigregister", svn_txdelta_op_t_swigregister, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_sview_offset_set", _wrap_svn_txdelta_window_t_sview_offset_set, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_sview_offset_get", _wrap_svn_txdelta_window_t_sview_offset_get, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_sview_len_set", _wrap_svn_txdelta_window_t_sview_len_set, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_sview_len_get", _wrap_svn_txdelta_window_t_sview_len_get, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_tview_len_set", _wrap_svn_txdelta_window_t_tview_len_set, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_tview_len_get", _wrap_svn_txdelta_window_t_tview_len_get, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_num_ops_set", _wrap_svn_txdelta_window_t_num_ops_set, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_num_ops_get", _wrap_svn_txdelta_window_t_num_ops_get, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_src_ops_set", _wrap_svn_txdelta_window_t_src_ops_set, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_src_ops_get", _wrap_svn_txdelta_window_t_src_ops_get, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_ops_set", _wrap_svn_txdelta_window_t_ops_set, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_ops_get", _wrap_svn_txdelta_window_t_ops_get, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_new_data_get", _wrap_svn_txdelta_window_t_new_data_get, METH_VARARGS, NULL},
	 { (char *)"new_svn_txdelta_window_t", _wrap_new_svn_txdelta_window_t, METH_VARARGS, NULL},
	 { (char *)"delete_svn_txdelta_window_t", _wrap_delete_svn_txdelta_window_t, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_t_swigregister", svn_txdelta_window_t_swigregister, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_window_dup", _wrap_svn_txdelta_window_dup, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_compose_windows", _wrap_svn_txdelta_compose_windows, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_apply_instructions", _wrap_svn_txdelta_apply_instructions, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_stream_create", _wrap_svn_txdelta_stream_create, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_next_window", _wrap_svn_txdelta_next_window, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_md5_digest", _wrap_svn_txdelta_md5_digest, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta", _wrap_svn_txdelta, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_target_push", _wrap_svn_txdelta_target_push, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_send_string", _wrap_svn_txdelta_send_string, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_send_stream", _wrap_svn_txdelta_send_stream, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_send_txstream", _wrap_svn_txdelta_send_txstream, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_apply", _wrap_svn_txdelta_apply, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_to_svndiff2", _wrap_svn_txdelta_to_svndiff2, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_to_svndiff", _wrap_svn_txdelta_to_svndiff, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_parse_svndiff", _wrap_svn_txdelta_parse_svndiff, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_read_svndiff_window", _wrap_svn_txdelta_read_svndiff_window, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_skip_svndiff_window", _wrap_svn_txdelta_skip_svndiff_window, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_set_target_revision_set", _wrap_svn_delta_editor_t_set_target_revision_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_set_target_revision_get", _wrap_svn_delta_editor_t_set_target_revision_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_open_root_set", _wrap_svn_delta_editor_t_open_root_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_open_root_get", _wrap_svn_delta_editor_t_open_root_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_delete_entry_set", _wrap_svn_delta_editor_t_delete_entry_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_delete_entry_get", _wrap_svn_delta_editor_t_delete_entry_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_add_directory_set", _wrap_svn_delta_editor_t_add_directory_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_add_directory_get", _wrap_svn_delta_editor_t_add_directory_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_open_directory_set", _wrap_svn_delta_editor_t_open_directory_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_open_directory_get", _wrap_svn_delta_editor_t_open_directory_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_change_dir_prop_set", _wrap_svn_delta_editor_t_change_dir_prop_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_change_dir_prop_get", _wrap_svn_delta_editor_t_change_dir_prop_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_close_directory_set", _wrap_svn_delta_editor_t_close_directory_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_close_directory_get", _wrap_svn_delta_editor_t_close_directory_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_absent_directory_set", _wrap_svn_delta_editor_t_absent_directory_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_absent_directory_get", _wrap_svn_delta_editor_t_absent_directory_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_add_file_set", _wrap_svn_delta_editor_t_add_file_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_add_file_get", _wrap_svn_delta_editor_t_add_file_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_open_file_set", _wrap_svn_delta_editor_t_open_file_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_open_file_get", _wrap_svn_delta_editor_t_open_file_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_apply_textdelta_set", _wrap_svn_delta_editor_t_apply_textdelta_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_apply_textdelta_get", _wrap_svn_delta_editor_t_apply_textdelta_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_change_file_prop_set", _wrap_svn_delta_editor_t_change_file_prop_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_change_file_prop_get", _wrap_svn_delta_editor_t_change_file_prop_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_close_file_set", _wrap_svn_delta_editor_t_close_file_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_close_file_get", _wrap_svn_delta_editor_t_close_file_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_absent_file_set", _wrap_svn_delta_editor_t_absent_file_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_absent_file_get", _wrap_svn_delta_editor_t_absent_file_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_close_edit_set", _wrap_svn_delta_editor_t_close_edit_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_close_edit_get", _wrap_svn_delta_editor_t_close_edit_get, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_abort_edit_set", _wrap_svn_delta_editor_t_abort_edit_set, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_abort_edit_get", _wrap_svn_delta_editor_t_abort_edit_get, METH_VARARGS, NULL},
	 { (char *)"new_svn_delta_editor_t", _wrap_new_svn_delta_editor_t, METH_VARARGS, NULL},
	 { (char *)"delete_svn_delta_editor_t", _wrap_delete_svn_delta_editor_t, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_t_swigregister", svn_delta_editor_t_swigregister, METH_VARARGS, NULL},
	 { (char *)"svn_delta_default_editor", _wrap_svn_delta_default_editor, METH_VARARGS, NULL},
	 { (char *)"svn_delta_noop_window_handler", _wrap_svn_delta_noop_window_handler, METH_VARARGS, NULL},
	 { (char *)"svn_delta_get_cancellation_editor", _wrap_svn_delta_get_cancellation_editor, METH_VARARGS, NULL},
	 { (char *)"svn_delta_path_driver", _wrap_svn_delta_path_driver, METH_VARARGS, NULL},
	 { (char *)"svn_txdelta_stream_t_swigregister", svn_txdelta_stream_t_swigregister, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_set_target_revision", _wrap_svn_delta_editor_invoke_set_target_revision, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_open_root", _wrap_svn_delta_editor_invoke_open_root, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_delete_entry", _wrap_svn_delta_editor_invoke_delete_entry, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_add_directory", _wrap_svn_delta_editor_invoke_add_directory, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_open_directory", _wrap_svn_delta_editor_invoke_open_directory, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_change_dir_prop", _wrap_svn_delta_editor_invoke_change_dir_prop, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_close_directory", _wrap_svn_delta_editor_invoke_close_directory, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_absent_directory", _wrap_svn_delta_editor_invoke_absent_directory, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_add_file", _wrap_svn_delta_editor_invoke_add_file, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_open_file", _wrap_svn_delta_editor_invoke_open_file, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_apply_textdelta", _wrap_svn_delta_editor_invoke_apply_textdelta, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_change_file_prop", _wrap_svn_delta_editor_invoke_change_file_prop, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_close_file", _wrap_svn_delta_editor_invoke_close_file, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_absent_file", _wrap_svn_delta_editor_invoke_absent_file, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_close_edit", _wrap_svn_delta_editor_invoke_close_edit, METH_VARARGS, NULL},
	 { (char *)"svn_delta_editor_invoke_abort_edit", _wrap_svn_delta_editor_invoke_abort_edit, METH_VARARGS, NULL},
	 { NULL, NULL, 0, NULL }
};


/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (BEGIN) -------- */

static swig_type_info _swigt__p_apr_array_header_t = {"_p_apr_array_header_t", "apr_array_header_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_file_t = {"_p_apr_file_t", "apr_file_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_hash_t = {"_p_apr_hash_t", "apr_hash_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int32_t = {"_p_apr_int32_t", "apr_int32_t *|time_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_int64_t = {"_p_apr_int64_t", "apr_int64_t *|svn_filesize_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_pool_t = {"_p_apr_pool_t", "apr_pool_t *", 0, 0, 0};
static swig_type_info _swigt__p_apr_size_t = {"_p_apr_size_t", "apr_size_t *", 0, 0, 0};
static swig_type_info _swigt__p_char = {"_p_char", "char *", 0, 0, 0};
static swig_type_info _swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(apr_getopt_t *,void *,apr_pool_t *)|svn_opt_subcommand_t *", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_svn_txdelta_window_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_svn_txdelta_window_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(svn_txdelta_window_t **,void *,apr_pool_t *)|svn_txdelta_next_window_fn_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_p_void_p_void_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_p_void_p_void_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void **,void *,void *,char const *,apr_pool_t *)|svn_delta_path_driver_cb_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(char const *,void *,apr_pool_t *)|svn_error_t *(*)(char const *,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_q_const__char_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t = {"_p_f_p_q_const__char_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t", "struct svn_error_t *(*)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **)|svn_error_t *(*)(char const *,void *,char const *,svn_revnum_t,apr_pool_t *,void **)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_q_const__char_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t = {"_p_f_p_q_const__char_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t", "struct svn_error_t *(*)(char const *,void *,svn_revnum_t,apr_pool_t *,void **)|svn_error_t *(*)(char const *,void *,svn_revnum_t,apr_pool_t *,void **)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_q_const__char_svn_revnum_t_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_q_const__char_svn_revnum_t_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(char const *,svn_revnum_t,void *,apr_pool_t *)|svn_error_t *(*)(char const *,svn_revnum_t,void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t = {"_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t", "struct svn_error_t *(*)(svn_txdelta_window_t *,void *)|svn_txdelta_window_handler_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void__p_svn_error_t = {"_p_f_p_void__p_svn_error_t", "struct svn_error_t *(*)(void *)|svn_cancel_func_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void__p_unsigned_char = {"_p_f_p_void__p_unsigned_char", "unsigned char *(*)(void *)|svn_txdelta_md5_digest_fn_t", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,apr_pool_t *)|svn_error_t *(*)(void *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_apr_pool_t_p_svn_txdelta_window_handler_t_p_p_void__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_apr_pool_t_p_svn_txdelta_window_handler_t_p_p_void__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,apr_pool_t *,svn_txdelta_window_handler_t *,void **)|svn_error_t *(*)(void *,char const *,apr_pool_t *,svn_txdelta_window_handler_t *,void **)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,char const *,svn_string_t const *,apr_pool_t *)|svn_error_t *(*)(void *,char const *,svn_string_t const *,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_svn_revnum_t_p_apr_pool_t__p_svn_error_t = {"_p_f_p_void_svn_revnum_t_p_apr_pool_t__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t,apr_pool_t *)|svn_error_t *(*)(void *,svn_revnum_t,apr_pool_t *)", 0, 0, 0};
static swig_type_info _swigt__p_f_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t = {"_p_f_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t", "struct svn_error_t *(*)(void *,svn_revnum_t,apr_pool_t *,void **)|svn_error_t *(*)(void *,svn_revnum_t,apr_pool_t *,void **)", 0, 0, 0};
static swig_type_info _swigt__p_int = {"_p_int", "int *|svn_boolean_t *", 0, 0, 0};
static swig_type_info _swigt__p_long = {"_p_long", "long *|svn_revnum_t *", 0, 0, 0};
static swig_type_info _swigt__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t = {"_p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t", "struct svn_error_t *(**)(svn_txdelta_window_t *,void *)|svn_txdelta_window_handler_t *", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_delta_editor_t = {"_p_p_svn_delta_editor_t", "struct svn_delta_editor_t **|svn_delta_editor_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_txdelta_stream_t = {"_p_p_svn_txdelta_stream_t", "struct svn_txdelta_stream_t **|svn_txdelta_stream_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_svn_txdelta_window_t = {"_p_p_svn_txdelta_window_t", "struct svn_txdelta_window_t **|svn_txdelta_window_t **", 0, 0, 0};
static swig_type_info _swigt__p_p_void = {"_p_p_void", "void **", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_baton_t = {"_p_svn_auth_baton_t", "struct svn_auth_baton_t *|svn_auth_baton_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_simple_t = {"_p_svn_auth_cred_simple_t", "struct svn_auth_cred_simple_t *|svn_auth_cred_simple_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_pw_t = {"_p_svn_auth_cred_ssl_client_cert_pw_t", "struct svn_auth_cred_ssl_client_cert_pw_t *|svn_auth_cred_ssl_client_cert_pw_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_client_cert_t = {"_p_svn_auth_cred_ssl_client_cert_t", "struct svn_auth_cred_ssl_client_cert_t *|svn_auth_cred_ssl_client_cert_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_ssl_server_trust_t = {"_p_svn_auth_cred_ssl_server_trust_t", "struct svn_auth_cred_ssl_server_trust_t *|svn_auth_cred_ssl_server_trust_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_cred_username_t = {"_p_svn_auth_cred_username_t", "struct svn_auth_cred_username_t *|svn_auth_cred_username_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_iterstate_t = {"_p_svn_auth_iterstate_t", "struct svn_auth_iterstate_t *|svn_auth_iterstate_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_object_t = {"_p_svn_auth_provider_object_t", "struct svn_auth_provider_object_t *|svn_auth_provider_object_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_provider_t = {"_p_svn_auth_provider_t", "struct svn_auth_provider_t *|svn_auth_provider_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_auth_ssl_server_cert_info_t = {"_p_svn_auth_ssl_server_cert_info_t", "struct svn_auth_ssl_server_cert_info_t *|svn_auth_ssl_server_cert_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_commit_info_t = {"_p_svn_commit_info_t", "struct svn_commit_info_t *|svn_commit_info_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_config_t = {"_p_svn_config_t", "struct svn_config_t *|svn_config_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_delta_editor_t = {"_p_svn_delta_editor_t", "struct svn_delta_editor_t *|svn_delta_editor_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_dirent_t = {"_p_svn_dirent_t", "struct svn_dirent_t *|svn_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_errno_t = {"_p_svn_errno_t", "enum svn_errno_t *|svn_errno_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_error_t = {"_p_svn_error_t", "struct svn_error_t *|svn_error_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_dirent_t = {"_p_svn_io_dirent_t", "struct svn_io_dirent_t *|svn_io_dirent_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_io_file_del_t = {"_p_svn_io_file_del_t", "enum svn_io_file_del_t *|svn_io_file_del_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_lock_t = {"_p_svn_lock_t", "struct svn_lock_t *|svn_lock_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_log_changed_path_t = {"_p_svn_log_changed_path_t", "struct svn_log_changed_path_t *|svn_log_changed_path_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_node_kind_t = {"_p_svn_node_kind_t", "enum svn_node_kind_t *|svn_node_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_t = {"_p_svn_opt_revision_t", "struct svn_opt_revision_t *|svn_opt_revision_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_revision_value_t = {"_p_svn_opt_revision_value_t", "union svn_opt_revision_value_t *|svn_opt_revision_value_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc2_t = {"_p_svn_opt_subcommand_desc2_t", "struct svn_opt_subcommand_desc2_t *|svn_opt_subcommand_desc2_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_opt_subcommand_desc_t = {"_p_svn_opt_subcommand_desc_t", "struct svn_opt_subcommand_desc_t *|svn_opt_subcommand_desc_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_prop_kind = {"_p_svn_prop_kind", "enum svn_prop_kind *|svn_prop_kind_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stream_t = {"_p_svn_stream_t", "struct svn_stream_t *|svn_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_string_t = {"_p_svn_string_t", "struct svn_string_t *|svn_string_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_stringbuf_t = {"_p_svn_stringbuf_t", "struct svn_stringbuf_t *|svn_stringbuf_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_op_t = {"_p_svn_txdelta_op_t", "struct svn_txdelta_op_t *|svn_txdelta_op_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_stream_t = {"_p_svn_txdelta_stream_t", "struct svn_txdelta_stream_t *|svn_txdelta_stream_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_txdelta_window_t = {"_p_svn_txdelta_window_t", "struct svn_txdelta_window_t *|svn_txdelta_window_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_checklist_t = {"_p_svn_version_checklist_t", "struct svn_version_checklist_t *|svn_version_checklist_t *", 0, 0, 0};
static swig_type_info _swigt__p_svn_version_t = {"_p_svn_version_t", "struct svn_version_t *|svn_version_t *", 0, 0, 0};
static swig_type_info _swigt__p_unsigned_char = {"_p_unsigned_char", "unsigned char *", 0, 0, 0};
static swig_type_info _swigt__p_void = {"_p_void", "void *", 0, 0, 0};
static swig_type_info _swigt__ptrdiff_t = {"_ptrdiff_t", "ptrdiff_t", 0, 0, 0};
static swig_type_info _swigt__size_t = {"_size_t", "size_t", 0, 0, 0};

static swig_type_info *swig_type_initial[] = {
  &_swigt__p_apr_array_header_t,
  &_swigt__p_apr_file_t,
  &_swigt__p_apr_hash_t,
  &_swigt__p_apr_int32_t,
  &_swigt__p_apr_int64_t,
  &_swigt__p_apr_pool_t,
  &_swigt__p_apr_size_t,
  &_swigt__p_char,
  &_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_svn_txdelta_window_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_p_void_p_void_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_q_const__char_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t,
  &_swigt__p_f_p_q_const__char_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t,
  &_swigt__p_f_p_q_const__char_svn_revnum_t_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  &_swigt__p_f_p_void__p_svn_error_t,
  &_swigt__p_f_p_void__p_unsigned_char,
  &_swigt__p_f_p_void_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_apr_pool_t_p_svn_txdelta_window_handler_t_p_p_void__p_svn_error_t,
  &_swigt__p_f_p_void_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_svn_revnum_t_p_apr_pool_t__p_svn_error_t,
  &_swigt__p_f_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t,
  &_swigt__p_int,
  &_swigt__p_long,
  &_swigt__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  &_swigt__p_p_svn_delta_editor_t,
  &_swigt__p_p_svn_txdelta_stream_t,
  &_swigt__p_p_svn_txdelta_window_t,
  &_swigt__p_p_void,
  &_swigt__p_svn_auth_baton_t,
  &_swigt__p_svn_auth_cred_simple_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_pw_t,
  &_swigt__p_svn_auth_cred_ssl_client_cert_t,
  &_swigt__p_svn_auth_cred_ssl_server_trust_t,
  &_swigt__p_svn_auth_cred_username_t,
  &_swigt__p_svn_auth_iterstate_t,
  &_swigt__p_svn_auth_provider_object_t,
  &_swigt__p_svn_auth_provider_t,
  &_swigt__p_svn_auth_ssl_server_cert_info_t,
  &_swigt__p_svn_commit_info_t,
  &_swigt__p_svn_config_t,
  &_swigt__p_svn_delta_editor_t,
  &_swigt__p_svn_dirent_t,
  &_swigt__p_svn_errno_t,
  &_swigt__p_svn_error_t,
  &_swigt__p_svn_io_dirent_t,
  &_swigt__p_svn_io_file_del_t,
  &_swigt__p_svn_lock_t,
  &_swigt__p_svn_log_changed_path_t,
  &_swigt__p_svn_node_kind_t,
  &_swigt__p_svn_opt_revision_t,
  &_swigt__p_svn_opt_revision_value_t,
  &_swigt__p_svn_opt_subcommand_desc2_t,
  &_swigt__p_svn_opt_subcommand_desc_t,
  &_swigt__p_svn_prop_kind,
  &_swigt__p_svn_stream_t,
  &_swigt__p_svn_string_t,
  &_swigt__p_svn_stringbuf_t,
  &_swigt__p_svn_txdelta_op_t,
  &_swigt__p_svn_txdelta_stream_t,
  &_swigt__p_svn_txdelta_window_t,
  &_swigt__p_svn_version_checklist_t,
  &_swigt__p_svn_version_t,
  &_swigt__p_unsigned_char,
  &_swigt__p_void,
  &_swigt__ptrdiff_t,
  &_swigt__size_t,
};

static swig_cast_info _swigc__p_apr_array_header_t[] = {  {&_swigt__p_apr_array_header_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_file_t[] = {  {&_swigt__p_apr_file_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_hash_t[] = {  {&_swigt__p_apr_hash_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int32_t[] = {  {&_swigt__p_apr_int32_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_int64_t[] = {  {&_swigt__p_apr_int64_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_pool_t[] = {  {&_swigt__p_apr_pool_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_apr_size_t[] = {  {&_swigt__p_apr_size_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_char[] = {  {&_swigt__p_char, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_svn_txdelta_window_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_svn_txdelta_window_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_p_void_p_void_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_p_void_p_void_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_q_const__char_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_q_const__char_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_q_const__char_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_q_const__char_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_q_const__char_svn_revnum_t_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_q_const__char_svn_revnum_t_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void__p_unsigned_char[] = {  {&_swigt__p_f_p_void__p_unsigned_char, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_apr_pool_t_p_svn_txdelta_window_handler_t_p_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_apr_pool_t_p_svn_txdelta_window_handler_t_p_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_svn_revnum_t_p_apr_pool_t__p_svn_error_t[] = {  {&_swigt__p_f_p_void_svn_revnum_t_p_apr_pool_t__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_f_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t[] = {  {&_swigt__p_f_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_int[] = {  {&_swigt__p_int, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_long[] = {  {&_swigt__p_long, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t[] = {  {&_swigt__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_delta_editor_t[] = {  {&_swigt__p_p_svn_delta_editor_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_txdelta_stream_t[] = {  {&_swigt__p_p_svn_txdelta_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_svn_txdelta_window_t[] = {  {&_swigt__p_p_svn_txdelta_window_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_p_void[] = {  {&_swigt__p_p_void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_baton_t[] = {  {&_swigt__p_svn_auth_baton_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_simple_t[] = {  {&_swigt__p_svn_auth_cred_simple_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_pw_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_pw_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_client_cert_t[] = {  {&_swigt__p_svn_auth_cred_ssl_client_cert_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_ssl_server_trust_t[] = {  {&_swigt__p_svn_auth_cred_ssl_server_trust_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_cred_username_t[] = {  {&_swigt__p_svn_auth_cred_username_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_iterstate_t[] = {  {&_swigt__p_svn_auth_iterstate_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_object_t[] = {  {&_swigt__p_svn_auth_provider_object_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_provider_t[] = {  {&_swigt__p_svn_auth_provider_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_auth_ssl_server_cert_info_t[] = {  {&_swigt__p_svn_auth_ssl_server_cert_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_commit_info_t[] = {  {&_swigt__p_svn_commit_info_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_config_t[] = {  {&_swigt__p_svn_config_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_delta_editor_t[] = {  {&_swigt__p_svn_delta_editor_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_dirent_t[] = {  {&_swigt__p_svn_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_errno_t[] = {  {&_swigt__p_svn_errno_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_error_t[] = {  {&_swigt__p_svn_error_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_dirent_t[] = {  {&_swigt__p_svn_io_dirent_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_io_file_del_t[] = {  {&_swigt__p_svn_io_file_del_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_lock_t[] = {  {&_swigt__p_svn_lock_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_log_changed_path_t[] = {  {&_swigt__p_svn_log_changed_path_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_node_kind_t[] = {  {&_swigt__p_svn_node_kind_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_t[] = {  {&_swigt__p_svn_opt_revision_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_revision_value_t[] = {  {&_swigt__p_svn_opt_revision_value_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc2_t[] = {  {&_swigt__p_svn_opt_subcommand_desc2_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_opt_subcommand_desc_t[] = {  {&_swigt__p_svn_opt_subcommand_desc_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_prop_kind[] = {  {&_swigt__p_svn_prop_kind, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stream_t[] = {  {&_swigt__p_svn_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_string_t[] = {  {&_swigt__p_svn_string_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_stringbuf_t[] = {  {&_swigt__p_svn_stringbuf_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_op_t[] = {  {&_swigt__p_svn_txdelta_op_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_stream_t[] = {  {&_swigt__p_svn_txdelta_stream_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_txdelta_window_t[] = {  {&_swigt__p_svn_txdelta_window_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_checklist_t[] = {  {&_swigt__p_svn_version_checklist_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_svn_version_t[] = {  {&_swigt__p_svn_version_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_unsigned_char[] = {  {&_swigt__p_unsigned_char, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__p_void[] = {  {&_swigt__p_void, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__ptrdiff_t[] = {  {&_swigt__ptrdiff_t, 0, 0, 0},{0, 0, 0, 0}};
static swig_cast_info _swigc__size_t[] = {  {&_swigt__size_t, 0, 0, 0},{0, 0, 0, 0}};

static swig_cast_info *swig_cast_initial[] = {
  _swigc__p_apr_array_header_t,
  _swigc__p_apr_file_t,
  _swigc__p_apr_hash_t,
  _swigc__p_apr_int32_t,
  _swigc__p_apr_int64_t,
  _swigc__p_apr_pool_t,
  _swigc__p_apr_size_t,
  _swigc__p_char,
  _swigc__p_f_p_apr_getopt_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_svn_txdelta_window_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_p_void_p_void_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_q_const__char_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_q_const__char_p_void_p_q_const__char_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t,
  _swigc__p_f_p_q_const__char_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t,
  _swigc__p_f_p_q_const__char_svn_revnum_t_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  _swigc__p_f_p_void__p_svn_error_t,
  _swigc__p_f_p_void__p_unsigned_char,
  _swigc__p_f_p_void_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_apr_pool_t_p_svn_txdelta_window_handler_t_p_p_void__p_svn_error_t,
  _swigc__p_f_p_void_p_q_const__char_p_q_const__svn_string_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_svn_revnum_t_p_apr_pool_t__p_svn_error_t,
  _swigc__p_f_p_void_svn_revnum_t_p_apr_pool_t_p_p_void__p_svn_error_t,
  _swigc__p_int,
  _swigc__p_long,
  _swigc__p_p_f_p_svn_txdelta_window_t_p_void__p_svn_error_t,
  _swigc__p_p_svn_delta_editor_t,
  _swigc__p_p_svn_txdelta_stream_t,
  _swigc__p_p_svn_txdelta_window_t,
  _swigc__p_p_void,
  _swigc__p_svn_auth_baton_t,
  _swigc__p_svn_auth_cred_simple_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_pw_t,
  _swigc__p_svn_auth_cred_ssl_client_cert_t,
  _swigc__p_svn_auth_cred_ssl_server_trust_t,
  _swigc__p_svn_auth_cred_username_t,
  _swigc__p_svn_auth_iterstate_t,
  _swigc__p_svn_auth_provider_object_t,
  _swigc__p_svn_auth_provider_t,
  _swigc__p_svn_auth_ssl_server_cert_info_t,
  _swigc__p_svn_commit_info_t,
  _swigc__p_svn_config_t,
  _swigc__p_svn_delta_editor_t,
  _swigc__p_svn_dirent_t,
  _swigc__p_svn_errno_t,
  _swigc__p_svn_error_t,
  _swigc__p_svn_io_dirent_t,
  _swigc__p_svn_io_file_del_t,
  _swigc__p_svn_lock_t,
  _swigc__p_svn_log_changed_path_t,
  _swigc__p_svn_node_kind_t,
  _swigc__p_svn_opt_revision_t,
  _swigc__p_svn_opt_revision_value_t,
  _swigc__p_svn_opt_subcommand_desc2_t,
  _swigc__p_svn_opt_subcommand_desc_t,
  _swigc__p_svn_prop_kind,
  _swigc__p_svn_stream_t,
  _swigc__p_svn_string_t,
  _swigc__p_svn_stringbuf_t,
  _swigc__p_svn_txdelta_op_t,
  _swigc__p_svn_txdelta_stream_t,
  _swigc__p_svn_txdelta_window_t,
  _swigc__p_svn_version_checklist_t,
  _swigc__p_svn_version_t,
  _swigc__p_unsigned_char,
  _swigc__p_void,
  _swigc__ptrdiff_t,
  _swigc__size_t,
};


/* -------- TYPE CONVERSION AND EQUIVALENCE RULES (END) -------- */

static swig_const_info swig_const_table[] = {
{0, 0, 0, 0.0, 0, 0}};

#ifdef __cplusplus
}
#endif
/*************************************************************************
 * Type initialization:
 * This problem is tough by the requirement that no dynamic 
 * memory is used. Also, since swig_type_info structures store pointers to 
 * swig_cast_info structures and swig_cast_info structures store pointers back
 * to swig_type_info structures, we need some lookup code at initialization. 
 * The idea is that swig generates all the structures that are needed. 
 * The runtime then collects these partially filled structures. 
 * The SWIG_InitializeModule function takes these initial arrays out of 
 * swig_module, and does all the lookup, filling in the swig_module.types
 * array with the correct data and linking the correct swig_cast_info
 * structures together.

 * The generated swig_type_info structures are assigned staticly to an initial 
 * array. We just loop though that array, and handle each type individually.
 * First we lookup if this type has been already loaded, and if so, use the
 * loaded structure instead of the generated one. Then we have to fill in the
 * cast linked list. The cast data is initially stored in something like a
 * two-dimensional array. Each row corresponds to a type (there are the same
 * number of rows as there are in the swig_type_initial array). Each entry in
 * a column is one of the swig_cast_info structures for that type.
 * The cast_initial array is actually an array of arrays, because each row has
 * a variable number of columns. So to actually build the cast linked list,
 * we find the array of casts associated with the type, and loop through it 
 * adding the casts to the list. The one last trick we need to do is making
 * sure the type pointer in the swig_cast_info struct is correct.

 * First off, we lookup the cast->type name to see if it is already loaded. 
 * There are three cases to handle:
 *  1) If the cast->type has already been loaded AND the type we are adding
 *     casting info to has not been loaded (it is in this module), THEN we
 *     replace the cast->type pointer with the type pointer that has already
 *     been loaded.
 *  2) If BOTH types (the one we are adding casting info to, and the 
 *     cast->type) are loaded, THEN the cast info has already been loaded by
 *     the previous module so we just ignore it.
 *  3) Finally, if cast->type has not already been loaded, then we add that
 *     swig_cast_info to the linked list (because the cast->type) pointer will
 *     be correct.
**/

#ifdef __cplusplus
extern "C" {
#endif
    
    SWIGRUNTIME void
    SWIG_InitializeModule(void *clientdata) {
        swig_type_info *type, *ret;
        swig_cast_info *cast;
        size_t i;
        swig_module_info *module_head;
        static int init_run = 0;
        
        clientdata = clientdata;
        
        if (init_run) return;
        init_run = 1;
        
        /* Initialize the swig_module */
        swig_module.type_initial = swig_type_initial;
        swig_module.cast_initial = swig_cast_initial;
        
        /* Try and load any already created modules */
        module_head = SWIG_GetModule(clientdata);
        if (module_head) {
            swig_module.next = module_head->next;
            module_head->next = &swig_module;
        } else {
            /* This is the first module loaded */
            swig_module.next = &swig_module;
            SWIG_SetModule(clientdata, &swig_module);
        }
        
        /* Now work on filling in swig_module.types */
        for (i = 0; i < swig_module.size; ++i) {
            type = 0;
            
            /* if there is another module already loaded */
            if (swig_module.next != &swig_module) {
                type = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, swig_module.type_initial[i]->name);
            }
            if (type) {
                /* Overwrite clientdata field */
                if (swig_module.type_initial[i]->clientdata) type->clientdata = swig_module.type_initial[i]->clientdata;
            } else {
                type = swig_module.type_initial[i];
            }
            
            /* Insert casting types */
            cast = swig_module.cast_initial[i];
            while (cast->type) {
                /* Don't need to add information already in the list */
                ret = 0;
                if (swig_module.next != &swig_module) {
                    ret = SWIG_MangledTypeQueryModule(swig_module.next, &swig_module, cast->type->name);
                }
                if (ret && type == swig_module.type_initial[i]) {
                    cast->type = ret;
                    ret = 0;
                }
                
                if (!ret) {
                    if (type->cast) {
                        type->cast->prev = cast;
                        cast->next = type->cast;
                    }
                    type->cast = cast;
                }
                
                cast++;
            }
            
            /* Set entry in modules->types array equal to the type */
            swig_module.types[i] = type;
        }
    }
    
    /* This function will propagate the clientdata field of type to
    * any new swig_type_info structures that have been added into the list
    * of equivalent types.  It is like calling
    * SWIG_TypeClientData(type, clientdata) a second time.
    */
    SWIGRUNTIME void
    SWIG_PropagateClientData(void) {
        size_t i;
        swig_cast_info *equiv;
        static int init_run = 0;
        
        if (init_run) return;
        init_run = 1;
        
        for (i = 0; i < swig_module.size; i++) {
            if (swig_module.types[i]->clientdata) {
                equiv = swig_module.types[i]->cast;
                while (equiv) {
                    if (!equiv->converter) {
                        if (equiv->type && !equiv->type->clientdata)
                        SWIG_TypeClientData(equiv->type, swig_module.types[i]->clientdata);
                    }
                    equiv = equiv->next;
                }
            }
        }
    }
    
#ifdef __cplusplus
}
#endif



#ifdef __cplusplus
extern "C" {
#endif
    
    /* Python-specific SWIG API */
#define SWIG_newvarlink()                             SWIG_Python_newvarlink()
#define SWIG_addvarlink(p, name, get_attr, set_attr)  SWIG_Python_addvarlink(p, name, get_attr, set_attr)
#define SWIG_InstallConstants(d, constants)           SWIG_Python_InstallConstants(d, constants)
    
    /* -----------------------------------------------------------------------------
     * global variable support code.
     * ----------------------------------------------------------------------------- */
    
    typedef struct swig_globalvar {
        char       *name;                  /* Name of global variable */
        PyObject *(*get_attr)(void);       /* Return the current value */
        int       (*set_attr)(PyObject *); /* Set the value */
        struct swig_globalvar *next;
    } swig_globalvar;
    
    typedef struct swig_varlinkobject {
        PyObject_HEAD
        swig_globalvar *vars;
    } swig_varlinkobject;
    
    SWIGINTERN PyObject *
    swig_varlink_repr(swig_varlinkobject *v) {
        v = v;
        return PyString_FromString("<Swig global variables>");
    }
    
    SWIGINTERN int
    swig_varlink_print(swig_varlinkobject *v, FILE *fp, int flags) {
        swig_globalvar  *var;
        flags = flags;
        fprintf(fp,"Swig global variables { ");
        for (var = v->vars; var; var=var->next) {
            fprintf(fp,"%s", var->name);
            if (var->next) fprintf(fp,", ");
        }
        fprintf(fp," }\n");
        return 0;
    }
    
    SWIGINTERN PyObject *
    swig_varlink_getattr(swig_varlinkobject *v, char *n) {
        swig_globalvar *var = v->vars;
        while (var) {
            if (strcmp(var->name,n) == 0) {
                return (*var->get_attr)();
            }
            var = var->next;
        }
        PyErr_SetString(PyExc_NameError,"Unknown C global variable");
        return NULL;
    }
    
    SWIGINTERN int
    swig_varlink_setattr(swig_varlinkobject *v, char *n, PyObject *p) {
        swig_globalvar *var = v->vars;
        while (var) {
            if (strcmp(var->name,n) == 0) {
                return (*var->set_attr)(p);
            }
            var = var->next;
        }
        PyErr_SetString(PyExc_NameError,"Unknown C global variable");
        return 1;
    }
    
    SWIGINTERN PyTypeObject*
    swig_varlink_type(void) {
        static char varlink__doc__[] = "Swig var link object";
        static PyTypeObject varlink_type
#if !defined(__cplusplus)
        ;
        static int type_init = 0;  
        if (!type_init) {
            PyTypeObject tmp
#endif
            = {
                PyObject_HEAD_INIT(&PyType_Type)
                0,                                  /* Number of items in variable part (ob_size) */
                (char *)"swigvarlink",              /* Type name (tp_name) */
                sizeof(swig_varlinkobject),         /* Basic size (tp_basicsize) */
                0,                                  /* Itemsize (tp_itemsize) */
                0,                                  /* Deallocator (tp_dealloc) */ 
                (printfunc) swig_varlink_print,     /* Print (tp_print) */
                (getattrfunc) swig_varlink_getattr, /* get attr (tp_getattr) */
                (setattrfunc) swig_varlink_setattr, /* Set attr (tp_setattr) */
                0,                                  /* tp_compare */
                (reprfunc) swig_varlink_repr,       /* tp_repr */
                0,                                  /* tp_as_number */
                0,                                  /* tp_as_sequence */
                0,                                  /* tp_as_mapping */
                0,                                  /* tp_hash */
                0,                                  /* tp_call */
                0,                                  /* tp_str */
                0,                                  /* tp_getattro */
                0,                                  /* tp_setattro */
                0,                                  /* tp_as_buffer */
                0,                                  /* tp_flags */
                varlink__doc__,                     /* tp_doc */
#if PY_VERSION_HEX >= 0x02000000
                0,                                  /* tp_traverse */
                0,                                  /* tp_clear */
#endif
#if PY_VERSION_HEX >= 0x02010000
                0,                                  /* tp_richcompare */
                0,                                  /* tp_weaklistoffset */
#endif
#if PY_VERSION_HEX >= 0x02020000
                0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0, /* tp_iter -> tp_weaklist */
#endif
#if PY_VERSION_HEX >= 0x02030000
                0,                                  /* tp_del */
#endif
#ifdef COUNT_ALLOCS
                0,0,0,0                             /* tp_alloc -> tp_next */
#endif
            };
#if !defined(__cplusplus)
            varlink_type = tmp;
            type_init = 1;
        }
#endif
        return &varlink_type;
    }
    
    /* Create a variable linking object for use later */
    SWIGINTERN PyObject *
    SWIG_Python_newvarlink(void) {
        swig_varlinkobject *result = PyObject_NEW(swig_varlinkobject, swig_varlink_type());
        if (result) {
            result->vars = 0;
        }
        return ((PyObject*) result);
    }
    
    SWIGINTERN void 
    SWIG_Python_addvarlink(PyObject *p, char *name, PyObject *(*get_attr)(void), int (*set_attr)(PyObject *p)) {
        swig_varlinkobject *v = (swig_varlinkobject *) p;
        swig_globalvar *gv = (swig_globalvar *) malloc(sizeof(swig_globalvar));
        if (gv) {
            size_t size = strlen(name)+1;
            gv->name = (char *)malloc(size);
            if (gv->name) {
                strncpy(gv->name,name,size);
                gv->get_attr = get_attr;
                gv->set_attr = set_attr;
                gv->next = v->vars;
            }
        }
        v->vars = gv;
    }
    
    /* -----------------------------------------------------------------------------
     * constants/methods manipulation
     * ----------------------------------------------------------------------------- */
    
    /* Install Constants */
    SWIGINTERN void
    SWIG_Python_InstallConstants(PyObject *d, swig_const_info constants[]) {
        PyObject *obj = 0;
        size_t i;
        for (i = 0; constants[i].type; ++i) {
            switch(constants[i].type) {
                case SWIG_PY_INT:
                obj = PyInt_FromLong(constants[i].lvalue);
                break;
                case SWIG_PY_FLOAT:
                obj = PyFloat_FromDouble(constants[i].dvalue);
                break;
                case SWIG_PY_STRING:
                if (constants[i].pvalue) {
                    obj = PyString_FromString((char *) constants[i].pvalue);
                } else {
                    Py_INCREF(Py_None);
                    obj = Py_None;
                }
                break;
                case SWIG_PY_POINTER:
                obj = SWIG_NewPointerObj(constants[i].pvalue, *(constants[i]).ptype,0);
                break;
                case SWIG_PY_BINARY:
                obj = SWIG_NewPackedObj(constants[i].pvalue, constants[i].lvalue, *(constants[i].ptype));
                break;
                default:
                obj = 0;
                break;
            }
            if (obj) {
                PyDict_SetItemString(d,constants[i].name,obj);
                Py_DECREF(obj);
            }
        }
    }
    
    /* -----------------------------------------------------------------------------*/
    /* Fix SwigMethods to carry the callback ptrs when needed */
    /* -----------------------------------------------------------------------------*/
    
    SWIGINTERN void
    SWIG_Python_FixMethods(PyMethodDef *methods,
    swig_const_info *const_table,
    swig_type_info **types,
    swig_type_info **types_initial) {
        size_t i;
        for (i = 0; methods[i].ml_name; ++i) {
            char *c = methods[i].ml_doc;
            if (c && (c = strstr(c, "swig_ptr: "))) {
                int j;
                swig_const_info *ci = 0;
                char *name = c + 10;
                for (j = 0; const_table[j].type; ++j) {
                    if (strncmp(const_table[j].name, name, 
                    strlen(const_table[j].name)) == 0) {
                        ci = &(const_table[j]);
                        break;
                    }
                }
                if (ci) {
                    size_t shift = (ci->ptype) - types;
                    swig_type_info *ty = types_initial[shift];
                    size_t ldoc = (c - methods[i].ml_doc);
                    size_t lptr = strlen(ty->name)+2*sizeof(void*)+2;
                    char *ndoc = (char*)malloc(ldoc + lptr + 10);
                    if (ndoc) {
                        char *buff = ndoc;
                        void *ptr = (ci->type == SWIG_PY_POINTER) ? ci->pvalue : 0;
                        if (ptr) {
                            strncpy(buff, methods[i].ml_doc, ldoc);
                            buff += ldoc;
                            strncpy(buff, "swig_ptr: ", 10);
                            buff += 10;
                            SWIG_PackVoidPtr(buff, ptr, ty->name, lptr);
                            methods[i].ml_doc = ndoc;
                        }
                    }
                }
            }
        }
    }
    
    /* -----------------------------------------------------------------------------*
     *  Initialize type list
     * -----------------------------------------------------------------------------*/
    
#if PY_MAJOR_VERSION < 2
    /* PyModule_AddObject function was introduced in Python 2.0.  The following function
    is copied out of Python/modsupport.c in python version 2.3.4 */
    SWIGINTERN int
    PyModule_AddObject(PyObject *m, char *name, PyObject *o)
    {
        PyObject *dict;
        if (!PyModule_Check(m)) {
            PyErr_SetString(PyExc_TypeError,
            "PyModule_AddObject() needs module as first arg");
            return -1;
        }
        if (!o) {
            PyErr_SetString(PyExc_TypeError,
            "PyModule_AddObject() needs non-NULL value");
            return -1;
        }
        
        dict = PyModule_GetDict(m);
        if (dict == NULL) {
            /* Internal error -- modules must have a dict! */
            PyErr_Format(PyExc_SystemError, "module '%s' has no __dict__",
            PyModule_GetName(m));
            return -1;
        }
        if (PyDict_SetItemString(dict, name, o))
        return -1;
        Py_DECREF(o);
        return 0;
    }
#endif
    
#ifdef __cplusplus
}
#endif

/* -----------------------------------------------------------------------------*
 *  Partial Init method
 * -----------------------------------------------------------------------------*/

#ifdef __cplusplus
extern "C"
#endif
SWIGEXPORT void SWIG_init(void) {
    static PyObject *SWIG_globals = 0; 
    PyObject *m, *d;
    if (!SWIG_globals) SWIG_globals = SWIG_newvarlink();
    
    /* Fix SwigMethods to carry the callback ptrs when needed */
    SWIG_Python_FixMethods(SwigMethods, swig_const_table, swig_types, swig_type_initial);
    
    m = Py_InitModule((char *) SWIG_name, SwigMethods);
    d = PyModule_GetDict(m);
    
    SWIG_InitializeModule(0);
    SWIG_InstallConstants(d,swig_const_table);
    
    {
        PyDict_SetItemString(d,"svn_txdelta_source", SWIG_From_long((int)(svn_txdelta_source))); 
    }
    {
        PyDict_SetItemString(d,"svn_txdelta_target", SWIG_From_long((int)(svn_txdelta_target))); 
    }
    {
        PyDict_SetItemString(d,"svn_txdelta_new", SWIG_From_long((int)(svn_txdelta_new))); 
    }
}

