.SH REPORTING BUGS
Report bugs, including
.I doveconf \-n
output, to the Dovecot Mailing List <dovecot@dovecot.org>.
Information about reporting Dovecot and Pigeonhole bugs is available at:
http://dovecot.org/bugreport.html
