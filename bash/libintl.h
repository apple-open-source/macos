libgnuintl.h