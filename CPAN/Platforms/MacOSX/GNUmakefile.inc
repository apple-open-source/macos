DEFAULT := $(shell sed -n '/^DEFAULT = /s///p' $(PERLVERSIONS))
KNOWNVERSIONS := $(shell grep -v '^DEFAULT' $(PERLVERSIONS))
BOOTSTRAPPERL = 5.34

MY_ARCHS := $(or $(RC_ARCHS),$(MY_HOST))

EXTRAMERGE := mergeoss mergeman
EXTRAVERSIONERFLAGS = -DFORCE_TWO_NUMBER_VERSIONS
