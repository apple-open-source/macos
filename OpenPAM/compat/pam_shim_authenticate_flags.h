xlate(PAM_SILENT, 0x8000U, PAM_SILENT, 0x7fffffff - 1) 
xlate(PAM_DISALLOW_NULL_AUTHTOK, 0x0001U, PAM_DISALLOW_NULL_AUTHTOK, 0x1)
