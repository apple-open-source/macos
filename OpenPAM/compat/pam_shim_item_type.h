xlate(PAM_SERVICE, 1, PAM_SERVICE, 1)
xlate(PAM_USER, 2, PAM_USER, 2)
xlate(PAM_USER_PROMPT, 9, PAM_USER_PROMPT, 9)
xlate(PAM_TTY, 3, PAM_TTY, 3)
xlate(PAM_RUSER, 8, PAM_RUSER, 8)
xlate(PAM_RHOST, 4, PAM_RHOST, 4)
xlate(PAM_AUTHTOK, 6, PAM_AUTHTOK, 6)
xlate(PAM_CONV, 5, PAM_CONV, 5)
///xlate(PAM_FAIL_DELAY, 10, PAM_FAIL_DELAY, 99999)
