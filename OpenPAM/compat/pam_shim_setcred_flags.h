xlate(PAM_ESTABLISH_CRED, 0x0002U, PAM_ESTABLISH_CRED, 0x1)
xlate(PAM_DELETE_CRED, 0x0004U, PAM_DELETE_CRED, 0x2)
xlate(PAM_REINITIALIZE_CRED, 0x0008U, PAM_REINITIALIZE_CRED, 0x4)
xlate(PAM_REFRESH_CRED, 0x0010U, PAM_REFRESH_CRED, 0x8)
