xlate(PAM_SILENT, 0x8000U, PAM_SILENT, 0x7fffffff - 1) 
xlate(PAM_CHANGE_EXPIRED_AUTHTOK, 0x0020U, PAM_CHANGE_EXPIRED_AUTHTOK, 0x4)
